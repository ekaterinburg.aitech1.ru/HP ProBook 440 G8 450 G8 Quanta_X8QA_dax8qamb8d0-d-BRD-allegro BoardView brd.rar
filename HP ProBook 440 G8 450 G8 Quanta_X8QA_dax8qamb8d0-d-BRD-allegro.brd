# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBUS_P:
  vias: v1(191.95,90.47) v2(190.22,89.24) v2(190.76,89.24) v2(191.31,89.24)
VCC1_RST#: length 15.8
  TOP w0.14: U4700.K6 v2(198.04,17.64)
  IN2 w0.089: v2(205.28,15.67) 205.47,15.67 207.22,17.42 v2(207.22,18.27)
  BOTTOM w0.109: v2(205.28,15.67) 204.98,15.97 203.66,15.97 202.93,16.7 v1(202.93,16.96) 202.93,17.66 202.16,18.44 201.6,18.44 201.27,18.77 200.48,18.77 199.35,17.64 v2(198.04,17.64) ; v2(207.22,18.27) 207.26,18.31 R4813.1 207.52,19 207.54,19.02 R4804.1 207.9,18.69 208,18.59 R7719.1
VCC1_RST#_R1: length 2.7
  BOTTOM w0.109: CON7702.16 210.2,17.72 210,17.92 209.07,17.92 208.83,18.16 R7719.2
VCC3V3_FLASH: length 44.5
  TOP w0.254: C1911.2 191.18,57.48 191.71,56.95 v1(191.83,56.95) 191.92,56.86 U1905.D2 U1905.D1
  IN1 w0.254: v1(191.83,56.95) 190.76,58.03 190.76,58.64 189.91,59.48 189,59.48 v1(188.31,60.17)
  IN2 w0.254: v2(187.42,90.57) 187.6,90.14 187.6,88.57 187.07,88.03 186.81,88.03 186.36,87.58 186.36,86.87 184.4,84.91 183.34,84.91 182.32,83.89 182.32,82.4 182.98,81.73 182.98,79.8 185.85,76.93 185.85,74.55 186.26,74.14 186.26,71.8 187.32,70.74 187.32,69.03 186.64,68.35 186.64,67.28 186.89,67.03 186.89,66.14 185.21,64.46 185.21,60.22 v1(185.34,60.09)
  BOTTOM w0.203: v2(187.42,90.57) 187.77,90.92 R5938.1
VCC_AUX_SENSE: length 10.9
  IN2 w0.203: v2(116.09,82.73) 116.54,83.18 116.54,85.51 115.02,87.03 115.02,89.01 114.53,89.51 113.69,89.51 113.41,89.23 113.41,88.68 v2(113.42,88.67)
  BOTTOM w0.203: v2(113.42,88.67) 113.41,88.68 113.41,89.31 PR9124.1 ; U400.AT9 116.43,82.39 v2(116.09,82.73)
VCCA_CLKLDO_1V8: length 27.8
  IN1 w0.254: v2(155.8,78.51) 155.57,78.28 155.57,78.08 154.94,77.44 153.41,77.44 153.33,77.35 151.8,77.35 150.76,78.39 150.25,78.39 149.8,78.84 147.4,78.84 147.06,79.18 146.99,79.22 146.82,79.3 146.48,79.3 146.07,78.88 v2(146.01,78.88) 146.01,78.8 145.59,78.38 143.43,78.38 142.95,78.86 139.95,78.86 139.62,79.19 138.94,79.19 138.34,79.79 138.34,79.84 138.1,80.08 138,80.08 137.63,80.45 v2(137.63,80.52)
  BOTTOM w0.203: U400.DV16 144.66,79.27 145.67,79.27 146.01,78.93 v2(146.01,78.88)
  BOTTOM w0.254: v2(137.63,80.52) 137.62,80.51 U400.DC15 ; R1601.1 154.92,81.19 C1646.2 154.96,80.46 v1(154.96,79.53) 154.96,79.04 155.49,78.51 v2(155.8,78.51)
VCCAUX_VID: length 16.4
  TOP w0.109: v2(142.96,100.1) 142.96,99.63 143.2,99.39 144.12,99.39 145.29,100.56 PD9602.3 145.53,101.13 145.31,101.34 145.31,102.16 145.58,102.42 PU10604.4 146.69,102.42 147.34,103.07 PU9601.2
  IN2 w0.089: v1(145.85,96.44) 145.85,96.74 142.96,99.63 v2(142.96,100.1)
  BOTTOM w0.109: PU9600.1 145.78,93.87 146.24,94.32 146.24,96.05 v1(145.85,96.44)
VCCAUX_VID0: length 79.9
  TOP w0.109: v2(135.63,71.3) 136.22,70.71 R1605.1 ; PR9100.1 122.28,104.98 v1(122.04,104.98) 121.89,104.98 PR9102.2 ; v1(129.18,104.06) 129.97,103.27 132.46,103.27 132.62,103.44 134.15,103.44 134.54,103.05 134.54,102.21 134.87,101.88 v1(137.41,101.88) 141.68,101.88 142.87,103.07 PU10604.2 144.22,103.07 144.78,102.51 144.78,101.64 144.35,101.21 PD9602.2
  IN2 w0.089: v1(122.04,104.98) 123,104.98 123.91,104.06 v1(129.18,104.06) 129.23,104.11 132.24,104.11 132.44,103.91 132.44,101.5 133.32,100.62 133.32,99.28 134.97,97.64 134.97,96.47 136.48,94.96 136.48,93.02 137.58,91.92 138.16,91.92 138.55,91.53 141.49,91.53 141.81,91.21 141.81,90.32 140.1,88.61 140.1,87.22 137.66,84.78 137.22,84.78 136.65,84.21 136.65,82.6 136.93,82.31 137.05,82.31 137.29,82.27 137.47,82.08 137.47,81.48 136.65,80.66 136.65,78.94 135.61,77.9 135.61,73.2 135.99,72.82 135.99,72.57 135.92,72.49 135.72,72.36 135.63,72.18 v2(135.63,71.3)
  BOTTOM w0.109: v1(122.04,104.98) 120.25,106.77 119.03,106.77 PR9106.1
VCCAUX_VID0_R: length 2.4
  TOP w0.109: R1605.2 136.22,69.85 v2(136.32,69.75) 136.37,69.7 R1611.2
  BOTTOM w0.109: v2(136.32,69.75) 136.32,69.95 136.58,70.21 U400.DB37
VCCAUX_VID1: length 135.4
  TOP w0.109: PR9101.1 122.21,106.57 v1(121.92,106.57) 121.86,106.57 PR9103.2 ; v2(137.75,69.85) 137.36,69.46 R1607.1 ; v1(135.38,102.31) 135.74,102.66 v1(136.17,102.66) 141.81,102.66 142.86,103.72 PU10604.1 144.23,103.72 144.65,103.3 144.65,102.97 145.06,102.56 145.06,101.42 144.83,101.19 144.83,100.76 143.98,99.91 PD9602.1
  IN2 w0.089: v2(139.5,61.7) 139.5,61.73 139.11,62.12 139.11,64.24 138.67,64.67 138.67,65.49 138.28,65.89 138.28,67.33 138.14,67.47 138.14,68.31 138.28,68.46 138.28,69.31 v2(137.75,69.85) ; v1(161.21,57.91) 161.59,58.29 161.59,59.71 160.47,60.83 160.47,64 159.87,64.6 159.87,66.19 158.34,67.71 158.34,68.54 158.74,68.94 158.74,70.62 158.68,70.68 158.68,71.75 159.38,72.44 159.38,76.02 159.16,76.25 159.16,80.79 156.96,82.99 156.96,84.1 155.9,85.16 151.47,85.16 149.74,86.88 149.74,91.93 146.55,95.13 145.21,95.13 144.27,96.08 144.27,96.6 142.57,98.3 138.66,98.3 137.89,99.06 137.54,99.06 136.74,99.86 136.74,100.31 135.38,101.67 v1(135.38,102.31) 135.18,102.31 132.66,104.83 129.79,104.83 128.57,106.04 127.2,106.04 127.1,106.14 124.1,106.14 123.85,106.4 122.09,106.4 v1(121.92,106.57)
  IN3 w0.089: v1(161.21,57.91) 160.27,56.97 158.73,56.97 158.45,57.25 156.2,57.25 154.57,55.62 150.99,55.62 148.22,58.4 148.22,61.82 147.57,62.47 143.55,62.47 142.87,61.8 142.54,61.8 141.93,62.41 140.2,62.41 v2(139.5,61.7)
  BOTTOM w0.109: v1(121.92,106.57) 121.49,107 119.31,107 119.02,107.29 119.02,107.31 118.66,107.67 PR9105.1
VCCAUX_VID1_R: length 2
  TOP w0.109: R1612.2 136.44,68.78 136.9,69.24 R1607.2 136.91,69.51 136.9,69.52 v2(136.9,69.8)
  BOTTOM w0.109: v2(136.9,69.8) 137.12,69.8 U400.DB38
VCCDSW_3P3: length 16.8
  IN3 w0.381: 144.13,68.65 145.2,67.57 147.7,67.57 147.95,67.32 147.95,65.98 148.85,65.08 149.74,65.08 150.67,65.47 151.74,65.47 151.99,65.37 152.18,65.17 152.29,64.92 152.29,64.25 153.19,63.35 156.45,63.35 v1(156.66,63.14)
  BOTTOM w0.305: v2(137.87,70.46) 138.12,70.21 U400.DD37
  vias: v1(155.37,65.28)
VCCIN_V1N: length 12.8
  TOP w0.203: v1(90.05,100.19) PR8812.1 PR8819.1
  IN3 w0.203: v1(98.37,100.38) 97.91,99.91 93.3,99.91 91.78,101.43 90.79,101.43 90.04,100.69 90.04,100.2 v1(90.05,100.19)
  BOTTOM w0.203: v1(98.37,100.38) 98.37,99.64 98.62,99.39 PR8906.1
VCCIN_V1P: length 11.3
  TOP w0.203: v1(92.26,102.51) 92.26,102.6 PR8807.2 91,103.05 PR8808.1
  IN3 w0.203: v1(97.72,100.37) 97.57,100.23 93.42,100.23 92.26,101.38 v1(92.26,102.51)
  BOTTOM w0.203: v1(97.72,100.37) 97.72,99.59 97.58,99.46 PR8905.1
VCCIN_V2N: length 24.3
  TOP w0.203: PR8821.1 90.26,105.99 v1(90.21,106.04) PR8806.1
  IN3 w0.203: v1(106.99,100.46) 106.85,100.32 103.21,100.32 102.42,101.12 95.04,101.12 92.68,103.48 92.68,105.58 91.77,106.5 90.67,106.5 v1(90.21,106.04)
  BOTTOM w0.203: v1(106.99,100.46) 107.14,100.32 107.14,99.77 106.85,99.49 PR8913.1
VCCIN_V2P: length 20.8
  TOP w0.203: v1(92.94,102.49) 92.94,102.03 92.68,101.77 v1(92.58,101.77) PR8815.2 91.3,101.77 91.21,101.87 PR8816.1
  IN3 w0.203: v1(107.65,100.47) 107.2,100.02 103.1,100.02 102.3,100.82 94.6,100.82 v1(92.94,102.49)
  BOTTOM w0.203: v1(107.65,100.47) 107.47,100.28 107.47,99.87 107.84,99.49 PR8912.1
VCCSENSE: length 1.6
  TOP w0.254: PR8843.1 107.48,69.42 v2(107.66,69.24)
  BOTTOM w0.203: U400.R38 107.34,69.56 v2(107.66,69.24)
VCCST_EN_OR: length 27.8
  TOP w0.109: v1(144.42,89.13) 144.42,89.43 143.53,90.32 v1(143.33,90.32) 142.77,90.32 PR9600.2 ; v1(135.43,98.37) 135.19,98.13 PR10612.2
  IN2 w0.089: v1(135.43,98.37) 135.43,97.89 135.69,97.63 135.69,96.52 136.66,95.55 136.66,93.1 137.65,92.1 138.23,92.1 138.62,91.71 141.56,91.71 141.99,91.29 141.99,90.46 143.33,89.13 v1(144.42,89.13)
  BOTTOM w0.109: PU9600.4 144.48,96.3 PR9603.2 144.13,96.43 144.13,92.04 144.6,91.56 144.6,90.83 144.42,90.66 v1(144.42,89.13)
VCCST_OVERRIDE: length 51.5
  TOP w0.109: v1(161.67,78.08) 161.64,78.1 160.08,78.1 157.22,75.25 v1(157.22,74.88) 157.22,74.78 156.29,73.84 155.25,73.84 154.89,73.48 154.89,73.47 v2(154.85,73.43) 154.51,73.09 R1523.2
  IN3 w0.089: v2(124.33,82.72) 125.25,81.8 125.25,80.69 126.87,79.07 128.98,79.07 129.56,78.48 129.56,77.59 132.46,74.7 134.26,74.7 135.48,73.48 138.15,73.48 138.22,73.56 141.58,73.56 141.63,73.61 144.04,73.61 144.07,73.58 146.64,73.58 147.19,74.14 149.56,74.14 150.72,72.98 151.71,72.98 151.88,72.81 153.92,72.81 154.54,73.43 v2(154.85,73.43)
  BOTTOM w0.109: PR10621.1 158.75,76.25 159.41,76.91 160.6,76.91 160.86,76.65 161.19,76.65 161.67,77.14 v1(161.67,78.08) ; v2(124.33,82.72) 124.66,82.39 U400.BP9
VCCST_OVRD: length 45
  TOP w0.109: PU10603.4 162.64,88.45 162.91,88.18 162.91,86.7 162.41,86.2 162.12,86.2 v1(161.83,85.91) 161.67,85.75 161.67,85.46 161.2,84.99 161.2,84.1 160.49,83.39 159.84,83.39 159.36,82.9 158.18,82.9 156.41,84.68 155.56,84.68 154.97,84.09 v1(154.88,84.09) ; PD9601.3 138.78,92.66 139.11,92.33 139.11,91.72 139.39,91.44 140.64,91.44 140.82,91.26 140.82,90.65 141.02,90.45 141.45,90.45 141.53,90.53 PR9601.2 141.9,90.53 143.84,88.59 144.6,88.59 145.03,89.02 v1(145.03,91.16)
  IN2 w0.089: v1(145.03,91.16) 145.03,91.67 146.02,92.65 148.24,92.65 149.2,91.7 149.2,86.67 151.54,84.33 154.64,84.33 v1(154.88,84.09)
  BOTTOM w0.109: v1(145.03,91.16) 145.04,91.16 145.04,92.56 145.13,92.66 PU9600.2
VCCST_OVRD_R1: length 51.3
  TOP w0.109: PU10602.4 143.45,98.34 142.96,97.85 141.44,97.85 141.04,97.46 140.74,97.46 139.88,96.59 139.88,95.76 139.32,95.2 138.99,95.2 138.76,94.97 138.76,94.32 v2(138.97,94.1) 138.95,94.1 138.61,93.76 138.61,93.32 139,92.93 139.16,92.93 139.74,92.35 PD9601.2 140.31,92.58 PD9600.3 141.39,92.58 141.83,92.14 PR9601.1 PR9600.1 ; PU10603.2 163.68,87.8 163.14,87.25 163.14,86.6 162.99,86.45 162.99,86.15 162.7,85.86 162.4,85.86 161.43,84.9 161.43,84 160.51,83.08 160.22,83.08 v1(160.06,82.92) 159.81,82.67 158.09,82.67 156.64,84.12 v1(156.28,84.12)
  IN2 w0.089: v1(156.28,84.12) 155.71,84.68 151.69,84.68 149.57,86.81 149.57,91.86 148.38,93.04 140.06,93.04 138.99,94.1 v2(138.97,94.1)
VCCST_OVRD_R2: length 67.6
  TOP w0.109: PD9601.1 140,93.04 141.98,93.04 142.36,92.66 143.3,92.66 143.76,93.11 PR9606.1 144.16,93.11 144.62,93.56 PQ9601.3 ; PD9601.1 139.22,93.31 v2(138.97,93.55) ; PD9601.1 139.74,93.53 139.44,93.83 139.44,94.62 PD9604.2 ; v1(126.77,105.51) 126.64,105.38 126.12,105.16 125.7,104.75 PU10606.2 ; v1(155.59,84.08) 155.99,83.69 156.75,83.69 157.99,82.45 160.2,82.45 161.66,83.91 161.66,84.79 162.49,85.62 163.02,85.62 163.42,86.03 v1(163.42,86.21) 163.42,86.97 163.6,87.15 PU10603.1
  IN2 w0.089: v1(155.59,84.08) 155.17,84.51 151.62,84.51 149.38,86.74 149.38,91.77 148.32,92.83 139.82,92.83 139.48,93.17 139.36,93.17 v2(138.97,93.55) 138.61,93.19 138.07,93.19 137.75,93.51 137.75,95.97 136.77,96.96 136.77,98.84 135.83,99.78 134.74,99.78 134.44,100.07 134.44,100.53 134.77,100.86 134.77,102.16 132.46,104.47 129.64,104.47 128.61,105.51 v1(126.77,105.51)
VCCST_PWRGD_TCSS: length 39.8
  IN3 w0.089: v2(129.83,84.04) 129.35,83.56 129.35,79.49 129.97,78.87 129.97,77.85 132.71,75.11 134.43,75.11 135.16,74.37 136.14,74.37 136.39,74.62 137.93,74.62 138.31,74.24 138.81,74.24 139.17,74.61 145.19,74.61 145.28,74.52 145.9,74.52 146.02,74.65 146.99,74.65 147.11,74.52 149.68,74.52 150.68,73.52 v2(150.99,73.52) 151.68,73.52 152.02,73.17 153.77,73.17 154.57,73.97 155.95,73.97 v2(156.49,73.43)
  BOTTOM w0.109: R1524.2 150.9,73.43 v2(150.99,73.52) ; PR10622.1 156.99,74.16 v1(156.99,73.75) 156.67,73.43 v2(156.49,73.43) ; U400.CE5 129.83,84.05 129.83,84.04 v2(129.83,84.04)
VCCSTG_EN_OR: length 41
  TOP w0.109: v1(149.47,101.69) 149.52,101.69 149.53,101.67 PR9611.2 150.09,102.28 149.95,102.42 PU9601.4 ; PR9613.2 139.72,98.98 139.53,99.18 v1(139.01,99.18) ; PR10614.1 135.15,94.36 135.57,93.94 v2(135.57,93.67)
  IN1 w0.079: v1(131.7,100.22) 132.19,100.71 133.84,100.71 134.19,101.05 134.19,102.8 135.13,103.74 142.9,103.74 145.35,101.29 149.07,101.29 v1(149.47,101.69)
  IN2 w0.089: v1(131.7,100.22) 131.93,99.99 131.93,99.33 133.95,97.31 133.95,96.37 135.57,94.75 v2(135.57,93.67)
  BOTTOM w0.109: v1(139.01,99.18) 138.69,98.85 137.18,98.85 v1(137.02,98.69) 136.73,98.4 136.73,95.2 135.57,94.04 v2(135.57,93.67)
VCCSTG_OVRD: length 34.7
  TOP w0.203: PU9601.1 148.12,103.72 148.5,103.34 148.5,102.02 148.37,101.88 148.37,100.64 147.62,99.9 146.89,99.9 146.75,100.04 145.25,100.04 144.22,99.01 143.13,99.01 142.97,99.16 142.01,99.16 141.51,99.65 140.17,99.65 140.16,99.64 138.66,99.64 v1(138.4,99.39)
  TOP w0.254: v1(125.3,107.64) 125.75,107.64 126.35,107.04 PU10606.4
  IN3 w0.508: v1(138.4,99.39) 138.12,99.11 135.34,99.11 134.32,100.13 134.32,102.22 132.18,104.37 131.37,104.37 128.78,106.96 126.9,106.96 126.21,107.64 v1(125.3,107.64)
  vias: v1(138.61,98.19)
VCCSTG_OVRD_R1: length 64.2
  TOP w0.109: v1(125.88,105.51) 125.8,105.51 125.05,104.76 PU10606.1 ; v2(138.38,94.1) 138.38,94.92 138.89,95.43 138.89,95.58 139.33,96.02 PD9604.1 139.34,96.46 139.82,96.94 PR9612.1 139.82,97.68 140,97.86 140.55,97.86 PD9603.3 140.55,98.27 PR9613.1 ; v1(146.62,93.79) 147.15,93.79 147.33,93.97 154.93,93.97 158.35,90.55 158.35,88.46 159.01,87.8 159.01,87.17 157.86,86.02 v1(157.86,85.67) 157.86,84.55 158.32,84.1 159.27,84.1 159.53,84.35 PU10605.4
  IN2 w0.089: v1(146.62,93.79) 145.36,93.79 144.75,94.4 144.75,95.35 144.07,96.02 144.07,96.54 142.79,97.82 140.75,97.82 138.89,95.96 138.89,94.82 138.38,94.31 ; 138.38,94.31 138.28,94.4 138.28,98.31 137.72,98.88 136.98,98.88 135.91,99.96 135.5,99.96 135.35,100.1 135.35,100.79 134.97,101.17 134.97,102.21 132.53,104.65 129.72,104.65 128.5,105.87 127.13,105.87 127.08,105.92 126.29,105.92 v1(125.88,105.51) ; 138.38,94.31 v2(138.38,94.1)
VDD_SIM: length 2
  TOP w0.109: v2(147.61,7.74) 147.6,7.76 R4415.1 R4414.2
  BOTTOM w0.109: v2(147.61,7.74) 147.49,7.86 CON4402.10
VINSEN_NVVDD: length 26.7
  TOP w0.203: PR9900.1 60.09,100.33 59.74,99.97 55.6,99.97 54.9,99.27 53.48,99.27 53.21,99.01 36.83,99.01 v1(36.78,99.06) 35.69,99.06 PR9806.2
VSS_AUX_SENSE: length 12
  IN2 w0.203: v2(112.88,88.67) 113,88.8 113,89.23 113.57,89.8 114.65,89.8 115.34,89.11 115.34,87.13 116.86,85.6 116.86,82.77 v2(116.94,82.69)
  BOTTOM w0.203: v2(112.88,88.67) 112.62,88.92 PR9125.1 ; U400.AV9 117.24,82.39 v2(116.94,82.69)
VSSSENSE: length 2.7
  TOP w0.254: v2(107.66,69.88) 107.28,70.25 107.01,70.25 v1(106.91,70.35) 106.75,70.5 PR8844.1
  BOTTOM w0.203: U400.R37 107.32,70.21 v2(107.66,69.88)
27M_XTAL_IN: length 10.2
  BOTTOM w0.102: 72.62,92.33 72.62,91.55 C6806.2 71.94,90.87
  BOTTOM w0.109: U6600.C11 70.73,86.81 70.73,87.46 70.59,87.6 70.59,89.82 71.64,90.87 71.94,90.87 ; 72.62,92.33 72.89,92.6 72.89,93.78 Y6800.3
27M_XTAL_OUT: length 8.3
  BOTTOM w0.102: C6807.2 73,91.64 73,92.07 v1(73.02,92.1) 73.31,92.38 73.35,92.38 73.63,92.66
  BOTTOM w0.109: U6600.B10 71.16,87.41 70.8,87.76 70.8,89.73 71.73,90.66 72.72,90.66 C6807.2 ; Y6800.1 73.63,92.66
2260_BST_1.35V: length 2.5
  BOTTOM w0.254: PU10200.20 26.11,88.14 v1(26.11,88.14) 25.7,87.73 25.34,87.73 PR10203.2
2260_EN_1.35V: length 56.6
  TOP w0.254: v1(31.22,96.99) 31.14,97.08 29.23,97.08 26.92,94.77 v1(26.92,94.71) 26.92,92.45 v1(27.41,91.96) 27.41,91.56 PC10217.1 ; v1(27.3,60.3) 26.76,60.84 24.39,60.84 23.71,61.53 PQ10200.2
  IN2 w0.254: v1(27.3,60.3) 30.07,63.07 30.07,74.47 30.86,75.26 30.86,82.46 31.41,83.01 31.41,85.99 31.41,85.99 31.41,86.43 31.11,86.73 31.1,86.73 30.17,87.65 30.17,91.33 30.11,91.4 30.11,92.67 31.03,93.59 31.03,95.58 31.29,95.84 31.29,96.92 v1(31.22,96.99)
  BOTTOM w0.254: v1(27.41,91.96) 27.41,92.02 PR10208.1 28.01,91.31 28.09,91.24 28.09,90.67 28.25,90.5 PU10200.2
2260_FB_1.35V: length 3.6
  BOTTOM w0.254: PR10210.1 PR10211.1 30.35,92.63 30.09,92.37 30.09,91.64 29.75,91.3 PU10200.5
2260_FB_1.35V_S: length 18.1
  TOP w0.203: PR10209.2 v1(24.14,79.42)
  IN3 w0.254: v1(29.08,93.9) 27.91,92.73 27.91,90.12 24.33,86.54 24.33,85.34 24.1,85.11 24.1,79.47 v1(24.14,79.42)
  BOTTOM w0.254: v1(29.08,93.9) 29.61,93.37 PR10210.2
2260_PFM_1.35V: length 4.7
  TOP w0.254: PR10207.2 28.27,91.73 v1(28.51,91.97)
  BOTTOM w0.254: PU10200.3 28.75,90.52 28.49,90.79 28.49,91.15 28.86,91.53 v1(29.08,91.62) 29.06,91.64 29.06,92.61 PR10205.2 28.51,92.42 v1(28.51,91.97)
2260_PG_1.35V: length 2.8
  BOTTOM w0.254: PU10200.1 27.71,90.26 27.71,90.83 v1(27.23,91.3) 26.9,91.64 26.9,92.5 PR10204.1
2260_SS_1.35V: length 1.6
  BOTTOM w0.254: PC10218.2 26.65,90.23 26.65,89.89 26.9,89.64 PU10200.23
2260_TON_1.35V: length 2.8
  BOTTOM w0.254: PR10200.2 31.19,91.95 30.76,91.51 v1(30.76,91.16) 30.25,90.66 PU10200.6
2260_VCC_1.35V: length 3.7
  TOP w0.508: v1(25.68,88.8) 26.02,88.45 PR10201.2
  BOTTOM w0.254: v1(25.68,88.8) 26.08,89.2 PC10207.2 26.34,89.51 26.57,89.28 26.57,88.89 26.81,88.64 PU10200.21
8051_RX_CAPS_LED#: length 80.1
  TOP w0.076: v2(196.74,18.94) U4700.J7
  TOP w0.109: v1(172.73,56.33) 172.96,56.1 173.5,56.1 174.26,56.86 176.53,56.86 176.63,56.76 178,56.76 178.23,57 U4701.3 178.79,57.38 178.79,57.38 R4734.1 179.58,57.38 179.68,57.48 R4745.1
  IN1 w0.076: v2(196.74,18.94) 197.12,18.57 197.74,18.57 198.4,19.23 198.4,19.76 198.21,19.95
  IN1 w0.079: v1(176.51,46.37) 177.04,46.37 180.34,43.06 180.34,42.4 180.8,41.94 180.8,40.48 184.18,37.1 184.18,34.82 186.14,32.85 186.14,30.97 188.9,28.22 189.84,28.22 190.05,28 190.05,27.06 193.31,23.81 194.57,23.81 196.31,22.07 197.09,22.07 198.17,20.99 198.17,19.99 198.21,19.95
  IN2 w0.089: v1(172.73,56.33) 172.73,55.76 172.06,55.1 172.06,51.6 172.83,50.83 173.36,50.83 174.89,49.31 174.89,47.09 175.61,46.37 v1(176.51,46.37)
  BOTTOM w0.076: 199.77,21.05 199.59,20.88 197.23,20.88 196.37,20.01 196.37,19.32 v2(196.74,18.94)
  BOTTOM w0.109: CON7702.14 210.37,16.72 209.62,17.47 208.79,17.47 208.75,17.51 206.45,17.51 202.91,21.05 199.77,21.05
8051_TX_LED_PWRSTBY#: length 71.5
  TOP w0.076: U4700.H8 v2(196.74,19.59)
  TOP w0.109: v1(173.32,56.53) 173.32,56.71 v1(173.65,57.05) 173.74,57.13 R4737.1 175.46,57.13 R4746.1 175.84,57.38 U4701.1
  IN1 w0.076: 196.8,21.46 197.13,21.13 197.13,20.62 196.97,20.47 196.97,19.83 v2(196.74,19.59)
  IN1 w0.079: 196.8,21.46 195.48,21.46 194.71,22.23 194.71,22.58 193.81,23.48 193.19,23.48 185.79,30.88 185.79,32.7 183.86,34.63 183.86,36.97 180.43,40.4 180.43,41.38 176.53,45.29 v1(176.53,45.59)
  IN2 w0.089: v1(173.32,56.53) 173.32,56.03 172.24,54.95 172.24,51.76 172.99,51.01 173.44,51.01 175.34,49.11 175.34,48.38 176.9,46.82 176.9,45.75 176.74,45.59 v1(176.53,45.59)
  BOTTOM w0.076: 197.74,20.47 197.53,20.67 197.25,20.67 196.74,20.16 v2(196.74,19.59)
  BOTTOM w0.109: CON7702.13 210.36,16.22 210.13,16.45 210.13,16.63 209.52,17.24 208.7,17.24 208.66,17.28 206.27,17.28 203.24,20.31 202.08,20.31 201.88,20.11 200.12,20.11 200.02,20.01 198.19,20.01 197.74,20.47
8097_EN_2.5V: length 59.4
  TOP w0.508: v2(183.49,30.4) 183.49,30.8 v1(183.3,31) 182.38,31.92 178.81,31.92 176.97,30.08 174.65,30.08 173.58,31.14 168.9,31.14 165.58,34.47 165.58,40.3 165.46,40.43 165.46,40.83 165.73,41.1 165.73,43.88 166.47,44.63 166.47,46.68 166.9,47.11 166.9,49.25 167.27,49.61 PR8722.1 170.08,49.75 170.64,50.32 171.99,50.32 172.37,50.7 173.78,50.7
  BOTTOM w0.508: v2(183.49,30.4) 184.4,29.49 184.4,25.93 185.38,24.96 185.38,23.83 183.79,22.24 183.79,18.72 182.63,17.56 PU8701.1
8097_PG_2.5V: length 1.6
  BOTTOM w0.109: PR8716.1 178.35,17.17 178.92,16.61 PU8701.5
8097_VFB_2.5V: length 14
  TOP w0.254: v2(181.35,16.59) 181.35,16.54 v1(181.77,16.12) 182.05,15.84 184.96,15.84 186.35,17.22 v2(186.35,18.57)
  BOTTOM w0.254: PR8723.2 PR8725.2 188.89,18.01 188.89,18.02 PC8725.2 188.41,18.51 187.91,19.01 187.16,19.01 186.74,18.59 186.37,18.59 v2(186.35,18.57) ; PU8701.6 179.74,17.56 180.72,16.59 v2(181.35,16.59)
8097_VFB_2.5V_S: length 2.2
  BOTTOM w0.254: PR8721.2 187.39,17.2 188.03,17.2 188.07,17.24 PC8725.1 188.58,17.07 189.21,17.07 PR8723.1
8231_BT: length 3.9
  TOP w0.109: v1(99.62,11.17) 99.82,11.38 99.94,11.38 PR8705.2
  TOP w0.203: PR8705.2 101.32,11.52 PU8700.18
8231_BT_S: length 2
  TOP w0.254: PC8710.1 99.46,13.33 v1(99.24,13.1) 99.5,12.84 PR8705.1
8231_CS: length 1.3
  TOP w0.109: PU8700.13 104.33,13.63 104.39,13.69 PR8702.2
8231_LG:
  vias: v1(101.85,16.86) v3(100.73,17.6)
8231_PG: length 1.7
  TOP w0.178: 106.43,12.32 PU8700.10
  TOP w0.203: 106.43,12.32 106.58,12.32 106.61,12.35 106.95,12.35 PR8700.1
8231_PH:
  vias: v1(101.7,13.38) v1(101.88,15.64) v1(101.88,15.01)
8231_S3: length 2.5
  TOP w0.203: PR8703.2 PC8706.2 107.03,10.6 106.51,11.12 PU8700.7
8231_S5: length 2.5
  TOP w0.203: v1(106.86,11.5) 106.84,11.52 PU8700.8
  BOTTOM w0.203: v1(106.86,11.5) 106.88,11.5 107.32,11.07 PC8700.1 PR8701.2
8231_TON: length 1.6
  TOP w0.203: PR8704.1 106.75,12.04 106.64,11.92 PU8700.9
8231_UG: length 1.3
  TOP w0.203: v3(101.67,12.11) 101.85,11.92 PU8700.17
8231_VDDQ: length 8.2
  TOP w0.178: PU8700.5 105.13,9.54 105.32,9.36
  TOP w0.203: 105.32,9.36 PR8714.2 105.92,10.04 v1(105.81,10.15)
  BOTTOM w0.203: PR8711.1 110.2,12.27 110.05,12.11 109.74,11.99 106.63,11.99 106.27,11.63 106.27,10.61 v1(105.81,10.15)
8231_VID: length 1.4
  TOP w0.109: PR8712.1 105.38,13.99 105.13,13.74 PU8700.11
8231_VLDOIN: length 3.8
  TOP w0.203: v1(101.21,10.16) PC8713.1 101.5,11.12 PU8700.19
  BOTTOM w0.508: PR8709.2 101.21,9.59 v1(101.21,10.16)
8231_VTTREF: length 2.6
  TOP w0.203: PR8707.2 PC8712.1 104.73,8.44 PU8700.4
+BAT_DIS: length 10.5
  TOP w0.254: PR8227.2 72.33,3.27 v2(72.7,3.65) ; PR8245.2 58.65,13.93 v1(58.17,13.46)
  IN1 w0.254: v1(58.17,13.46) 59.56,13.46 59.99,13.03 64.26,13.03 64.39,13.15 v1(66.52,13.15)
+BATCHG: length 4.2
  TOP w0.254: 74.52,15.21 74.11,14.8 74.11,12.58 73.46,11.94 PR8421.1
  vias: v1(76.22,14.76) v3(76.02,16.25) v3(76.02,15.52) v3(76.76,16.25) v3(76.76,15.52) v3(77.49,16.25) v3(77.49,15.52) v3(78.23,16.25) v3(78.23,15.52)
+BATCHG+: length 8.2
  TOP w0.254: PR8231.2 70.56,8.59 PC8222.1 PC8221.2 70.06,9.58 70.21,9.93 70.52,10.25 70.52,10.86 v1(70.66,11) 70.66,11.21 72.2,12.75 v1(72.64,12.75)
  BOTTOM w0.254: PR8222.1 72.66,12.75 v1(72.64,12.75)
+BATCHG-: length 10.3
  TOP w0.254: PR8229.2 68.16,8.79 PC8220.1 PC8221.1 69.28,9.62 v1(69.71,10.04) 70.15,10.49 70.15,11.22 72.26,13.33 72.95,13.33 v1(73.53,12.75)
  BOTTOM w0.254: PR8221.1 73.1,12.32 v1(73.53,12.75)
+BATCHG_-: length 2.8
  TOP w0.254: U2000.D1 U2000.D2 73.25,10.36 72.53,11.08 C2005.2 72.41,11.86 PR8421.2
+FB_PLLAVDD: length 24.6
  TOP w0.254: C6717.2 62.11,77.5 v2(61.58,77.72)
  TOP w0.381: C7730.2 66.61,83.84 v2(66.61,84.44)
  IN2 w0.381: 62.75,81.94 65.83,81.94 66.61,82.72 v2(66.61,84.44)
  IN2 w0.508: v1(65.83,64.01) 63.24,66.6 63.24,69.5 62.55,70.18 62.55,76.75 61.58,77.72 v2(61.58,77.72)
  BOTTOM w0.305: v2(61.64,81.89) 61.55,81.89 U6600.H22
  BOTTOM w0.381: v2(61.58,77.72) 61.58,77.72 61.18,77.32 U6600.P22 ; U6600.F16 66.61,84.37 v2(66.61,84.44)
+OLEDVDD:
  vias: v1(9.25,29.28) v1(9.24,28.66)
+OLEDVSS:
  vias: v1(9.23,26.86) v1(9.23,26.21)
+PVT_VCC: length 21.5
  TOP w0.254: R5632.2 197.83,27.97 197.27,28.52 v2(197.25,28.52) 197.25,28.65 196.92,28.98 196.19,28.98 195.81,28.6 v1(194.92,28.6) 193.04,28.6 192.76,28.88 191.64,28.88 191.41,28.65 R5631.1 191.41,27.83 191.06,27.48 190.41,27.48 R5628.1 189.65,27.18 189.23,27.61 189.23,29.04 v2(190.08,29.89)
  BOTTOM w0.203: C5604.1 200.69,29.51 R5629.1
  BOTTOM w0.254: v2(197.25,28.52) 197.25,29.88 197.58,30.21 199.56,30.21 199.68,30.34 C5605.1 200.91,30.34 C5604.1 ; v2(190.08,29.89) 190.08,29.58 190.47,29.18 U5605.8
+SMDDR_VREF_DQ0: length 1.4
  BOTTOM w0.254: v1(159.17,21.59) JDIM2800.164
+SMDDR_VREF_DQ1: length 30
  IN1 w0.508: v1(82.77,18.04) 83.91,19.18 93.24,19.18 93.81,19.75 95.96,19.75 96.15,19.94 103.38,19.94 104.44,21 v1(109.12,21)
  BOTTOM w0.254: JDIM2900.164 82.21,19.25 82.77,18.7 v1(82.77,18.04)
+SPI_VCC: length 62.1
  TOP w0.203: 160.83,93.6 163.43,91 R5626.2 ; v1(165.65,58.87) 165.23,58.87 R5122.2
  TOP w0.254: C5107.1 162.88,57.06 163.42,57.06 163.65,57.28 R5124.2 164.85,56.49 166.01,56.49 v1(166.32,56.79) 166.55,56.79 v1(166.86,57.11) C5100.1 167.02,58.41 167.02,58.64 166.83,58.83 C5110.2 166.58,59.18 165.89,59.87 U5100.8 ; R5125.1 R5100.1
  TOP w0.381: 164.23,68.86 165.68,68.86 166.42,68.12 v1(166.42,67.97) 166.93,67.46 166.93,66.8 166.62,66.49 R5125.1
  IN2 w0.508: v1(166.32,56.79) 166.42,56.79 166.86,57.23 166.86,57.91 166.47,58.3 166.22,58.3 v1(165.65,58.87) 165.65,60.16 166.41,60.91 166.41,61.15 166.5,61.25 166.5,64.51 165.89,65.13 165.89,66.39 ; v1(160.67,94.67) 160.67,94.02 162.13,92.56 162.13,86.35 163.93,84.55 163.93,79.7 165.01,78.62 165.01,74.69 163.49,73.17 163.49,72.45 164.26,71.68 164.26,70.25 164.69,69.82 164.69,69.09
  vias: v1(169.39,95.07)
+UIM_PWR: length 117.8
  TOP w0.381: v1(208.2,3.17) 208.19,3.16 207.67,3.16 C4207.2
  TOP w0.508: v1(212.04,19) 212.95,19 213.76,19.81 213.76,20.85 213.28,21.33 206.53,21.33 206.4,21.45 205.66,21.45
  IN1 w0.508: v1(208.2,3.17) 208.2,2.03 207.55,1.38 194.95,1.38 v1(193.65,2.68) ; v1(166.49,52.9) 172.44,52.9 172.77,53.24 174.58,53.24 174.87,53.54 177.5,53.54 178.07,54.11 180.61,54.11 181.17,53.55 181.96,53.55 183.35,52.16 184.82,52.16 186.4,50.58 186.4,48.24 188.03,46.61 189.36,46.61 190.78,45.19 190.78,41.48 190.46,41.16 190.46,35.69 191.52,34.64 191.52,32.51 192.98,31.05 193.39,31.05 194.17,30.27 196.65,30.27 196.73,30.19 197.27,30.19 198.16,29.82 200.37,29.82 202.34,27.85 203.16,27.85 204.14,26.86 204.35,26.86 206.3,24.92 208.24,24.92 208.85,24.3
  IN3 w0.508: v1(166.49,52.9) 165.48,52.9 162.89,55.49 161.26,55.49 160.35,56.4 156.55,56.4 v1(156.49,56.33)
  BOTTOM w0.254: v1(193.65,2.68) 193.67,2.66 CON4202.36
  BOTTOM w0.508: CON4204.1 160.23,66.63 159.26,65.66 159.26,64.24 159.1,64.09 159.1,63.35 159.54,62.91 159.54,60.86 156.49,57.81 v1(156.49,56.97) v1(156.49,56.33)
  vias: v1(210.93,8.91) v1(210.98,8.28)
+VAC:
  vias: v1(156.16,102.66)
+VAC_IN: length 14.4
  TOP w0.203: v1(157.86,105.03) 157.74,104.9 PR8014.1
  BOTTOM w0.203: v1(157.86,105.03) 157.68,104.85 154.13,104.85 153.64,104.37 152.88,104.37 152.27,103.76 152.27,102.49 152.03,102.25 148.69,102.25 148.37,101.92 148.37,101.15 ; 147.14,101.04 146.81,101.37 146.81,101.98 PR8001.1
  vias: v1(149.05,97.94) v1(149.65,98.71) v1(150.29,98.71) v1(150.91,98.71) v1(151.55,98.71) v1(152.19,98.71)
+VHIF: length 5.5
  TOP w0.14: U4700.F1 195.11,13.9 195.28,13.74 195.37,13.52 195.37,12.76 195.4,12.73
  TOP w0.508: 195.4,12.73 v1(195.4,12.57) C4703.1 C4700.1 196.63,11.61 196.8,11.61 196.93,11.47 R4725.2
+VSPI: length 6.5
  TOP w0.305: U4700.H12 196.41,22.86
  TOP w0.508: R4729.2 194.72,26.81 195.05,26.48 C4704.1 195.04,26.2 195.35,25.9 C4705.2 195.6,24.79 196.41,23.98 v1(196.41,23.16) 196.41,22.86
A_3S_ICHSPKR: length 80.8
  TOP w0.109: R3612.1 188.11,36.19 187.3,36.19 186.45,37.05 184.87,37.05 183.85,38.07 v1(183.85,38.12) v1(183.85,39.03)
  IN1 w0.079: v1(161.1,53.94) 161.1,54.04 161.66,54.6 162.61,54.6 163.46,55.45 171,55.45 172.42,56.86 172.91,56.86 173.31,57.26 178.27,57.26 v1(179.35,58.34)
  IN2 w0.089: v1(183.85,39.03) 183.34,39.03 183.19,39.18 183.19,39.77 184.31,40.89 184.31,42.59 184.15,42.75 183.34,42.75 183.09,42.99 183.09,43.34 183.35,43.6 183.35,44.5 182.78,45.06 182.78,47.87 182.58,48.07 182.58,50.19 181.2,51.58 181.2,53.1 179.68,54.62 179.68,58.01 v1(179.35,58.34)
  BOTTOM w0.079: U400.DC50 137.8,63.67 137.8,63.12 138.67,62.25
  BOTTOM w0.109: 138.67,62.25 138.67,61.43 139.25,60.86 139.25,60.39 140.03,59.61 R1213.1 140.21,59.38 140.38,59.21 140.38,58.62 140.3,58.54 R1200.2 140.3,57.13 140.85,56.59 143.41,56.59 143.76,56.23 144.39,56.23 145.59,55.03 147.36,55.03 147.8,55.47 149.65,55.47 150.08,55.03 153.51,55.03 153.81,54.74 156.47,54.74 157.06,54.15 158.72,54.15 159.17,54.59 160.45,54.59 v1(161.1,53.94)
A_SD#: length 67
  TOP w0.076: U4700.L8 v2(198.04,19.59)
  TOP w0.109: v1(186.51,45.77) 186.51,45.72 D3600.1 187.4,44.7 187.07,44.37 187.07,43.89 187.12,43.84 v1(187.12,43.41) 187.12,43.2 187.53,42.8 R3618.2
  IN1 w0.079: v2(198.04,19.59) 197.97,19.67 197.97,20.98 197.05,21.89 196.27,21.89 194.51,23.64 193.25,23.64 185.97,30.93 185.97,32.78 184.02,34.72 184.02,37.04 180.62,40.44 180.62,41.9 180.19,42.33 180.19,42.89 177.1,45.97 176.3,45.97 175.43,46.84 v1(175.43,47.34)
  IN2 w0.089: v1(184.91,54.71) 184.88,54.68 184.88,50.96 185.78,50.07 185.78,49.6 185.78,49.6 185.78,47.72 186.23,47.27 186.23,46.05 v1(186.51,45.77)
  BOTTOM w0.109: v1(184.91,54.71) 184.34,54.14 180.88,54.14 179.87,53.13 178.4,53.13 176.81,51.55 176.81,50.19 176.41,49.79 176.41,48.32 v1(175.43,47.34)
AC_DC#_ALERT: length 386.6
  TOP w0.076: U4700.F6 v2(194.79,17.64)
  TOP w0.109: v1(83.19,87.34) 82.97,87.12 80.42,87.12 79.75,87.79 77.57,87.79 76.73,88.63 76.73,90.19 77.65,91.11 77.65,92.44 77.26,92.83 77.26,93.47 76.93,93.8 76.93,94.18 76.15,94.96 R4748.2 76.15,95.71 76.91,96.47 v1(76.91,96.97) 77.63,97.69 D6902.1
  IN1 w0.079: v1(10.3,38.29) 9.95,38.64 9.95,40.87 12.68,43.59 13.11,43.59 14.95,45.43 14.95,48.22 17.9,51.18 17.9,51.64 18.65,52.38 22.09,52.38 22.34,52.13 22.76,52.13 24.92,54.29 24.92,54.46 28.11,57.65 28.88,57.65 29.2,57.33 29.76,57.33 30.45,58.01 34.94,58.01 37.37,55.58 37.37,54.02 v1(37.85,53.54) ; v2(197.64,13.57) 197.46,13.39 197.46,10.28 196.08,8.9 196.08,7.26 195.84,7.03 194.9,7.03 194.71,7.22 193.15,7.22 191.86,8.52 185.95,8.52 185.76,8.33 183.31,8.33 181.92,6.94 179.92,6.94 179.27,6.3 178.81,6.3 177.8,5.29 171.94,5.29 168.59,8.63 162.77,8.63 162.09,7.96 161.64,7.96 161.28,7.6 158.71,7.6 158.58,7.47 151.17,7.47 150.56,6.85 146.79,6.85 146.38,7.26 145.5,7.26 145.09,6.85 143.65,6.85 143.21,7.29 142.51,7.29 142.08,6.86 140.82,6.86 139.79,7.89 136.71,7.89 136.17,7.35 133.37,7.35 132.69,8.02 130.7,8.02 130.16,7.49 126.44,7.49 125.9,8.03 125.47,8.03 124.81,7.37 115.76,7.37 114.22,5.82 104.77,5.82 103.79,6.8 102.41,6.8 101.98,7.23 99.6,7.23 98.52,8.31 96.62,8.31 96.1,8.83 88.48,8.83 87.98,9.32 87.98,9.65 87.78,9.85 86.76,9.85 85.42,8.51 72.92,8.51 72.61,8.19 71.43,8.19 70.47,9.15 60.58,9.15 59.46,8.02 56.46,8.02 53.97,5.54 53.97,5.51 53.42,4.96 50.99,4.96 50.75,4.72 42.63,4.72 42.09,5.26 35.89,5.26 35.33,4.7 31.62,4.7 30.38,5.94 22.53,5.94 21.4,7.07 21.07,7.07 20.76,7.38 17.07,7.38 14.59,4.89 10.8,4.89 v1(10.53,4.63)
  IN2 w0.089: v1(37.85,53.54) 39.91,55.6 47.93,55.6 49.19,56.87 53.38,56.87 55.25,55 62.02,55 62.23,55.2 64.5,55.2 65.45,56.15 65.45,58.68 66.79,60.02 66.79,60.8 69.59,63.6 74.59,63.6 76.2,65.2 76.2,66.32 79.47,69.59 79.47,69.98 84.44,74.96 84.44,78.82 85.11,79.48 85.11,86.15 83.92,87.34 v1(83.19,87.34)
  IN3 w0.089: v1(10.53,4.63) 10.13,5.03 10.13,6.46 7.45,9.14 7.45,19.47 6.57,20.35 6.57,23.11 7.52,24.06 7.52,28.74 7.14,29.12 7.14,33.5 10.3,36.66 v1(10.3,38.29)
  BOTTOM w0.076: 197.18,14.27 197.18,15.62 196.8,16 196.8,17.07 195.86,18.01 195.15,18.01 v2(194.79,17.64)
  BOTTOM w0.109: v2(197.64,13.57) 197.63,13.57 197.18,14.02 197.18,14.27
ACZ_RST#: length 4.3
  BOTTOM w0.079: 146.91,68.1 145.36,68.1 145.1,68.36 144.56,68.36 U400.DV41
  BOTTOM w0.109: R1503.1 147.88,67.13 146.91,68.1
ACZ_RST#_AUDIO: length 78.6
  TOP w0.109: v1(181.72,46) 182.14,45.58 182.14,44.78 182.55,44.37 183.21,44.37 R3620.2
  IN3 w0.089: v2(148.82,66.79) 150.19,66.79 150.64,66.34 151.84,66.34 152.47,66.08 152.9,65.65 153.13,65.09 153.13,64.86 153.74,64.25 156.83,64.25 158.06,63.02 158.06,62.24 156.54,60.72 156.54,60.53 156.64,60.42 156.79,60.42 157.52,61.15 157.64,61.15 157.79,61 157.79,60.87 157.12,60.2 157.12,59.97 157.54,59.55 157.76,59.55 158.99,60.78 159.12,60.78 159.24,60.66 159.24,60.53 157.94,59.23 157.94,59.12 158.07,58.99 158.21,58.99 159.5,60.28 159.62,60.28 159.75,60.15 159.75,60.03 158.67,58.95 158.67,58.85 158.81,58.71 158.93,58.71 160.14,59.92 160.72,59.92 161.39,59.24 162.02,59.24 163.1,58.16 163.27,58.16 163.78,57.65 163.78,57.47 163.41,57.11 163.41,56.98 163.54,56.85 163.67,56.85 164.03,57.22 164.16,57.22 164.29,57.1 164.29,56.97 163.92,56.6 163.92,56.48 164.04,56.35 164.17,56.35 164.54,56.72 164.79,56.72 165.5,57.43 165.63,57.43 165.76,57.31 165.76,57.19 165.04,56.47 165.04,56.34 165.17,56.22 165.29,56.22 165.74,56.67 165.87,56.67 166,56.54 166,56.42 165.08,55.51 165.08,55.36 165.19,55.25 165.33,55.25 165.71,55.63 165.83,55.63 165.98,55.48 165.98,55.4 165.54,54.96 165.54,54.87 165.69,54.72 165.81,54.72 166.18,55.09 166.29,55.09 166.46,54.92 166.46,54.79 166.22,54.55 166.22,54.42 166.35,54.3 166.47,54.3 166.72,54.54 166.84,54.54 167.09,54.3 167.68,54.3 168.36,54.98 168.48,54.98 168.64,54.82 168.64,54.69 167.7,53.75 167.7,53.64 167.83,53.51 167.97,53.51 168.9,54.44 169.02,54.44 169.15,54.31 169.15,54.19 168.56,53.6 168.56,53.47 168.68,53.35 168.81,53.35 169.4,53.94 169.52,53.94 169.65,53.81 169.65,53.68 169.06,53.1 169.06,52.97 169.19,52.84 169.31,52.84 169.9,53.43 170.03,53.43 170.15,53.31 170.15,53.18 169.56,52.59 169.56,52.47 169.69,52.34 169.81,52.34 170.4,52.93 170.53,52.93 170.69,52.77 170.69,52.65 170.46,52.43 170.46,52.29 170.55,52.2 170.74,52.2 170.94,52.4 171.06,52.4 172.63,50.83 173.22,50.83 174.76,49.3 175.33,49.3 178.51,46.12 181.6,46.12 v1(181.72,46)
  BOTTOM w0.109: v2(148.82,66.79) 148.52,66.79 R1503.2
ACZ_SDIN0_AUDIO: length 94.3
  TOP w0.109: R3614.1 189.34,36.77 189.21,36.9 EC3600.2 188.72,36.95 187.59,36.95 186.77,37.77 185.18,37.77 184.64,38.32 184.64,39.41 182.3,41.74 182.3,42.99 182.11,43.19 182.11,44.29 181.7,44.69 v1(181.7,45.35)
  IN3 w0.089: v2(147.37,69.5) 145.14,69.5 145.04,69.4 145.04,69.13 145.13,69.03 146.45,69.03 146.52,68.97 146.52,68.26 146.58,68.2 146.77,68.2 146.87,68.31 146.87,68.97 146.94,69.03 147.11,69.03 147.23,68.92 147.23,68.27 147.3,68.2 147.48,68.2 147.58,68.3 147.58,68.94 147.65,69.01 147.84,69.01 147.93,68.92 147.93,68.49 147.99,68.43 148.22,68.43 148.28,68.49 148.28,68.84 148.37,68.93 148.55,68.93 148.67,68.81 148.67,68.2 148.98,67.9 149.68,67.9 150.01,67.56 150.01,67.21 150.52,66.7 151.9,66.7 152.64,66.39 153.2,65.84 153.48,65.17 153.48,65 153.88,64.6 156.97,64.6 158.4,63.16 158.4,61.99 160.12,60.27 160.85,60.27 161.53,59.59 162.16,59.59 163.25,58.5 163.79,58.5 164.2,58.91 164.32,58.91 164.45,58.78 164.45,58.66 163.92,58.13 163.92,58.01 164.05,57.88 164.18,57.88 165,58.7 165.12,58.7 165.25,58.58 165.25,58.45 164.41,57.61 164.41,57.47 164.59,57.29 164.72,57.29 166.36,58.93 166.52,58.93 166.68,58.77 166.68,58.64 166.26,58.22 166.26,58.1 166.38,57.97 166.51,57.97 166.93,58.39 167.06,58.39 167.18,58.27 167.18,58.14 166.62,57.58 166.62,57.48 166.74,57.35 166.9,57.35 167.43,57.89 167.56,57.89 167.76,57.68 167.76,57.53 166.16,55.93 166.16,55.79 166.26,55.69 166.43,55.69 168.03,57.29 168.16,57.29 168.29,57.16 168.29,57.03 166.65,55.39 166.65,55.28 166.77,55.16 166.92,55.16 168.49,56.73 168.61,56.73 168.73,56.61 168.73,56.44 167.27,54.98 167.27,54.81 167.4,54.68 167.58,54.68 168.3,55.4 168.54,55.4 172.77,51.18 173.36,51.18 174.9,49.64 175.47,49.64 178.65,46.46 181.86,46.46 182.14,46.17 182.14,45.79 v1(181.7,45.35)
  BOTTOM w0.109: v2(147.37,69.5) 147.15,69.5 146.88,69.77 145.46,69.77 145.16,70.08 144.64,70.08 U400.DV37
ACZ_SDOUT: length 58.6
  TOP w0.109: v2(161.74,65.01) 161.21,64.48 161.21,61.84 159.59,60.22 159.59,58.46 160.38,57.67 160.38,56.89 161.55,55.71 v1(161.55,54.57) 161.55,53.51 159.38,51.34 159.38,50.59 158.16,49.38 158.16,48.56 157.89,48.29 157.12,48.29 157.06,48.35 156.27,48.35 155.62,48.99 155.62,49.5 154.84,50.29 153.9,50.29 151.69,48.08 151.46,48.08 151.28,47.9 149.41,47.9 Q1500.3 149.31,47.06 150.45,47.06 150.7,46.8 150.7,45.07 151.97,43.8 Q1502.3
  IN3 w0.089: v2(161.74,65.01) 161.38,65.01 158.89,67.5 157.98,67.5 157.83,67.34 156.73,67.34 155.16,68.91 150.23,68.91 149.31,69.82 148.8,69.82 v2(148.66,69.96)
  BOTTOM w0.079: U400.DT37 143.62,70.36 143.94,70.36 144.06,70.49 145.26,70.49 145.6,70.15 146.01,70.15
  BOTTOM w0.109: 146.01,70.15 148.47,70.15 v2(148.66,69.96)
ACZ_SDOUT_AUDIO: length 5.9
  TOP w0.109: R1543.1 R1232.2 188.49,39.32 189.93,39.32 EC3604.2 190.58,39.72 190.58,39.57 191.18,38.96 191.18,38.75 191.44,38.5 191.95,38.5 191.97,38.52 U3600.4
ACZ_SDOUT_G: length 1.8
  TOP w0.109: Q1500.2 147.93,45.36 v1(147.93,44.5) 148.28,44.14 R1530.1
ACZ_SDOUT_R: length 49.3
  TOP w0.109: Q1500.1 149.89,43.8 153.13,40.57 153.13,38.41 154.03,37.52 158.27,37.52 v1(159.14,38.39) ; v1(184.92,40.98) v1(185.56,40.98) 186.25,40.98 187.07,40.16 187.58,40.16 187.7,40.03 R1543.2
  IN2 w0.089: v1(159.14,38.39) 159.16,38.36 161,38.36 161.37,38.73 163.72,38.73 164.03,38.43 165.91,38.43 167.3,37.03 168.9,37.03 169.31,36.62 v1(169.85,36.62)
  BOTTOM w0.109: v1(184.92,40.98) 184.44,40.5 182.54,40.5 180.92,38.88 180.92,38.41 180.52,38.01 180.52,36.69 178.99,35.16 175.38,35.16 174.97,35.58 173.86,35.58 173.49,35.94 171.24,35.94 170.56,36.62 v1(169.85,36.62)
ACZ_SYNC: length 4.3
  BOTTOM w0.109: U400.DU37 144.22,70.31 145.19,70.31 145.54,69.96 147.51,69.96 R1502.1
ACZ_SYNC_AUDIO: length 91.9
  TOP w0.109: v1(183.61,39.62) 183.9,39.62 184.27,39.26 184.27,38.17 185.03,37.41 186.61,37.41 187.44,36.57 188.37,36.57 188.59,36.35 189.36,36.35 EC3601.2 190.21,36.37 190.8,36.37 190.93,36.5 191.87,36.5 191.89,36.52 U3600.9
  IN3 w0.089: v2(148.98,69.47) 149.43,69.47 150.39,68.5 155.08,68.5 156.58,67 157.59,67 157.89,66.71 159.2,66.71 162.35,63.55 162.35,61.93 162.78,61.51 166.18,61.51 167.48,60.2 167.63,60.2 167.9,60.47 168.08,60.47 168.17,60.38 168.17,60.23 167.88,59.95 167.88,59.82 168.01,59.7 168.14,59.7 168.59,60.16 168.73,60.16 168.85,60.03 168.85,59.91 168.47,59.52 168.47,59.42 168.62,59.26 168.71,59.26 168.98,59.53 169.08,59.53 169.2,59.4 169.2,59.25 168.91,58.96 168.91,58.58 170.18,57.32 170.18,56 170.34,55.83 171.52,55.83 172.23,55.12 172.77,55.12 174.59,53.3 174.59,52.57 178.71,48.45 179.51,48.45 179.97,48.91 179.97,50.77 180.72,51.52 182.47,51.52 182.85,51.14 183.73,51.14 183.82,51.05 183.82,50.87 183.73,50.78 182.85,50.78 182.76,50.69 182.76,50.52 182.85,50.43 183.73,50.43 183.82,50.34 183.82,50.16 183.73,50.07 182.85,50.07 182.76,49.98 182.76,48.26 183.65,47.37 183.65,45.26 183.81,45.1 184.67,45.1 184.76,45.01 184.76,44.84 184.66,44.73 183.74,44.73 183.65,44.64 183.65,44.46 183.77,44.35 184.9,44.35 185.02,44.23 185.02,44.08 184.88,43.94 183.88,43.94 183.78,43.84 183.78,43.66 183.87,43.58 184.79,43.58 184.88,43.49 184.88,43.27 184.76,43.16 184.02,43.16 183.92,43.06 183.92,42.89 184.01,42.8 184.4,42.8 184.49,42.71 184.49,42.01 184.4,41.92 183.49,41.92 183.4,41.83 183.4,41.65 183.49,41.56 184.4,41.56 184.49,41.48 184.49,41.3 184.4,41.21 183.49,41.21 183.4,41.12 183.4,40.94 183.49,40.85 184.4,40.85 184.49,40.76 184.49,40.59 184.4,40.5 183.49,40.5 183.4,40.41 183.4,40.23 183.49,40.14 184.56,40.14 184.68,40.02 184.68,39.77 184.53,39.62 v1(183.61,39.62)
  BOTTOM w0.109: v2(148.98,69.47) 148.46,69.47 R1502.2
ADP_DET: length 174.3
  TOP w0.076: U4700.M5 199.01,17.21 199.57,16.65
  TOP w0.109: 199.57,16.65 199.74,16.48 v2(200.06,16.48) ; v1(113.82,13.74) 113.33,13.26 113.33,11.91 114.58,10.67 114.58,9.8 112.98,8.2 v1(112.98,6.83)
  TOP w0.178: 57.08,8.89 PU8200.5
  TOP w0.203: 57.08,8.89 57.08,9.16 56.94,9.3 PR8232.1 56.94,9.95 57.13,10.14 PR8230.1 v1(57.13,12.06) 57.3,12.06 v1(57.64,11.72)
  IN2 w0.089: v1(57.64,11.72) 57.72,11.64 68.35,11.64 71.11,14.4 74.46,14.4 75.69,13.17 78.83,13.17 80,14.34 87.28,14.34 88.02,15.09 88.8,15.09 89.25,15.54 93.14,15.54 93.74,16.14 97.18,16.14 97.57,16.53 104.22,16.53 104.65,16.96 110.34,16.96 110.73,16.57 110.73,14.24 111.22,13.74 v1(113.82,13.74)
  IN3 w0.089: v1(112.98,6.83) 114.09,7.95 118.4,7.95 119.5,6.85 123.24,6.85 123.47,7.08 124.98,7.08 125.26,6.96 125.42,6.8 126.06,6.8 126.61,7.36 130.07,7.36 130.54,7.82 132.66,7.82 133.35,7.14 136.04,7.14 136.85,7.95 139.78,7.95 140.87,6.85 142.07,6.85 143.46,8.23 144.08,8.23 144.23,8.38 145.27,8.38 145.4,8.51 146.61,8.51 146.81,8.31 148.18,8.31 148.26,8.38 151.22,8.38 151.64,7.97 159.54,7.97 159.62,8.04 161.02,8.04 161.42,8.45 161.42,8.81 161.59,8.97 161.73,9.03 162.18,9.03 162.37,8.85 164.96,8.85 165.44,8.37 169.79,8.37 171.15,7.01 172.24,7.01 172.39,7.16 178.38,7.16 179.47,8.25 180.03,8.25 180.51,8.73 180.51,9.39 181.18,10.06 182.36,10.06 183.34,11.03 183.34,12.75 184.1,13.51 186.31,13.51 186.61,13.21 187.45,13.21 187.85,13.6 189.71,13.6 190.17,14.06 191.51,14.06 191.65,14.2 195.3,14.2 196.69,14.78 196.74,14.8 197.08,15.14 199.18,15.14 200.06,16.01 v2(200.06,16.48)
ADP_ID_ADC_R: length 3.9
  TOP w0.076: v2(194.79,15.69) U4700.E2
  BOTTOM w0.076: v2(194.79,15.69) 194.79,15.26 R4714.1 195.51,14.88 195.86,14.53 195.86,13.87 195.98,13.74 196.39,13.74 196.51,13.86 C4710.2
ADP_PRES_OUT: length 120.3
  TOP w0.076: 196.57,14.13 196.57,14.35 196.49,14.43 196.36,14.43 196.25,14.47 196.09,14.63 196.09,15.69 U4700.H3
  TOP w0.109: v2(196.39,12.7) 196.37,12.72 v1(196.37,13.43) 196.37,13.57 196.56,13.76 196.56,14.08 196.57,14.13 ; R1534.2 142.95,56.78 142.37,57.37 R1538.2 142.33,57.88 142.08,58.13 142.08,58.95 142.32,59.19 142.32,60.19 142.9,60.77 142.9,61.43 142.19,62.13 142.19,62.21 140.18,64.23 140.18,67.13 140.41,67.36 140.72,67.36 v2(141.13,67.76)
  IN1 w0.079: v2(196.39,12.7) 196.39,13.26 194.71,14.94 193.28,14.94 192.13,16.09 192.13,18.66 192.1,18.69 192.1,20.09 190.67,21.52 190.67,23.21 187.78,26.09 187.77,26.09 187.5,26.36 187.04,26.36 186.88,26.53 186.88,27.49 184.16,30.21 184.16,31.01 182.23,32.93 182.23,36.3 180.19,38.34 176.46,38.34 175.78,39.01 175.78,43.17 174.69,44.26 172.58,44.26 172.14,43.82 172.14,43.33 171.63,42.83 166.62,42.83 165.27,41.48 164.56,41.48 164.16,41.07 162.96,41.07 162.4,41.63 162.4,42.03 161.58,42.86 160.79,42.86 160.3,42.36 159.26,42.36 158.57,41.68 v1(157.37,41.68)
  IN2 w0.089: v2(141.13,67.76) 140.8,67.43 140.25,67.43 140,67.18 140,66.43 139.89,66.32 139.89,63.68 140.32,63.25 140.32,59.19 141.71,57.8 141.71,57.48 140.51,56.28 140.51,54.43 146.12,48.82 146.76,48.82 149.86,45.71 153.24,45.71 154.04,44.92 154.04,44.57 156.93,41.68 v1(157.37,41.68)
  BOTTOM w0.109: v2(141.13,67.76) 140.87,67.51 U400.DK43
ALERT: length 15
  TOP w0.109: R6953.1 82.42,79.58 79.58,79.58 78.18,80.97 78.18,83.79 77.72,84.25 76.17,84.25 75.59,84.83 75.16,84.83 v1(74.88,85.11) 74.7,85.29 73.48,85.29 73.23,85.04 v2(73.23,84.32)
  BOTTOM w0.109: U6600.F8 73.16,84.32 v2(73.23,84.32)
AMBER_BATLED#: length 108.4
  TOP w0.109: U4700.L9 198.7,19.58 200.38,19.58 v1(200.59,19.79) v2(201.42,20.62) ; R7616.2 164.51,101.14 163.79,100.41 C4800.2 163.79,99.63 164.79,98.63 166.22,98.63 v2(166.85,99.26)
  IN2 w0.089: v2(201.42,20.62) 201.04,21.01 198.52,21.01 197.43,22.1 196.44,22.1 194.94,23.59 191.78,23.59 190.7,24.67 190.7,25.07 189.78,26 189.78,26.62 189.11,27.29 188.97,27.29 186.87,29.39 186.57,30.11 186.57,31.96 182.35,36.18 182.35,37.27 180.96,38.67 180.96,40.25 178.21,43 178.21,47.74 176.8,49.15 176.8,52.53 175.23,54.1 175.23,55.4 176.01,56.19 176.01,60.16 172.91,63.27 172.91,65.43 172.66,65.68 172.66,71.64 172.18,72.11 172.18,75.3 170.93,76.56 170.82,76.82 170.82,78.23 171.39,78.8 171.39,79.71 170.7,80.4 170.7,81.62 168.98,83.35 168.98,86.87 166.34,89.51 166.34,90.8 166.78,91.24 166.78,94.13 166.22,94.68 166.22,98.02 166.85,98.65 v2(166.85,99.26)
AMP_BEEP: length 2.5
  TOP w0.109: U3600.11 193.35,34.98 192.99,34.62 C3616.2 C4404.2
AMP_BEEP_L: length 3.4
  TOP w0.109: R3612.2 188.97,35.31 R3613.1 190.06,34.59 190.23,34.75 C3617.2 190.97,34.75 191.11,34.62 C3616.1
AN_RBIAS: length 3.4
  TOP w0.109: R5931.1 182.33,99.56 182.8,99.76 v2(183.42,99.76)
  BOTTOM w0.079: 183.89,99.11 183.89,98.38 U5900.L4
  BOTTOM w0.109: 183.89,99.11 183.42,99.58 v2(183.42,99.76)
AN_RSENSE: length 3.3
  TOP w0.109: R5931.2 182.94,99.39 183.79,99.39 v2(183.97,99.57)
  BOTTOM w0.079: v2(183.97,99.57) 184.3,99.57 184.82,99.05 184.82,98.4 U5900.L5
AOZ5507_BST1: length 2.6
  BOTTOM w0.254: PR8901.2 94.55,110.66 94.89,110.32 v1(94.89,109.67) 94.76,109.55 PU8900.4
AOZ5507_BST2: length 3.2
  BOTTOM w0.254: PU8901.4 107.04,109.21 106.73,109.52 106.73,110.12 105.78,111.07 PR8908.2
AOZ5507_PHASE1:
  vias: v1(96.21,108.91)
AOZ5507_PHASE2:
  vias: v1(108,109.57)
AOZ5507_SW1:
  vias: v3(95.05,102.99) v3(95.78,102.99)
AOZ5507_SW2:
  vias: v1(106.78,102.41) v3(106.48,103.3) v3(107.22,103.3)
AOZ5507_VCC1: length 5.5
  BOTTOM w0.254: PR8900.2 90.94,110.54 v1(92.28,110.54) 92.61,110.54 93.3,109.86 PC8908.2 93.76,108.97 PU8900.2
AOZ5507_VCC2: length 3.5
  BOTTOM w0.254: PR8907.2 103.8,110.34 104.14,110.01 v1(104.52,110.01) 104.72,109.8 PC8928.2 105.44,109.62 106.04,109.02 PU8901.2
AP12: length 1.6
  TOP w0.109: TP1602.1 115.64,80.57 115.54,80.67 v2(115.54,80.96)
  BOTTOM w0.109: U400.AP12 115.54,81.37 v2(115.54,80.96)
B/I: length 7.3
  TOP w0.109: v1(87.1,11.72) 87.1,11.3 87.68,10.73 88.2,10.73 88.9,10.03 v1(89.36,10.03) 89.84,10.03 PR8414.2
  BOTTOM w0.109: v1(87.1,11.72) 87.52,11.3 88.01,11.3 88.62,11.91 PCN8400.4
B_RTC: length 2.4
  BOTTOM w0.508: PR8420.1 88.07,14.79 87.37,14.09 PCN8400.5
BARREL_ADP_DET: length 122.1
  TOP w0.076: U4700.H5 196.74,17.64 v2(196.74,17.64)
  TOP w0.109: v2(165.58,99.26) 165.58,99.49 165.05,100.02 v1(165.05,100.45) 165.05,102.31 166.06,103.32 166.06,103.95 165.42,104.59 163.86,104.59 163.16,103.89 PR8022.1 162.76,103.58 162,103.58 161.69,103.89 PR8019.1 161.57,103.27 161.08,102.79 160.34,102.79 PQ8011.3
  IN1 w0.079: v1(172.36,46.49) 172.78,46.91 173.62,46.91 173.96,47.25 174.32,47.25 174.9,47.83 175.47,47.83 176.4,46.9 176.73,46.9 180.8,42.82 180.8,42.51 182.34,40.97 182.34,39.16 184.33,37.17 184.33,34.91 186.32,32.92 186.32,31.16 188.89,28.6 190.02,28.6 190.28,28.33 190.28,27.29 193.6,23.97 194.62,23.97 195.77,22.82 197.24,22.82 198.6,21.46 198.6,19.05 197.68,18.13 197.23,18.13 v2(196.74,17.64)
  IN2 w0.089: v1(172.36,46.49) 171.91,46.94 171.91,47.32 170.55,48.68 170.55,50.68 171.19,51.33 171.19,55.49 171.53,55.83 171.53,57.19 170.58,58.14 170.58,63.69 170.21,64.07 170.21,65.13 170.36,65.28 170.36,66.68 169.46,67.58 169.46,69.29 169.64,69.47 169.64,69.82 169.84,70.03 170.37,70.03 170.84,70.49 170.84,73.65 168.89,75.59 168.89,77.76 168.25,78.4 168.25,81.24 166.49,83 166.49,83.89 165.91,84.48 165.91,89.15 165.8,89.26 165.8,91.53 166.19,91.92 166.19,93.84 165.4,94.63 165.4,99.08 v2(165.58,99.26)
  BOTTOM w0.109: v2(196.74,17.64) 197,17.38 197,16.2 197.5,15.7 C4804.1
BARREL_ADP_EN: length 127.3
  TOP w0.076: U4700.F4 v2(195.44,16.34)
  IN2 w0.076: v2(195.44,16.34) 195.44,15.73 195.22,15.52
  IN2 w0.089: 195.22,15.52 195.05,15.34 193.85,15.34 193.22,15.97 192.68,15.97 192.47,16.18 192.47,18.27 191.91,18.84 191.91,19.74 191.27,20.38 190.33,20.38 190.17,20.22 188.82,20.22 187.96,21.08 187.96,21.81 187.57,22.2 187.34,22.25 187.22,22.3 186.33,23.19 186.33,24.53 185,25.87 183.74,28.91 182.95,29.7 182.95,31.05 181.33,32.66 180.76,32.66 177.68,35.74 177.68,36.93 177.09,37.53 176.33,37.53 175.59,38.27 175.59,43.33 174.62,44.3 173.17,44.3 173.06,44.19 172.36,44.19 172.26,44.09 169.94,44.09 168.86,45.17 168.86,48.65 166.69,50.82 166.69,51.99 165.79,52.89 165.79,58.11 164.79,59.11 164.79,60.08 166.12,61.41 166.12,64.35 165.38,65.09 164.92,65.09 164.79,65.21 164.79,66.7 163.7,67.79 163.7,70.19 162.77,71.12 162.77,73.04 163.43,73.7 163.43,74.41 163.76,74.74 163.76,76.86 162.65,77.97 162.65,78.44 161.7,79.39 161.7,81.59 160.37,82.93 160.37,86.55 158.86,88.07 158.86,89.53 154.51,93.88 150.12,93.88 147.39,96.61 147.39,99.01 146.55,99.85 146.55,100.15 v2(146.25,100.45)
  BOTTOM w0.109: v2(146.25,100.45) 145.97,100.45 145.31,99.79 145.31,98.96 144.96,98.6 v1(143.53,98.6) 142.42,98.6 142.22,98.4 PR8011.2 141.96,97.99 139.77,97.99 PQ8004.1
BAT_GRNLED#: length 108.9
  TOP w0.102: U4700.F7 195.23,18.62 195.56,18.94 v2(196.09,18.94)
  TOP w0.109: v1(165.3,104.09) 164.54,103.32 164.54,102.82 164.44,102.72 R7615.2 163.54,102.72 C4805.2
  IN2 w0.076: v2(196.09,18.94) 196.09,19.51 197.13,20.55 197.13,20.6
  IN2 w0.089: 197.13,20.6 197.13,21.08 196.95,21.26 196.16,21.26 195.9,21.52 195.39,21.52 194.72,22.19 194.72,22.55 194.54,22.73 193.32,22.73 192.89,23.16 191.07,23.16 189.92,24.31 189.92,24.74 188.99,25.67 188.99,26.29 188.78,26.5 188.64,26.5 186.2,28.94 185.78,29.95 185.78,31.5 183.49,33.8 183.49,34.8 182.17,36.11 182.17,36.92 180.7,38.39 180.7,40.25 178.03,42.92 178.03,47.28 176.39,48.92 176.39,51.27 175.79,51.86 175.41,51.86 174.6,52.68 174.6,55.04 175.84,56.28 175.84,60.09 172.73,63.2 172.73,65.36 172.48,65.6 172.48,71.56 172.01,72.04 172.01,75.23 170.75,76.49 170.64,76.74 170.64,78.3 171.22,78.87 171.22,79.63 170.53,80.32 170.53,81.55 168.8,83.27 168.8,86.79 166.16,89.43 166.16,90.87 166.6,91.32 166.6,94.05 166.04,94.61 166.04,98.1 166.49,98.54 166.49,100.63 167.28,101.42 167.28,102.82 166.9,103.2 166.75,103.2 165.86,104.09 v1(165.3,104.09)
BATLOW#: length 128
  TOP w0.076: v2(188.36,21.36) 188.71,21.36 188.96,21.1 190.03,21.1 190.61,20.52 191.28,20.52 191.86,19.94 U4700.A9
  TOP w0.109: v2(145.59,68.43) 146,68.02 147.32,68.02 148.08,67.26 149.07,67.26 149.43,66.9 151.3,66.9 151.49,67.08 R1532.1 151.49,67.38 151.66,67.55 152.43,67.55 R1535.1
  IN1 w0.079: v1(187.94,11.05) 187.94,11.63 190.2,13.9 190.2,17.24 190.12,17.42 189.98,17.56 189.42,17.56 188.97,18.01 188.97,20.75 v2(188.36,21.36)
  IN2 w0.089: v1(168.22,52.27) 167.65,52.27 167.05,51.66 167.05,50.97 169.22,48.8 169.22,45.34 170.11,44.44 172.03,44.44 172.13,44.54 172.89,44.54 173.19,44.84 174.68,44.84 175.98,43.55 175.98,38.38 176.47,37.89 177.24,37.89 178.05,37.07 178.05,36.51 179.03,35.53 179.03,34.93 181.12,32.84 181.41,32.84 183.13,31.12 183.13,29.77 183.89,29.01 185.15,25.97 186.51,24.61 186.51,23.82 186.84,23.5 187.71,23.5 187.89,23.32 187.89,22.45 188.37,21.96 188.37,21.37 v2(188.36,21.36) ; v1(149.15,56.13) 148.56,56.72 147.9,56.72 146.85,57.77 146.85,60.53 145.77,61.6 145.77,62.82 146.46,63.51 147.53,63.51 147.91,63.89 147.91,64.91 147.71,65.38 147.69,65.4 147.69,66.12 147.48,66.33 147.32,66.33 146.86,66.79 146.86,67.17 145.6,68.43 v2(145.59,68.43)
  IN3 w0.089: v1(187.94,11.05) 191.19,11.05 191.56,11.42 192.93,11.42 193.02,11.51 197.06,11.51 197.55,12 201.38,12 202.29,12.91 v2(202.29,13.05) ; v1(149.15,56.13) 149.83,55.44 154.64,55.44 156.27,57.08 158.37,57.08 158.66,56.79 160.51,56.79 161.42,55.88 163.19,55.88 165.65,53.42 166.67,53.42 167.82,52.27 v1(168.22,52.27)
  BOTTOM w0.079: U400.DN41 142.32,68.44 144.18,68.44 144.26,68.51 145.17,68.51 145.38,68.3 145.46,68.3 v2(145.59,68.43)
  BOTTOM w0.109: Q4800.3 201.79,12.55 v2(202.29,13.05)
BATT+: length 5
  TOP w0.254: 78.13,9.3 77.81,8.98 74.52,8.98 74.28,8.74 73.43,8.74 PR8422.1
  vias: v1(81.68,12.67) v3(81.69,11.12) v3(81.74,11.84) v3(82.48,11.84) v3(82.43,11.12) v3(83.16,11.12) v3(83.21,11.84) v3(83.95,11.84) v3(83.9,11.12)
BATT+_+: length 3.2
  TOP w0.254: PR8422.2 72.95,9.29 v1(72.77,9.47) 72.75,9.47 72.41,9.8 C2005.1 72.74,10.3 73.08,9.96 U2000.D3

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DV33_18: length 2.6
  TOP w0.203: 176.43,36.98 176.62,37.17 U7600.18
  TOP w0.508: 176.43,36.98 176.37,36.92 176.37,36.91 176.32,36.86 176.32,36.35 176.71,35.96 C7607.1
GND: length 2000.7
  TOP w0.109: 206.91,2.13 207.13,1.9 207.87,1.9 208.89,2.92 208.89,7.47 207.74,8.61 207.74,8.76 207.54,8.96 207.06,8.96 206.86,8.76 205.94,8.76 205.76,8.94 205.76,9.14 205.51,9.4 204.98,9.4 204.79,9.21 204.79,8.73 204.72,8.57 204.72,8.05 204.98,7.8 205.43,7.8 205.69,8.05 206.65,8.05 206.93,7.77 207.62,7.77 208,7.39 208,5.66 207.77,5.44 R4230.2 ; v1(88.01,98.35) 88.01,98.02 87.88,97.89 87.88,96.16 88.81,95.23 88.81,91.71 88.19,91.08 88.19,90.68 87.86,90.35 87.86,89.18 v1(87.12,88.44) v1(87.12,85.9) ; 94.94,76.91 95.17,76.91 95.65,76.43 ; v1(89.63,93.81) 89.75,93.81 90.07,94.13 90.07,95.27 89.38,95.96 89.38,96.57 88.97,96.97 ; 105.69,69.47 102.87,69.47 101.59,70.74 v2(100.24,70.74) 99.64,71.34 99.64,71.63 99.43,72.13 99.43,73.69 98.52,74.61 98.52,75.83 97.87,76.47 96.47,76.47 95.1,77.85 95.1,78.53 93.23,80.4 93.05,80.4 ; v1(103.2,113.62) 103.42,113.84 125.43,113.84 130,109.27 130,109.08 131.24,107.84 154.11,107.84 154.2,107.74 ; R1239.2 162.22,74.52 162.1,74.39 161.47,74.39 ; 93.57,79.04 93.57,79.19 93.17,79.6 92.83,79.6 ; 102.99,68.28 103.02,68.3 104.97,68.3 105.13,68.15 105.71,68.15 v2(105.88,67.97) 105.97,67.97 106.22,68.22 106.42,68.22 106.56,68.36 107.02,68.36 107.11,68.45 108.18,68.45 ; v2(108.61,69.29) 108.91,69.59 108.91,70.13 108.66,70.38 ; 98.98,70.13 98.98,71.69 98.84,72.04 98.84,72.96 98.78,73.02
  TOP w0.14: U4700.M3 199.24,16.02 199.87,15.39 v2(199.97,15.39)
  TOP w0.152: 168.83,66.2 Q5101.1
  TOP w0.178: v1(33.68,101.8) 33.93,102.05 PU9800.11 ; v1(103.75,10.94) 103.53,10.72 PU8700.1 ; U7500.5 20.87,42.64 v1(20.84,42.6)
  TOP w0.203: v2(135.33,96.8) 135.09,97.03 134.88,97.12 134.87,97.13 134.59,97.41 PC10634.2 ; PQ10501.4 70.62,98.76 71.17,98.22 PR10520.2 71.68,97.91 v1(71.98,97.61) ; v2(134.33,82.68) 134.87,82.14 C7760.1 ; v1(58.57,10.61) 58.72,10.77 58.72,10.97 58.73,10.98 58.73,11.84 59.27,12.38 PC8203.1 ; v1(58.29,99.03) 58.01,99.31 56.11,99.31 55.36,98.56 53.78,98.56 53.46,98.24 31.69,98.24 30.45,99.48 30.45,99.82 PR9809.2 ; U4700.A8 191.44,19.27 191.39,19.32 v2(191.39,19.33) ; v1(123.42,26.49) 123.47,26.44 C1726.2 ; R4811.2 167.1,43.6 166.98,43.48 v1(166.98,43.4) ; v2(188.27,94.07) 188.48,94.27 R5920.2 ; v1(117.42,27.09) 117.26,27.09 C1720.2 ; C2808.2 118.77,21.69 v1(118.68,21.6) ; v1(114.09,23.01) 114.3,22.81 114.3,22.73 R2920.2 ; PC9800.1 33.56,99.74 33.93,99.74 PR9807.1 ; U2004.C1 200.28,78.26 v1(200.73,78.71) ; 174.06,84.66 173.84,84.88 PR8403.1 ; C2807.2 126.04,25.19 v1(125.42,25.19) ; PR8020.2 162.35,104.49 162.08,104.76 v1(162.08,104.96) 161.92,105.12 PR8021.2 ; PR9821.1 30.25,103.65 29.92,103.99 29.92,104.57 v1(29.98,104.63) ; v1(202.46,91.89) 202.21,92.15 U6201.8 U6201.3 199.59,92.15 v1(199.57,92.17) ; v2(37.97,68.48) 37.96,68.48 37.92,68.52 37.92,69.62 37.97,69.67 R7006.1 ; v2(155.39,73.43) 155.28,73.32 R1224.2 ; PR9812.2 34.69,107.11 34.69,108.1 v1(34.72,108.13) ; v1(88.24,73.81) 88.19,73.86 PU10501.15 PU10501.11 ; PR9805.1 31.29,106.35 v1(31.29,108.15) ; Q4106.1 183.91,84.86 183.95,84.82 R4152.2 183.67,84.15 v1(183.46,84.35) ; C2812.2 130.37,22.22 v1(129.68,22.22) ; R3508.2 199.62,52.91 199.59,52.94 v1(199.59,52.96) ; R4743.1 171.4,43.64 v1(171.4,43.36) ; PU10601.11 PU10601.15 ; 146.65,63.28 146.65,62.01 v1(146.63,62) 146.65,61.98 146.65,61.47 147.43,60.69 v1(147.43,58.47) 147.79,58.11 147.79,57.61 148.06,57.34 148.72,57.34 149.96,56.1 149.96,55.78 150.82,54.91 151.33,54.91 v1(151.97,54.28) 152.52,53.72 v1(152.52,51.31) 152.52,50.92 151.97,50.37 v1(150.32,50.37) 148.23,50.37 147.75,50.85 v1(147.75,51.64) 147.75,52.8 146.68,53.87 v1(146.68,55.7) 146.68,56.19 145.81,57.06 v1(145.74,57.06) 145.74,59.82 v1(145.09,60.48) 144.63,60.93 144.63,63.01 143.96,63.68 v2(143.93,63.68) ; v2(143.14,64.21) 143.11,64.24 143.11,64.7 142.9,64.92 ; v1(32.38,104.21) 32.38,103.88 32.15,103.65 PC9804.2 ; 168.83,66.2 169.64,65.38 v1(169.68,65.38) ; v1(162.7,104.96) 163.07,104.59 PR8022.2 ; C2008.2 200.26,76.02 200.2,76.07 v1(200.2,76.4)
  TOP w0.254: v1(45.82,45.49) 45.83,45.48 CON7703.25 ; v1(183.56,25.61) 183.95,25.61 184.45,26.11 R2817.1 ; v2(188.63,26.14) 188.63,26.62 C4806.2 ; C4109.2 186.47,70.16 186.75,69.88 186.75,69.64 186.29,69.18 186.13,69.11 185.92,69.09 185.77,69.12 v1(185.34,69.54) ; v2(191.29,17.03) 191.47,17.03 191.76,17.32 U4700.A5 ; R1545.1 29.42,31.35 v1(29.46,31.38) ; v2(194.26,81.52) 194.37,81.52 194.77,81.91 R6200.2 ; Q4111.1 196.86,70.62 196.92,70.69 v1(196.92,71.05) ; R1538.1 143.23,57.47 v1(143.31,57.47) ; v1(49.03,43.67) 48.72,43.98 CON7703.19 ; v1(48.9,53.98) CON7703.59 ; C6719.1 54.02,91.68 R6713.1 54.53,90.5 57.48,90.5 59.2,88.77 v2(59.66,88.77) ; v1(40.06,48.48) CON7703.38 ; U1800.C3 195.35,3.49 v1(195.75,3.9) ; v1(186.94,7.82) R4213.1 ; U1800.C1 195.35,2.05 194.96,1.66 192.8,1.66 192.56,1.9 C1802.2 192.1,2.61 v1(192.05,2.66) ; Q4106.1 183.38,85.33 183.28,85.24 R4151.2 ; v1(193.66,10.46) 193.66,10.66 194.1,11.11 R4824.2 ; C7239.2 17.43,7.91 v1(17.61,7.91) ; C1638.1 136.56,73.13 v2(137.27,73.84) ; R1522.2 135.92,67.3 v2(136,67.22) ; v2(139.9,69.55) 139.9,69.78 139.59,70.09 C1651.1 ; v1(71.53,92.09) 71.34,92.28 R6806.2 ; R2819.1 160.23,21.57 v1(160.17,21.51) ; PC8802.2 v1(81.86,109.64) ; v1(169.12,71.89) 168.96,71.73 U1907.C3 ; v1(175.13,51.04) 175.71,51.62 C2009.2 176.2,51.81 176.55,52.17 U2005.C1 ; C1803.2 25.83,33.7 25.35,33.7 v1(25.12,33.47) ; C7603.2 180.06,34.74 180.74,35.43 v1(180.79,35.43) 180.92,35.56 C7602.2 ; v1(21.25,27.88) 21.5,27.63 U2008.C1 ; CON6300.A12 210.55,111.59 v1(210.4,111.74) ; v1(11.53,19.73) 11.53,19.81 11.11,20.23 10.74,20.23 10.69,20.18 CON7602.14 ; v1(159.85,7.22) 160.01,7.39 U1906.C3 ; R1215.2 155.3,81.86 v1(155.55,81.61) ; PC8720.1 99.8,16.65 99.63,16.83 99.63,17.5 v3(99.73,17.6) ; v1(163.75,66.98) 163.58,66.8 C5111.1 ; R7004.1 38.73,88.69 38.76,88.69 v2(39.16,89.09) ; v2(158.11,67.09) 157.94,66.92 C1401.2 ; R4810.1 200.18,12.29 200.01,12.46 v2(200.01,12.81) ; v1(31.3,35.28) 31.45,35.14 R3429.1 ; v1(180.01,84.27) 179.77,84.51 U4102.3 ; v1(199.65,69.52) 199.68,69.54 U6200.3 U6200.8 v1(201.93,69.54) ; R3515.2 201.61,52.03 201.87,52.29 201.87,52.77 v1(202,52.91) 202.26,52.65 202.26,52.45 202.42,52.29 C3525.2 ; C2002.2 18.84,13.14 18.64,13.33 18.64,13.76 18.39,14.02 17.79,14.02 v1(17.6,13.83) ; U2005.C3 176.55,54.07 v1(176.92,54.44) ; v2(167.4,99.26) 167.4,99.12 167.06,98.78 C1907.2 167.06,98.04 167.56,97.54 U1904.C1 ; v1(43.17,51.48) CON7703.50 ; v2(146.78,78.84) 146.94,78.84 147.54,78.23 R1142.2 ; v1(156.17,23.41) 156.36,23.41 156.77,23.01 R2820.1 ; 139.4,16.72 139.96,16.72 v1(140.08,16.6) ; U4700.E12 194.46,22.24 v2(194.36,22.35) ; CON7703.8 43.52,40.98 43.84,41.3 v1(43.84,41.51) 43.84,42.09 43.44,42.48 CON7703.14 ; v1(209.73,104.98) 209.91,104.98 211.03,106.09 CON6300.A1 ; v2(187.5,22.59) 187.51,22.59 R4815.1 ; C1900.2 45.49,14.46 v1(45.49,15.01) ; R2907.2 82.77,22.02 v1(82.65,22.14) ; U1909.B3 25.65,67.87 v1(24.86,68.65) ; R4409.2 208.43,11.42 v2(208.01,11.83) ; v1(154.93,54.29) 154.69,54.54 154.38,54.54 C500.1 ; v1(48.94,42.25) 48.71,42.48 CON7703.13 ; C4706.2 173.95,5.15 v1(173.71,4.91) ; v1(69.92,24.3) 70.09,24.3 70.43,24.64 70.43,25.17 70.1,25.5 C1727.2 ; v1(24.45,35.71) 24.48,35.69 U1802.B3 ; Q3405.1 34.71,33.14 v1(34.41,32.84) ; v1(86.99,98.39) 86.83,98.24 PC8814.1 ; v1(192.81,56.18) 192.94,56.05 C1908.2 ; v2(146.22,99.59) 146.22,99.23 146.06,99.07 PU10602.3 ; C3427.2 27.58,39.34 27.25,39.67 v1(27.25,40) ; v1(48.93,40.98) CON7703.7 ; v1(209.09,11.96) 209.7,11.35 U4400.2 ; U1807.C1 14,16.6 13.41,17.19 v1(13.41,17.24) ; C1915.2 v1(28.71,53.41) 28.85,53.54 U1908.C1 ; v1(120.47,105.95) 120.79,105.95 PR9103.1 ; CON7703.32 40.1,46.98 v1(40.1,46.98) ; CON7703.2 43.14,39.48 v1(43.61,39.02) ; PC8610.2 143.8,13.59 v1(143.51,13.89) ; U2000.C1 74.04,11.23 74.31,11.5 74.31,11.55 v1(74.32,11.56) 74.37,11.56 74.42,11.61 C2000.2 ; v1(30.33,40.59) 30.4,40.52 30.4,39.84 30.58,39.66 U3405.2 ; v1(151.18,54.3) 152,53.48 C1405.1 ; v1(53.39,16.38) 54.48,16.38 54.81,16.71 PR8204.2 ; R1420.2 173.07,5.03 v1(172.95,4.91) ; 173.3,44.43 R7607.1 ; R405.2 157.12,65.08 v2(157.44,64.76) ; R1542.1 144.13,56.18 R404.2 143.88,55.24 143.43,54.79 v1(142.97,54.79) ; C1902.2 146.4,8.68 R4414.1 146.86,9.01 v1(147.32,9.46) 147.15,9.46 146.58,10.03 U1900.C1 ; v1(174.04,49.3) 174.04,49.3 PC8726.1 ; C1403.1 148.43,54.01 v1(147.98,54.46) ; U4700.J12 197.06,22.43 v2(197.1,22.47) ; R1043.2 95.58,73.84 96,74.27 R1009.2 96.23,74.87 R1042.2 ; 81.56,113.21 81.56,111.51 82.28,110.79 C2018.2 ; C2001.2 120.44,90.69 v1(120.83,91.07) 120.42,91.48 U2001.C1 ; C1501.1 155.95,47.37 155.87,47.29 v1(155.55,47.29) ; R1307.1 154.33,81.58 v1(154.28,81.63) 154.51,81.86 R1233.2 ; 199.44,79.74 199.44,78.91 v1(199.38,78.86) ; v1(145.31,56.6) 145.22,56.6 145.08,56.73 R800.2 ; v1(158.85,86.27) PU10605.3 ; Q4703.4 187.08,8.72 186.71,9.09 186.71,9.57 186.27,10.02 Q4703.1 ; U1802.C1 26.37,36.09 v1(26.97,35.48) ; v2(45.94,69.3) 46.07,69.17 46.43,69.17 C7022.2 ; CON7602.11 9.68,21.68 9.44,21.92 9.44,22.23 ; R6704.2 50.65,79.93 v1(50.65,79.93) ; C5110.1 166.58,57.89 v1(166.22,57.52) 165.55,56.86 R5126.1 ; v1(11.07,17.18) 11.07,17.18 CON7602.20 ; U1807.B3 15.66,17 v1(15.77,16.89) ; R2821.1 153.46,24.43 153.18,24.15 v1(152.95,24.15) ; Q801.1 157.27,48.77 156.69,49.35 156.39,49.35 156.07,49.67 156.07,50.21 v1(156.18,50.32) 156.38,50.52 Q800.1 ; R608.1 128.21,81.98 v2(128.86,82.63) ; v2(207.71,26.48) 207.71,27.18 207.19,27.7 206.03,27.7 205.65,28.08 EC3603.2 ; U1903.C1 110.66,15.39 110.69,15.41 C1906.2 111.25,16.1 v1(111.33,16.18) ; v2(201.1,13.01) 201.46,13.01 C4722.1 ; v1(49.18,47.39) 48.78,46.98 CON7703.31 ; C3416.2 30.75,27.72 30.23,28.23 v1(29.57,28.23) ; 187.2,38.1 187.07,38.22 C1504.1 ; v1(141.32,57.64) 141.23,57.72 141.23,58.41 R1546.1 ; C1801.2 23.73,28.84 v1(24.02,29.13) ; v1(26.49,28.14) 26.06,27.71 U1803.C1 ; D3701.2 201.78,31.43 ; 135.1,4.87 162.08,4.87 ; v1(80.57,103.17) PC8817.1 ; v1(21.23,7.44) 21.04,7.63 21.04,8.74 20.24,9.54 ; v1(176.43,58.19) 177.14,58.19 177.58,57.75 U4701.2
  TOP w0.305: C6112.1 199.56,92.17 v1(199.57,92.17) ; v2(186.43,92.59) 186.4,92.63 185.93,92.63 185.6,92.95 C5921.2 ; Q5201.1 28.53,6.16 28.98,5.71 v1(28.98,5.43) ; C5412.2 185.21,10.85 v1(185.21,10.74) ; PC9803.2 39.5,103.45 v1(39.52,103.48) ; v1(100.43,10.16) PC8713.2 ; 152.83,102.71 152.08,103.45 PC9605.2 ; U6203.14 197.09,83.92 v1(197.31,84.14) ; PU9601.3 147.15,102.42 146.42,101.69 v2(146.38,101.69) ; C1723.2 101.75,22.01 v1(101.74,21.99) ; v1(86.08,27.01) 86.37,27.3 C1718.2 ; v2(75.68,69.46) 74.89,70.25 74.86,70.25 C6684.1 ; v1(188.97,42.26) 189.48,41.75 C3618.1 189.49,41.7 C3619.2 ; CON7602.26 9.34,14.18 v1(9.34,14.18) ; C7609.2 173.67,33.89 173.2,33.42 v1(173.2,33.27) ; C4406.2 41.45,6.8 v1(41.45,6.55) ; PU10606.3 126.35,103.46 ; PQ10501.1 69.1,100.06 69.34,99.82 69.34,99.06 69.63,98.76 PQ10501.4
  TOP w0.381: C1621.2 134.38,77.59 C1627.2 134.38,78.28 ; C6669.2 67.76,79.19 v1(68.36,79.79) 68.83,80.26 C6644.1 ; v1(157.22,14.65) 157.22,15.22 PC9521.2 ; PR8119.1 PC8106.1 173.2,18.75 v1(173.71,18.25) ; C3624.2 189.33,44.17 v1(189.23,44.27) ; v1(158.43,25.06) C1706.2 ; C6717.1 61.69,76.72 v2(61.58,76.83) ; v1(25.91,31.21) 25.69,31.43 C3412.2 ; v1(83.3,100.47) PC8806.1 ; C7038.1 37.79,94.35 v2(37.94,94.5) ; v1(83.02,101.65) 83.42,102.06 PC8805.1 ; C769.2 124.18,68.54 v2(124.18,67.87) ; C2814.2 173.32,22.28 v1(173.18,22.14) ; C6108.1 188.85,85.75 v1(189.3,85.29) ; PU10604.3 143.06,102.42 142.77,102.13 v1(142.77,101.57) 142.59,101.39 C3628.1 ; 173.3,44.43 172.53,44.43 172.14,44.03 172.14,43.26 C7610.2 171.84,43.13 171.61,43.36 v1(171.4,43.36) ; PC8220.2 67.38,8.87 v1(67.66,8.58) ; C6647.1 67.87,72.06 67.31,72.06 67.13,72.23 C6626.1 66.68,72.06 66.09,72.06 v1(65.99,71.96) ; C7060.2 34.77,89.8 C7000.1 35.4,89.84 v2(35.54,89.7) ; C6631.1 66.42,79.2 v1(66.42,79.88) ; v1(172.27,64.65) 172.79,64.13 PC9536.2 ; 207.19,14.71 205.95,14.71 v2(205.74,14.5) ; C3423.2 26.02,45.2 v1(26.36,45.54) ; v2(131.86,57.2) 131.78,57.12 C1721.2 ; C7024.2 38.64,79.39 v1(38.79,79.54) ; C4403.1 192.68,32.69 v1(193.01,33.02) ; v1(140.45,100.11) 140.45,100.89 C3627.1 ; v1(90.02,25.18) 90.02,25.23 90.04,25.25 C2907.2 ; v1(150.57,30.35) 150.33,30.11 C1710.2 ; C767.2 107.66,74.94 v2(107.74,75.02) ; v1(181.71,42.54) 181.71,42.21 R7613.1 ; v1(72.35,75.71) 71.9,76.16 C6675.1 72.46,76.44 72.51,76.39 C6663.1 ; C4204.2 184.95,7.48 185.27,7.8 v1(185.27,7.8) ; C7046.2 37.98,74.94 v2(37.94,74.9) ; C1712.2 156.14,23.45 v1(156.17,23.41) ; v1(164.42,68.15) 164.53,68.03 C5108.1 ; v1(203.54,49.83) 203.57,49.86 C3526.2 ; 7.32,5.68 7.65,5.35 v1(7.65,4.98) ; v1(21.13,36.12) 21.13,36.16 Q7508.1 ; v2(43.01,5.95) 43.01,6.49 PR8417.1 ; C4715.2 187.71,13.21 v2(187.32,13.59) ; v1(42.12,79.81) 42.09,79.84 C7030.1 ; v1(24.2,46.78) 24.04,46.94 Q3403.1 ; C741.2 113.87,59.33 113.54,59 v2(113.24,59) ; v2(42.68,68.5) 42.57,68.38 C7041.1 ; C1725.2 C7224.1 134.43,57.22 v2(134.44,57.22) ; EC3703.2 212.38,43.74 v1(212.85,43.74) ; v1(60.97,26.49) 60.97,26.35 C1707.2 ; v1(66.05,3.24) 65.96,3.33 PD8203.2 ; v2(45.15,87.31) 44.57,87.89 C7036.1 ; C746.2 121.24,59.24 v2(121.5,59.24) ; v1(145.79,53.08) 145.69,53.08 144.83,52.22 144.83,50.8 Q4401.1 ; v1(96.33,26.07) 96.36,26.1 C1709.2 ; C1717.2 92.49,26.46 v1(92.97,26.46) ; v1(78,22.81) 78,23.15 77.56,23.59 C2911.2 ; C6622.1 70.38,79.76 v1(70.35,79.79) 70.03,80.11 C6639.1 ; v1(152.93,22.22) 152.88,22.22 152.42,21.77 ; EC2903.2 49.68,23.46 v1(49.72,23.43) ; v1(161.86,102.16) 161.86,101.82 162.25,101.42 EC4.2 ; v2(123.19,67.97) 123.19,68.29 123.32,68.42 C735.2 ; C5204.2 35.61,5.4 36.14,4.86 v1(36.14,4.84) ; C3400.2 31.22,46.66 v1(31.16,46.72) ; C2811.2 146.43,23.04 v1(146.63,23.24) ; C1714.2 144.11,30.32 v1(144.68,30.88) 144.88,31.09 C1708.2 ; C2924.2 76.03,22.1 v1(76.07,22.06) ; C7008.1 46.1,83.25 v2(46.03,83.32) ; v1(140.33,90.93) 140.33,90.14 140.43,90.04 R1121.1 ; EC2901.2 100.96,26.63 100.81,26.48 v1(100.47,26.48) ; C2805.2 165.62,26.48 v1(164.92,26.48) ; C6803.1 72.97,78.5 72.54,78.08 v1(72.54,77.71) ; PC8816.1 87.89,100.33 v1(87.68,100.33) ; C3413.1 25.4,33.02 25.12,33.3 v1(25.12,33.47) ; C7039.1 44.83,93.6 44.72,93.71 C7015.1 43.56,93.71 v2(43.55,93.69) ; C4716.1 201.88,18.95 v2(201.75,18.82) 202.17,18.4 C4802.1 ; v1(163.26,38.32) C2826.2 C2827.2 ; Q4703.1 185.76,10.02 185.21,10.56 v1(185.21,10.74) ; C7028.2 34.53,93.53 v2(34.69,93.7) ; C1700.1 53.71,24.78 v1(53.4,25.09) ; v2(34.69,85.7) 34.14,86.25 C7003.1 ; C3527.2 202.76,48.09 203.12,47.72 v1(203.45,47.72) ; C7020.1 35.49,71.75 v2(35.54,71.7) ; C739.2 111.16,59.24 v2(110.86,59.24) ; v1(162.68,22.17) 162.73,22.23 C2815.2 ; C6653.2 74.36,84.82 74.83,84.35 v2(74.83,84.32) 74.84,84.31 C6650.2 ; EC2902.2 104.43,23.21 104.21,23.43 v1(103.82,23.43) ; C2925.2 67.82,26.02 67.62,25.83 v1(67.08,25.83) ; C2802.2 144.68,22.79 v1(144.23,22.79) ; v1(139.6,91.01) 139.65,90.96 R1422.1 ; v1(176.88,34.08) 176.71,34.25 C7607.2 ; C2803.2 148.37,23.93 v1(147.9,23.93) ; v2(35.56,69.32) 35.1,69.32 C7059.2 ; C6608.1 69.82,75.28 v1(70.34,75.8) ; C749.2 124.02,58.45 v2(123.78,58.45) ; v1(40.59,78.44) 40.5,78.52 C7012.1 ; C6632.1 69.91,73.23 v1(70.32,73.64) 70.65,73.31 C6670.1 ; v2(42.74,83.3) 42.09,82.65 C7019.1 ; v1(70.34,75.8) 70.98,75.16 C6617.1 ; v1(70.34,75.8) 70.72,76.18 C6672.1 ; C757.2 107.78,73.18 v2(107.78,73.18) ; VC6200.1 199.88,85.07 v1(199.61,85.07) ; C5034.1 127.08,8.8 127.08,8.79 127.86,8.01 v1(127.9,8.01) ; v2(132.89,58.6) 132.99,58.49 C1719.2 ; C2901.2 57.52,25.25 57.26,25 v1(56.97,25) 56.49,25 56.28,25.2 C7225.1 ; C4114.2 195.83,75.25 v1(195.51,74.93) ; PC8210.2 60.13,3.86 v1(59.41,3.86) ; CON7600.6 203.46,17.5 v2(203.34,17.63) ; v1(191.64,35.82) 191.52,35.94 EC3601.1 ; v2(109.21,57.47) 109.21,57.47 C1704.2 ; C2809.2 150.8,23.08 v1(150.85,23.13) 150.85,23.32 C2816.2 ; PC8401.1 175.51,83.81 v1(175.51,84.35) 175.34,84.52 PC8402.1 174.2,84.52 174.06,84.66 ; C2800.1 142.24,22.72 v1(142.17,22.78) ; C7040.1 41.83,91.4 v2(41.88,91.45) ; PC8108.1 v1(15.99,46.5) ; v1(173.23,74.24) 172.94,73.95 PC9529.1 ; v1(93.19,16.28) 92.96,16.51 PC8704.2 ; C7606.2 176.04,32.71 v1(176.17,32.58) C7608.2 ; v1(19.21,17.07) 18.88,17.4 18.3,17.4 PC9505.2 ; C3530.2 C3531.2 ; v2(35.47,95.34) 35.47,95.57 35.09,95.94 C7044.2 ; v1(82.98,26.46) 83.4,26.89 C2923.2 ; v1(71.72,22.81) 71.11,22.81 C2918.2 ; C2916.2 73.23,25.17 73.61,24.79 v1(73.61,24.57) ; v1(103.72,22.14) 104.32,22.14 EC2900.2 ; v1(189.15,38.81) C3623.1 ; EC3605.2 v1(201.14,31.43) 201.78,31.43 ; v1(65.72,21.54) 65.68,21.5 C2900.1 ; 196.97,4.01 D4205.1 195.87,4.01 v1(195.75,3.9) ; v1(35.4,26.85) 35.4,26.9 C7765.2 ; v2(45.97,85.67) 46,85.64 C7006.1 ; v1(189.3,87.2) 188.87,86.76 C6107.1 ; v1(100.22,23.42) 100.2,23.41 C1711.2 ; v1(73.46,26.54) 73.52,26.61 C2914.2 ; EC3604.1 189.66,39.82 v1(189.07,39.82) ; C7043.2 44.49,67.03 v2(44.37,66.91) ; C2806.2 159.9,25.99 v1(159.43,26.46) ; C4400.2 148.58,9.09 147.85,9.09 147.48,9.46 v1(147.32,9.46) ; C7004.1 46.53,91.6 v2(46.13,91.6) ; C7226.1 C2810.2 151.62,25.43 v1(151.62,25.08) ; v1(24,44.85) 24.37,45.22 C3300.1 ; U6202.2 201.63,81.99 v1(201.24,81.6) ; C1705.2 145.89,24.51 v1(146.63,24.51) ; C2903.2 52.8,22.23 v1(52.72,22.15) ; C6638.1 69.86,77.22 v1(70.34,77.7) ; C7016.1 42.03,64.71 42.62,65.3 v2(42.74,65.3) ; C7701.1 37.95,52.12 v1(37.75,51.92) ; C3626.1 C3625.1 136.56,100.68 v1(137.15,100.08) 137.15,99.33 PC10628.2 ; C6664.1 67.74,75.04 v1(68.45,75.75) 68.45,76.43 C6607.1 C6662.1 ; C737.2 106.05,59.15 v2(105.92,59.28) ; C2909.2 87.27,22.13 v1(87.72,22.13) ; PC10506.2 89.23,67.66 v1(88.24,66.68) ; v2(113.24,56.18) 113.23,56.17 C1715.2 ; v1(181.41,36.59) 181.41,37.26 ; CON7600.12 204.54,26.11 203.95,25.52 v2(203.95,25.06) ; C1702.1 75.2,25.74 74.73,25.28 v1(74.45,25.28) ; C2919.2 79.13,22.21 79.4,22.48 v1(79.4,22.71) ; v1(140.68,21.57) 141.31,21.57 C2804.2 ; C7026.2 46,90.08 v2(46,89.76) ; EC4.2 162.6,100.81 C4800.1 ; EC4.2 162.6,102.31 C4805.1 ; v1(54.23,11.1) PC8224.2 ; v2(44.34,85.7) 44.9,85.14 C7002.1 ; v1(52.65,5.45) 52.11,5.99 PC8227.1 ; C7223.1 108.02,54.7 C1713.2 107.08,54.7 v2(106.01,55.77) ; v1(72.37,23.47) 72.44,23.39 C2921.2 ; v1(174.67,73) 174.67,72.68 PC9537.2 PC9538.2 ; v3(96.76,18.3) 96.44,18.3 PC8708.2 ; v1(196.64,10.27) 196.64,10.81 C4700.2 ; C2917.2 68.56,23.02 v1(68.12,22.58) ; v2(34.19,83.1) 34.19,83.13 34.33,83.28 C7045.2 ; C2912.2 96.34,22.26 v1(96.22,22.14) ; v2(44.34,83.3) 43.76,83.88 C7034.1 ; v1(189.3,83.39) 189.81,82.88 C6106.1 ; C6613.1 73.01,74.33 C6614.1 72.1,73.85 v1(72.28,73.67) ; C2913.2 104.42,25.27 v1(104.16,25.02) 104.43,24.75 C2910.2 ; C6802.1 75.75,78.81 v2(75.75,80.19) ; C1716.2 129.7,58.73 v2(129.63,58.8) ; v2(118.96,58.78) 118.66,58.78 118.26,59.18 C743.2 ; C2813.2 137.1,23.52 v1(137.17,23.44) ; C4703.2 v1(195.4,10.23) ; v1(201.74,41.27) C3600.1 ; R1553.2 150.01,81.33 149.74,81.6 148.31,81.6 v2(148.14,81.43) ; PC10638.2 16.93,41.8 v1(15.88,41.8) ; v2(69.87,84.39) 70.38,84.89 C6619.1 ; v1(22.42,61.67) 22.14,61.39 C7210.1 ; C2801.2 178.2,26.14 v1(178.45,25.9) ; Q3404.1 20.57,47.52 v1(20.09,47.05) ; v2(46.54,92.83) 46.69,92.68 C7018.1 ; PC9801.2 30.8,104.72 30.07,104.72 v1(29.98,104.63) ; v1(51.2,38.81) R7707.2
  TOP w0.508: C1703.2 80.75,24.97 C1701.2 ; C4203.2 190.95,4.27 v1(190.4,4.82) ; v1(26.12,6.58) 26.12,7.32 PC9517.2 PC9513.2 ; H7900.1 215.4,2.41 ; H7900.1 213.74,2.99 ; H7900.1 212.04,2.45 ; v1(206.83,22.55) 206.66,22.72 205.66,22.72 ; v1(32.27,100.06) 32.93,99.4 PC9800.1 ; v1(35.41,107.59) 35.8,107.59 PC9802.1 ; C5920.2 176.15,103.19 v1(176.15,102.72) ; PC8219.2 v1(66.68,3.24) ; C5939.1 v1(174.26,102.94) ; VC5001.2 v1(12.03,40.41)
  IN1 w0.079: 156.18,78.33 156.18,78.66 155.98,78.86 155.6,78.86 155.29,78.56 155.29,78.18 154.81,77.7 153.31,77.7 153.21,77.6 151.91,77.6 150.85,78.66 150.34,78.66 149.91,79.09 148.69,79.09 v2(148.39,79.4) 148.08,79.09 147.49,79.09 147.22,79.37 147.11,79.44 146.85,79.55 146.39,79.55 146.09,79.25 144.83,79.25 144.6,79.02 v2(143.46,79.02) 143.23,79.25 139.93,79.25 139.73,79.45 139.04,79.45 138.73,79.75 138.73,80.26 138.9,80.43 139.11,80.43 v2(139.26,80.58) ; 155.12,77.19 153.67,77.19 153.59,77.11 151.69,77.11 150.67,78.13 150.17,78.13 149.71,78.59 147.19,78.59 146.94,78.84 v2(146.78,78.84) 146.46,78.84 145.75,78.13 143.3,78.13 142.97,78.46 140,78.46
  IN1 w0.102: 204.16,13.1 204.17,13.11 204.17,14.84 204.4,15.08 204.4,16.42 204.85,16.86 204.85,22.45 202.62,24.69 200.1,24.69 198.03,26.75 195.09,26.75 193.72,28.12 193.24,28.12 192.53,28.83 192.17,28.83 189.2,31.8 v1(189.2,33) v1(189.2,33.63) 188.03,34.8 188.03,36.32 187.17,37.18 187.17,39.16 187.07,39.27 187.07,43.48 v1(187.55,43.97) 187.91,43.97 188.16,43.71 188.16,41.76 187.86,41.45 187.86,37.95 v1(188.13,37.67) 188.13,37.17 188.77,36.52 188.77,35.05 189.9,33.92 189.9,31.84 192.35,29.39 192.76,29.39 193.5,28.65 193.91,28.65 195.31,27.25 198.24,27.25 198.9,26.59 199.34,26.59 v2(199.6,26.33) 199.71,26.22 199.71,25.78 200.31,25.18 201.66,25.18 202.25,25.77 v2(202.69,25.77) 202.69,25.34 205.37,22.67 205.37,16.62 204.9,16.15 204.9,14.86 204.67,14.63 204.67,13.61
  IN1 w0.254: v3(65.91,103.99) 65.91,102.44 65.48,102 61.8,102 59.36,99.57 58.82,99.57 v1(58.29,99.03) ; 72.16,94.46 71.35,94.46 69.87,95.93 68.88,95.93 67.79,97.03 58.8,97.03 v1(58.75,96.97) ; v1(209.31,100.3) v1(206.23,100.3) ; 70.56,85.29 70.99,85.72 70.99,86.51 71.55,87.07 71.55,89.25 71.65,89.35 ; v1(71.53,92.09) 71.53,90.26 v1(71.9,89.89)
  IN1 w0.381: 49.78,27.82 57.31,35.35 57.4,35.35
  IN1 w0.508: v1(85.37,55.37) 65.35,35.35 57.4,35.35
  IN2 w0.254: 78.59,7.39 77.37,7.39 75.94,5.97
  IN3 w0.102: 187.68,2.13 187.65,2.16 187.65,2.92 187.81,3.07 188.82,3.07 189.06,2.83 189.06,2.25 189.71,1.6 205.92,1.6 207.49,3.17 207.49,3.88 208.02,4.42 v1(208.02,4.7)
  IN3 w0.254: 76.25,5.71 76.25,2.32 v1(76.07,2.14)
  BOTTOM w0.079: 63.11,88.61 63.22,88.51 63.22,87.54 U6600.B20
  BOTTOM w0.109: R401.1 148.33,84.18 v2(148.33,84.33) ; v1(161.01,73.4) 161.01,72.92 161.16,72.77 R1562.2 ; 198.22,44.02 197.28,44.02 196.82,43.56 193.64,43.56 193.1,43.02 193.1,42.61 192.45,41.96 192.45,41.65 192.23,41.43 190.7,41.43 190.53,41.59 C4218.1 ; Q6903.4 88.23,80.78 88.01,80.57 v1(87.78,80.57) ; v1(189.23,44.27) 188.92,43.97 v1(187.55,43.97) 187.3,43.71 187.3,42.06 187.58,41.78 188.49,41.78 v1(188.97,42.26)
  BOTTOM w0.14: U5900.K2 U5900.K1 v2(182.11,97.7) ; U400.CB41 128.05,68.26 v2(127.76,67.97)
  BOTTOM w0.178: 70.92,90.65 70.32,90.06 U6600.B11 ; v1(72.51,65.53) 72.8,65.81 U6600.AF8
  BOTTOM w0.203: U400.DR11 v2(143.47,81.86) U400.DU11 ; R5935.2 183.68,89.55 183.36,89.23 v1(181.53,89.23) 181.48,89.28 181.48,90.98 R5932.2 ; v1(185.62,103) 185.83,103.21 R5915.2 ; U400.DV1 144.5,86.58 v2(144.71,86.8) ; v1(36.14,4.84) 36.31,4.84 36.88,5.41 37.23,5.41 37.69,5.86 CON5202.5 ; v1(51.72,23.43) 51.82,23.43 52.22,23.03 JDIM2900.52 ; PU8900.20 91.88,106.6 v1(91.45,107.03) ; 108.34,78.21 U400.V19 ; U400.V19 108.65,77.9 ; U400.V19 108.95,78.21 ; R5924.2 188.51,90.67 188.42,90.57 v2(188.39,90.57) ; U5900.G5 v2(184.3,96.41) ; v2(184.3,96.41) U5900.F5 ; v2(184.3,96.41) 183.97,96.09 U5900.F3 183.74,95.86 U5900.F2 U5900.F1 v2(182.06,95.86) ; 144.02,63.26 U400.DV52 ; U400.DV52 144.32,62.97 ; U400.DV52 143.93,63.65 v2(143.93,63.68) 144.16,63.91 U400.DV51 144.41,63.91 144.6,63.73 ; U400.DV52 144.61,63.26 ; U400.DV52 144.32,63.56 ; U400.DW51 144.95,63.78 145.21,63.52 ; v2(100.24,70.74) 100.35,70.64 101.08,70.64 U400.B36 101.51,70.44 101.52,70.43 U400.D36 ; JDIM2900.48 51.22,21.79 51.59,22.16 v1(51.72,22.16) ; 136.97,73.06 U400.DA30 ; U400.DA30 136.97,73.65 ; U400.DA30 136.68,73.36 ; U400.DA30 137.27,73.36 ; 108.8,79.31 U400.W16 109.11,79.01 ; v1(189.25,54.58) PR8408.2 ; v2(191.29,17.03) 191.45,17.03 191.74,17.32 R4814.1 ; U400.CD48 129.49,64.91 U400.CE49 130.13,64.91 U400.CG48 v2(130.44,64.32) U400.CG51 U400.CG52 ; v1(189.84,52.88) 189.79,52.93 PR8409.1 ; v1(199.25,96.07) 199.25,95.11 v1(199.46,94.89) 199.24,94.89 199.08,94.74 C6109.2 ; U400.DT4 143.52,85.06 v2(143.29,84.82) ; U5900.H11 187.04,97.07 186.88,97.07 U5900.J9 ; U5900.H11 U5900.H12 188.27,96.78 v2(188.32,96.83) ; U5900.H11 187.27,96.78 186.89,96.39 ; 115.11,68.26 U400.AN41 115.4,67.98 ; v2(178.31,91.54) 178.31,91.23 PR8025.2 PR8023.1 ; v2(185.6,96.41) U5900.G7 U5900.J9 ; PC8105.2 190.77,12.14 v2(190.83,12.09) ; 120.6,68.26 U400.BF41 120.89,67.98 ; 101.35,62.97 U400.B52 ; U400.B52 101.35,63.56 ; U400.B52 101.65,63.26 ; U400.B52 101.06,63.26 ; U5900.M2 183.2,98.8 v2(183.42,99.02) 183.66,98.79 U5900.M3 ; U400.Y49 109.01,64.59 U400.W48 ; U400.Y49 U400.Y50 ; U400.Y49 109.65,64.59 U400.AA48 110.29,64.91 U400.AC49 110.93,64.91 U400.AD48 ; U5900.J9 186.83,97.65 v2(186.88,97.65) 186.92,97.7 U5900.K11 U5900.K12 188.26,97.7 188.29,97.72 v2(188.32,97.72) ; U5900.J9 186.25,97.71 v2(186.21,97.71) ; R1001.1 115.36,89.86 v1(114.83,90.4) ; R5926.2 186.91,91.52 186.43,92 v2(186.43,92.59) ; 100.97,85.89 U400.B2 ; U400.B2 101.27,85.58 ; U400.B2 101.58,85.89 ; U400.B2 101.27,86.2 ; v1(51.76,8.51) 52.35,7.93 PR8220.1 ; v1(186.38,103.97) v1(186.38,105.04) v1(186.38,106.13) 186.67,106.42 v1(187.4,106.42) 188.63,106.42 v1(188.63,106.42) 188.63,106.42 v1(189.89,106.42) 190.53,106.42 190.82,106.13 v1(190.82,105.36) v1(190.82,104.51) 190.69,104.37 v1(190.69,102.71) ; 119.78,85.29 U400.BC2 U400.BC1 119.78,86.85 119.76,86.87 v2(119.76,86.97) ; U6600.B8 72.95,87.35 72.95,88.41 73.15,88.61 73.15,88.6 v1(73.15,88.6) ; C1655.2 152,69.29 151.56,69.73 151.56,70.22 151.56,70.22 151.56,70.93 152.16,71.52 U1600.2 ; v2(104.62,87.87) 104.62,87.8 104.6,87.77 104.6,87.63 105.64,86.58 U400.M1 U400.M2 ; PU8901.20 v1(103.94,106.95) ; v1(139.6,91.01) 139.6,90.67 139.42,90.49 139.42,90.27 R1303.2 ; R1030.2 91.72,74.72 v1(91.72,75.77) ; v2(116.35,64.27) U400.AT51 ; U5900.A11 U5900.B11 U5900.B12 188.22,94.02 v2(188.27,94.07) ; PR9210.2 120.49,13.44 120.37,13.56 v2(120.37,13.61) ; U400.CV48 135.69,64.91 U400.CY47 ; PR8016.2 175.53,92.55 v2(175.93,92.15) ; v2(100.16,80.42) 100.29,80.55 101,80.55 U400.B13 101.1,80.55 101.65,80.55 U400.C13 U400.E13 ; 101,64.4 U400.A49 100.38,64.4 v2(100.24,64.25) ; U400.AW2 U400.AW1 117.6,86.59 v2(117.6,86.99) ; U400.CY35 136.62,70.87 ; U400.CY35 136.03,70.87 ; U400.CY35 136.32,70.57 ; U400.CY35 136.32,71.16 ; v2(196.6,87.12) 196.6,87.09 196.18,86.68 R6105.2 ; 186.89,96.39 186.87,96.39 U5900.F9 186.92,95.73 v2(186.92,95.1) ; 186.89,96.39 186.89,96.3 U5900.F11 U5900.F12 188.27,95.86 v2(188.31,95.9) ; U400.CN52 U400.CN51 v2(133,64.39) U400.CN48 ; PU9901.19 54.7,104.53 v1(54.68,104.54) ; R5913.2 193.15,102.08 ; U400.DA33 136.68,72 ; PC9921.2 57.55,97.33 57.86,97.03 58.09,97.03 58.11,97 v1(58.11,96.97) ; 136.03,79.17 U400.CY17 ; U400.CY17 136.32,79.46 ; U400.CY17 136.62,79.17 ; U400.A45 98.97,66.49 98.42,65.95 v2(98.42,65.84) ; C6104.2 189.64,90.29 189.64,90.72 189.97,91.05 R5930.2 ; C1644.1 148.85,64.86 148.94,64.77 R1544.1 R1249.2 ; U400.DM10 141.44,81.94 141.14,81.63 v2(141.14,81.46) ; v2(100.36,69.27) 100.45,69.18 U400.B39 ; v1(79.14,108.26) PU9900.19 ; U400.CV51 U400.CV52 ; C1653.2 148.97,71.19 149.15,71.37 v2(149.37,71.37) ; v2(181.77,94.87) 182.11,94.87 182.18,94.94 U5900.D1 U5900.D2 ; U5900.D11 U5900.D12 188.3,94.94 v2(188.31,94.93) ; R5914.2 190.69,102.07 ; PR8018.1 172.79,101.29 v1(172.56,101.52) ; 117.86,68.26 U400.AY41 118.14,67.98 ; U5900.L12 187.96,98.32 188.44,98.32 v2(188.65,98.52) 188.56,98.62 U5900.M12 ; U400.AK12 v2(113.81,81.02) ; 63.11,88.61 v2(62.67,89.05) ; U400.DD52 U400.DD51 ; v1(202.87,98.29) 202.76,98.29 ; U400.DK51 140.52,64.06 140.52,64.43 v2(140.83,64.74) ; R5922.2 181.94,93.85 v2(182.11,94.02) U5900.B1 U5900.B2 ; v1(200.54,94.87) 200.77,95.1 200.77,96.21 v1(200.37,96.62) v1(200.37,97.84)
  BOTTOM w0.254: U400.D27 U400.B27 U400.A27 v2(100.04,74.33) ; v1(100.22,23.42) 100.32,23.42 100.7,23.04 100.7,21.25 100.72,21.23 JDIM2900.238 ; JDIM2900.172 84.21,21.74 84.6,22.13 v1(84.72,22.13) ; PU9600.3 144.48,92.32 v1(144.61,92.19) ; JDIM2900.210 93.72,22.99 93.3,23.4 v1(93.22,23.4) ; U6101.9 197.55,95.22 v1(197.76,95.43) ; v1(166.09,79.98) 166.18,80.08 CON7701.9 ; v1(125.18,21.61) JDIM2800.36 ; v1(49.72,23.43) 49.92,23.43 50.22,23.13 JDIM2900.44 ; JDIM2900.218 95.72,23.04 95.34,23.42 v1(95.22,23.42) ; JDIM2900.14 42.72,22.13 44.01,23.43 v1(44.22,23.43) ; CON7603.4 4.11,12.55 v1(4.32,12.34) ; JDIM2900.61 54.46,26.85 54.84,26.48 v1(54.97,26.48) ; JDIM2800.72 134.17,23.04 133.78,23.44 v1(133.68,23.44) ; v1(212.29,11.22) 211.84,11.22 211.83,11.22 CON7702.3 ; U400.AH8 U400.AK8 113.88,83.04 v2(114.27,83.43) 114,83.69 U400.AK7 113.69,83.69 v2(113.31,84.07) 113.59,84.34 U400.AK5 U400.AK4 113.57,84.99 v2(113.3,84.72) 113.02,84.99 U400.AH4 ; U400.BV48 126.3,64.91 U400.BU49 125.66,64.91 U400.BT48 125.03,64.91 U400.BP49 ; v1(166.92,25.18) 166.98,25.18 167.43,25.63 JDIM2800.197 ; v2(134.33,82.68) 134.61,82.39 U400.CU9 135.31,81.94 U400.CV10 ; U2006.C1 176.21,105.82 v1(176.39,106) ; U400.DJ1 140.55,86.25 140.55,85.82 U400.DJ2 U400.DJ4 140.92,85.06 v2(141.11,84.86) ; JDIM2900.31 46.97,26.82 46.63,26.49 v1(46.46,26.49) 46.3,26.49 45.97,26.82 JDIM2900.27 ; U400.DR34 v2(143.47,71.38) U400.DU34 ; C5937.2 176.96,63.88 v1(176.96,63.2) ; R4813.2 206.81,18.82 206.68,18.69 206.68,18.29 v2(206.68,18.29) ; JDIM2900.247 102.96,26.89 103.38,26.48 v1(103.47,26.48) ; v2(205.86,109.93) 205.86,109.82 D6314.3 ; v2(118.03,83.4) 118.38,83.04 U400.AY8 ; v2(141.11,84.86) 141.11,84.4 U400.DL5 ; v2(141.11,84.86) U400.DL3 ; v2(141.11,84.86) 141.47,84.86 U400.DM4 ; v1(175.02,23.49) 175.1,23.49 175.68,22.91 JDIM2800.230 ; U400.D32 U400.B32 U400.A32 v2(100.16,72.38) ; v1(4.32,11.71) 3.98,12.05 CON7603.3 ; JDIM2900.98 63.72,21.8 64.05,22.14 v1(64.22,22.14) 64.42,22.14 64.72,21.84 JDIM2900.102 ; v1(14.57,5.98) 14.33,5.75 CON4300.15 ; U400.K48 104.55,64.91 U400.J49 ; U400.K48 105.18,64.91 U400.L49 105.82,64.91 U400.N48 106.46,64.91 U400.P49 107.09,64.59 U400.T48 ; U400.K48 104.89,65.22 U400.L47 U400.L45 U400.L44 U400.L42 ; v2(105.69,74.51) 106,74.2 U400.N28 ; v1(98.22,22.14) 98.1,22.14 97.72,21.76 JDIM2900.226 ; v1(135.68,21.63) JDIM2800.78 ; U400.CJ5 131.18,84.47 v2(131.18,84.85) 131.18,85.31 U400.CJ3 ; U1801.C1 199.51,40 199.26,39.75 ; v1(87.72,22.13) 87.6,22.13 87.21,21.75 JDIM2900.184 ; R1137.2 148.8,81.43 v2(148.14,81.43) ; v1(11.99,2.71) 12.03,2.75 CON4300.3 ; v2(41.87,90.41) 41.94,90.41 42.26,90.1 VRAM7000.G5 ; v1(95.22,22.15) 95.09,22.15 94.72,21.78 JDIM2900.214 ; JDIM2900.22 44.72,21.82 44.38,22.16 v1(44.22,22.16) ; CON4300.9 12.27,4.25 v1(12.08,4.43) ; JDIM2800.52 129.18,23.03 128.78,23.43 v1(128.68,23.43) ; v1(129.68,22.22) 129.76,22.22 130.18,21.81 JDIM2800.56 ; PC8910.1 89.6,107.01 v1(89.6,105.47) ; R1031.2 97.21,83.39 v1(96.85,83.03) 97.2,82.67 R1039.2 ; v1(117.42,24.55) 117.29,24.55 116.91,24.93 116.91,25.25 116.42,25.73 JDIM2800.1 ; PU8900.3 94.26,109.25 PC8908.1 94.08,109.91 v1(93.65,110.34) ; JDIM2900.217 95.47,26.8 95.16,26.49 v1(94.97,26.49) 94.84,26.49 94.47,26.86 JDIM2900.213 ; v1(127.9,8.01) 127.58,8.01 127.14,8.45 CON5000.10 ; JDIM2900.60 54.22,21.79 54.58,22.16 v1(54.72,22.16) ; v1(40.72,21.5) JDIM2900.6 ; v2(159.43,17.98) 160.11,17.31 U5403.5 ; U400.DN1 142.8,86.84 v2(142.8,86.85) 142.8,87.68 143.18,88.06 v1(143.18,88.62) v1(143.18,90.98) 143.18,91.95 143.62,92.39 v1(143.62,93.99) ; JDIM2800.181 163.43,27.26 v1(163.11,26.95) ; v1(175.56,104.12) 175.81,104.37 U2006.B3 ; C4113.1 184.42,83.52 183.77,84.17 183.64,84.17 v1(183.46,84.35) 183.39,84.27 182.34,84.27 182.06,83.99 C4112.1 ; C1654.2 157.55,70.69 158.09,70.16 158.09,69.31 v2(158.01,69.24) ; v1(30.33,40.59) 30.33,40.54 30.3,40.52 R3406.1 30.3,39.7 29.98,39.38 C3407.1 ; U400.DG5 139.32,84.4 139.32,84.01 U400.DG6 139.57,83.6 v2(139.88,83.29) ; v1(46.22,23.42) 46.37,23.42 46.72,23.07 JDIM2900.30 ; U400.K28 104.7,74.2 v2(104.39,74.51) ; VRAM7000.G10 38.24,90.1 37.93,90.41 v2(37.93,90.49) VRAM7000.F10 ; JDIM2800.214 171.68,21.78 171.71,21.81 172.05,22.15 v1(172.18,22.15) ; v1(173.29,26.07) 173.92,26.71 JDIM2800.223 ; U400.D42 U400.B42 ; v1(27.25,40) 27.5,40.25 CON3400.30 ; JDIM2800.252 181.18,21.56 180.77,21.97 180.77,23.69 v1(179.8,24.66) ; CON3400.15 29.18,32.75 v1(29.42,32.52) ; v2(116.8,69.37) 116.99,69.19 U400.AV39 ; v2(108.37,73.18) 108.37,73.17 U400.W30 ; v1(26.54,87.6) 26.58,87.64 PU10200.19 ; v1(100.47,26.48) 100.38,26.48 99.97,26.9 JDIM2900.235 ; JDIM2800.43 126.93,26.42 125.69,25.19 v1(125.42,25.19) 125.22,25.19 124.93,25.48 JDIM2800.35 ; U400.BV3 v2(126.32,84.87) U400.BV5 ; JDIM2800.102 141.68,22.47 141.99,22.78 v1(142.17,22.78) 142.29,22.78 142.68,22.39 JDIM2800.106 ; U400.N39 U400.N41 ; CON4100.39 182.09,70.99 182.42,70.66 182.42,70.3 v1(182.19,70.07) ; JDIM2800.238 177.68,23.01 177.19,23.49 v1(176.96,23.49) ; v1(164.68,22.13) 164.56,22.13 164.17,21.75 JDIM2800.184 ; v1(103.47,25.21) 103.53,25.21 103.96,25.64 JDIM2900.251 ; VRAM7001.F10 38.27,72.9 v2(37.95,72.58) 38.34,72.18 VRAM7001.G10 ; U400.DE3 138.83,85.25 138.83,84.93 v2(138.82,84.91) 138.83,84.89 138.83,84.86 138.67,84.7 138.67,84.39 U400.DE5 ; v1(166.22,57.52) 165.97,57.52 165.88,57.61 CON4204.9 ; JDIM2900.77 58.47,25.67 59.11,25.03 v1(59.22,25.03) ; v1(130.36,27.12) 130.42,27.18 JDIM2800.57 ; R7013.1 50.18,71.23 v1(50.18,72.36) ; R1122.2 v1(147.43,58.47) 147.46,58.5 R1405.2 147.47,58.98 C1101.1 ; v2(37.94,84.88) 38.32,84.5 VRAM7000.P10 ; v1(103.82,23.43) 103.94,23.43 104.22,23.15 JDIM2900.252 ; v2(106.96,81.51) 106.72,81.74 U400.P11 ; v1(131.93,25.21) 132,25.21 132.42,25.63 JDIM2800.65 ; JDIM2900.205 92.47,26.86 92.86,26.46 v1(92.97,26.46) ; JDIM2800.171 160.93,26.87 161.33,26.46 v1(161.43,26.46) ; JDIM2800.217 172.43,26.8 172.33,26.7 172.11,26.49 v1(171.92,26.49) 171.8,26.49 171.43,26.86 JDIM2800.213 ; v1(166.68,22.19) 166.6,22.19 166.18,21.77 JDIM2800.192 ; v1(60.22,23.44) 60.32,23.44 60.72,23.04 JDIM2900.86 ; v2(64.93,87.59) 65.32,87.2 U6600.B17 ; U400.DM33 141.52,72.12 v2(141.26,72.38) ; R617.2 95.55,84.4 95.91,84.77 v1(96.21,84.77) ; v1(174.67,73) 174.55,73 174.36,72.81 174.24,72.81 174.09,72.67 CON4100.7 ; JDIM2900.72 57.22,23.04 56.82,23.44 v1(56.72,23.44) ; v2(107.74,75.02) 107.74,75.21 U400.U25 ; v2(141.21,80.57) 141.21,80.42 U400.DM15 ; C1647.2 148.11,73.39 v2(147.57,73.39) ; v1(126.68,23.43) 126.88,23.43 127.18,23.13 JDIM2800.44 ; JDIM2900.39 48.97,26.85 48.57,26.46 v1(48.46,26.46) 48.09,26.46 47.97,26.58 JDIM2900.35 ; v1(131.93,26.48) 131.8,26.48 131.42,26.85 JDIM2800.61 ; CON4300.27 14.38,8.75 v1(14.55,8.92) ; JDIM2800.15 119.93,27.33 v1(119.31,26.71) ; JDIM2800.180 163.17,21.77 162.78,22.17 v1(162.68,22.17) ; v1(128.42,25.21) 128.52,25.21 128.93,25.61 JDIM2800.51 ; R6703.1 53.26,83.26 v1(52.93,82.93) ; CON7704.5 138.62,9.11 138.83,9.32 139.24,9.32 ; JDIM2800.189 165.43,25.64 165,25.21 v1(164.92,25.21) ; v1(173.18,22.14) 173.3,22.14 173.68,21.76 JDIM2800.222 ; U400.DD33 U400.DD31 ; JDIM2900.223 96.97,26.71 v1(96.33,26.07) ; v1(97.46,86) 97.33,86.13 96.13,86.13 R1000.2 ; v1(139.32,9.4) 139.24,9.32 ; 139.24,9.32 139.12,9.19 CON7704.4 ; v1(135.93,26.48) 135.99,26.48 136.43,26.92 JDIM2800.81 ; R1244.2 140.33,91.31 v1(140.33,90.93) 140.33,90.78 139.9,90.35 R1302.1 ; JDIM2800.22 121.68,21.82 121.34,22.16 v1(121.18,22.16) 121.05,22.16 120.68,21.78 JDIM2800.18 ; v1(86.33,78.36) 86.46,78.23 Q6904.1 ; v1(140.68,21.57) JDIM2800.98 ; JDIM2800.26 122.68,21.88 123,22.2 v1(123.18,22.2) ; v1(131.68,23.43) 131.75,23.43 132.17,23.01 JDIM2800.64 ; JDIM2900.82 59.72,21.78 60.11,22.17 v1(60.22,22.17) ; JDIM2900.188 88.21,23.05 87.87,23.4 v1(87.72,23.4) ; v2(107.78,73.18) 107.35,73.62 U400.T29 ; JDIM2800.196 167.18,23.03 166.75,23.46 v1(166.68,23.46) ; JDIM2900.231 98.97,25.62 98.57,25.22 v1(98.47,25.22) ; v1(176.25,76.43) 176.25,76.91 176.5,77.16 176.5,77.65 176.84,77.98 CON4100.18 ; PC8724.2 187.22,18.28 187.48,18.54 187.69,18.54 v2(187.7,18.55) ; U400.BF39 120.64,69.19 v2(120.46,69.37) ; JDIM2900.201 91.47,26.34 92.62,25.19 v1(92.97,25.19) 93.07,25.19 93.47,25.59 JDIM2900.209 ; U400.AM2 U400.AM1 114.58,86.57 114.6,86.59 114.6,87.07 114.29,87.38 v2(114.22,87.38) ; CON7701.16 163.93,75.36 164.29,75.72 v1(164.4,75.72) ; 213.99,21.46 213.73,21.72 CON7702.24 ; 213.99,21.46 v1(214.04,21.46) ; 213.99,21.46 213.76,21.22 CON7702.23 ; v1(164.92,26.48) 164.79,26.48 164.43,26.85 JDIM2800.185 ; JDIM2800.73 134.43,26.9 134,26.47 v1(133.93,26.47) 133.81,26.47 133.42,26.86 JDIM2800.69 ; PU10200.4 29.25,90.73 29.03,90.96 v1(29.03,90.96) ; v1(126.68,22.16) 126.53,22.16 126.18,21.8 JDIM2800.40 ; U400.H12 103.78,81.09 v2(104.23,81.54) ; v1(65.72,21.54) JDIM2900.106 ; v1(125.42,26.46) 125.53,26.46 125.93,26.85 JDIM2800.39 ; U400.BP49 124.39,64.91 U400.BN48 123.75,64.91 U400.BL49 123.11,64.91 U400.BK48 ; U400.BP49 U400.BP50 ; JDIM2800.6 v1(117.68,22.04) ; U400.BB4 U400.AY4 U400.AV4 U400.AV5 U400.AV7 U400.AV8 117.7,83.04 v2(118.03,82.72) 118.35,82.39 U400.AY9 ; v1(89.74,23.46) 89.82,23.46 90.22,23.06 JDIM2900.196 ; JDIM2900.193 89.47,26.83 89.84,26.45 v1(90.02,26.45) ; C2010.2 176.22,102.79 v1(176.15,102.72) ; U400.DM39 141.52,69.29 v2(141.25,69.57) ; v2(41.88,91.45) 41.88,91.3 42.28,90.9 VRAM7000.F5 ; v1(138.68,21.55) JDIM2800.90 ; JDIM2900.107 65.97,27.42 66.11,27.27 66.11,26.85 65.67,26.41 v1(65.59,26.41) ; v2(103.14,74.51) 103.27,74.38 103.27,74.2 U400.G28 ; R7007.1 49.62,88.5 49.96,88.16 v1(49.96,88.03) ; v2(131.4,69.37) 131.59,69.19 U400.CK39 ; CON3400.37 29.12,43.75 29.4,44.02 30.05,44.02 30.3,43.77 v1(30.3,43.08) ; v1(168.68,21.51) JDIM2800.202 ; PR9117.2 v1(119.22,106.25) ; v1(86.08,27.01) 86.18,27.01 86.47,27.29 JDIM2900.181 ; JDIM2900.189 88.47,25.64 88.04,25.21 v1(87.97,25.21) ; v1(46.22,22.15) 46.04,22.15 45.72,21.83 JDIM2900.26 ; v1(48.22,21.53) JDIM2900.36 ; 108.05,64.59 U400.U49 108.37,64.59 U400.W48 ; JDIM2900.9 41.46,27.14 v1(42.02,26.58) ; U400.DR40 143.09,68.86 v2(143.47,68.86) 143.88,68.86 U400.DU40 U400.DV40 ; U400.DD39 138.2,68.91 137.88,68.59 v2(137.81,68.59) ; JDIM2800.188 165.17,23.05 164.83,23.4 v1(164.68,23.4) ; v2(196.19,14.09) 196.29,14.2 R4742.2 196.29,14.98 C4713.2 ; R1548.1 147.9,77.57 v2(147.56,77.23) ; v2(150.2,66.02) 150.51,66.02 R1219.2 ; C1808.2 202.9,26 202.69,25.8 v2(202.69,25.77) ; PQ9100.4 127.5,104.58 127.69,104.39 127.69,104.39 127.81,104.27 128.25,104.27 128.36,104.39 PR9122.2 ; U400.AD8 111.35,82.75 111.69,82.75 U400.AF8 111.52,83.5 v2(111.52,84.17) v2(111.52,84.73) ; v2(147.49,81.43) 147.49,81.4 148.3,80.59 R1127.2 ; v1(40.46,24.45) 40.33,24.45 39.46,25.31 JDIM2900.1 ; v1(131.24,10.13) 131.14,10.03 CON5000.2 ; v2(188.39,90.57) 188.39,90.37 188.95,89.81 C6104.2 ; v1(137.17,22.17) 137.07,22.17 136.68,21.78 JDIM2800.82 ; v1(59.22,26.3) 59.28,26.3 59.74,26.76 59.74,27.18 59.47,27.46 JDIM2900.81 ; JDIM2800.93 139.43,26.07 140.36,25.13 v1(140.43,25.13) 140.59,25.13 140.93,25.46 JDIM2800.99 ; CON3400.18 29.23,34.25 v1(29.42,34.44) ; v1(49.72,22.16) 49.57,22.16 49.22,21.8 JDIM2900.40 ; JDIM2900.222 96.72,21.76 96.34,22.14 v1(96.22,22.14) ; C3420.1 v1(28.53,56.64) ; U400.W26 108.35,75 108.34,75.01 v2(108.34,75.04) ; v1(161.43,25.19) 161.58,25.19 161.93,25.54 JDIM2800.175 ; PR8024.1 171.65,84.5 v1(171.32,84.83) ; v2(107.86,84.99) U400.V4 ; JDIM2800.89 138.43,26.81 138.1,26.48 v1(137.93,26.48) 137.72,26.48 137.43,26.77 JDIM2800.85 ; R1228.2 137.13,59.16 v1(136.75,58.77) 136.42,59.1 R802.2 ; VRAM7001.B10 38.34,76.1 v2(37.94,75.7) ; C7700.2 121.75,89.37 v1(121.34,88.96) ; JDIM2900.47 50.97,26.82 51.31,26.48 v1(51.46,26.48) ; v1(116.89,22.68) 116.89,21.55 116.68,21.33 JDIM2800.2 ; CON7700.10 16.18,39.19 v1(15.97,39.39) ; JDIM2900.175 84.97,25.54 84.62,25.19 v1(84.47,25.19) ; JDIM2900.192 89.22,21.77 89.64,22.19 v1(89.72,22.19) ; JDIM2900.89 61.47,26.78 61.17,26.49 v1(60.97,26.49) 60.77,26.49 60.47,26.8 JDIM2900.85 ; v1(56.97,26.27) 56.85,26.27 56.46,26.66 JDIM2900.69 ; PC8719.2 109.7,18.23 v1(109.55,18.08) ; JDIM2900.57 53.46,27.18 v1(53.4,27.12) ; U400.P8 106.74,83.04 v2(106.96,83.26) 107.17,83.04 U400.T8 107.66,83.04 v2(107.87,83.26) 108.09,83.04 U400.V8 108.57,83.04 v2(108.86,83.34) 109.15,83.04 U400.Y8 ; PR8013.1 194.21,70.49 v1(193.71,70) ; R6805.2 75.46,93.04 v1(75.6,93.18) ; v2(103.74,74.51) 104.05,74.2 U400.H28 ; JDIM2900.64 55.22,23.01 54.79,23.43 v1(54.72,23.43) ; v2(186.92,95.1) 187.08,94.94 U5900.D11 ; JDIM2800.218 172.68,23.04 172.3,23.42 v1(172.18,23.42) ; JDIM2900.73 57.47,27.29 57.58,27.18 57.58,25.55 57.03,25 v1(56.97,25) ; v2(119.75,81.42) 120.17,81.42 U400.BD12 ; v1(63.97,27.11) JDIM2900.99 ; v1(91.72,21.51) JDIM2900.202 ; U400.BK8 123.09,83.04 v2(123.42,83.37) 123.74,83.04 U400.BM8 ; R620.2 94.72,83.57 v1(94.33,83.18) ; U400.DU46 143.53,66.14 v2(143.47,66.2) 143.41,66.14 U400.DR46 ; U1801.B3 U1801.C3 201.28,40 201.56,40.28 C1800.2 201.78,40.28 201.78,40.9 201.74,40.93 v1(201.74,41.27) ; 59.14,70.28 58.54,70.28 58.11,69.85 U6600.AC26 ; v2(105.04,74.51) 105.35,74.2 U400.L28 ; PC8929.1 103.01,106.46 v1(102.71,106.76) ; v1(100.22,22.15) 100.11,22.15 99.72,21.75 JDIM2900.234 ; v1(128.42,26.48) 128.27,26.48 127.93,26.82 JDIM2800.47 ; v1(147.49,89.12) 147.49,89.6 147.6,89.71 R1412.2 147.6,90.66 v1(147.8,90.86) ; v1(51.46,25.21) 51.56,25.21 51.97,25.61 JDIM2900.51 ; U400.AV12 117.42,81.47 117.12,81.16 v2(117.14,81.13) ; CON4300.33 14.75,10.25 v1(14.9,10.4) ; v1(84.47,26.46) 84.37,26.46 83.97,26.87 JDIM2900.171 ; v1(101.74,21.99) 102.22,21.51 JDIM2900.244 ; v1(41.72,21.52) JDIM2900.10 ; JDIM2900.227 97.97,26.86 98.34,26.49 v1(98.47,26.49) ; CON4300.39 14.49,11.75 v1(14.92,12.17) ; VRAM7000.D10 v2(37.94,92.9) ; U400.DF37 138.92,70.22 U400.DD35 138.27,70.95 ; v2(127.05,82.7) 127.23,82.7 U400.BY9 127.07,81.93 U400.BW10 ; v1(133.68,22.17) 133.56,22.17 133.17,21.79 JDIM2800.68 ; U6600.E17 65.31,84.8 v2(64.89,84.38) ; JDIM2900.19 43.97,26.84 44.34,26.47 v1(44.46,26.47) 44.73,26.47 44.97,26.7 JDIM2900.23 ; JDIM2900.185 87.47,26.85 87.83,26.48 v1(87.97,26.48) ; v2(139.9,69.55) 139.57,69.22 U400.DG39 ; v1(62.47,27.12) JDIM2900.93 ; U6600.AG26 58.02,66.52 v2(58.02,65.9) ; v1(141.88,88.3) 141.76,88.42 141.76,88.8 141.27,89.28 v1(141.27,90.93) ; v1(100.47,25.21) 100.56,25.21 100.97,25.62 JDIM2900.239 ; JDIM2800.193 166.43,26.83 166.8,26.45 v1(166.92,26.45) ; JDIM2900.176 85.21,23.14 v1(85.04,23.31) ; v1(143.77,17.82) 143.86,17.91 PC8605.2 ; v2(136.65,76.27) 136.65,76.35 U400.CY22 ; JDIM2800.107 142.93,26.81 142.53,26.42 v1(142.43,26.42) 142.32,26.42 141.93,26.82 JDIM2800.103 ; v1(65.59,25.14) 65.46,25.14 64.97,25.63 JDIM2900.103 ; JDIM2900.230 98.72,22.99 98.29,23.41 v1(98.22,23.41) ; v1(121.18,23.43) 120.97,23.43 119.68,22.13 JDIM2800.14 ; v1(128.68,22.16) 128.55,22.16 128.18,21.79 JDIM2800.48 ; v1(42.02,24.55) 42.56,24.55 43.15,25.14 43.15,27.2 42.97,27.39 JDIM2900.15 ; U5400.5 90.45,77.29 v1(90.45,77.01) ; v1(160.17,21.51) JDIM2800.168 ; JDIM2900.167 82.97,27.47 83.13,27.3 83.13,26.62 v1(82.98,26.46) ; JDIM2900.65 55.46,25.63 55.04,25.21 v1(54.97,25.21) ; U400.CC3 128.92,85.26 v2(128.92,84.89) 128.79,84.76 U400.CC5 ; v1(52.72,22.15) 52.8,22.15 53.22,21.73 JDIM2900.56 ; PC10503.2 v1(62.78,60.83) ; JDIM2800.94 139.68,22.7 140.45,23.47 v1(140.68,23.47) ; v1(205.21,43.69) 204.77,43.24 D3703.2 ; U400.DR28 v2(143.49,74) U400.DU28 ; v1(118.68,21.6) JDIM2800.10 ; v1(28.34,5.43) 27.78,5.43 27.59,5.62 CON4400.7 ; JDIM2800.172 161.17,21.74 161.56,22.13 v1(161.68,22.13) ; v2(95.86,71.6) 95.84,71.58 95.84,71.22 96.16,70.89 R1417.1 ; v1(124,22.93) 123.67,22.6 123.67,22.04 123.68,22.04 JDIM2800.30 ; U400.DG21 139.24,77.71 v2(139.24,77.82) ; v2(103.17,65.19) 102.93,64.95 U400.E48 102.31,64.95 U400.D49 ; JDIM2900.206 92.72,21.68 93.16,22.13 v1(93.22,22.13) ; JDIM2800.209 170.43,25.61 170.03,25.21 v1(169.87,25.21) ; U400.DG33 139.57,71.72 v2(139.28,71.44) 139.28,71.44 ; JDIM2800.60 131.17,21.79 131.54,22.16 v1(131.68,22.16) ; 144.67,9.65 145.01,9.32 145.34,9.32 145.49,9.17 CON4402.14 ; PR9204.1 121.51,11.42 v1(121.51,10.79) ; v1(159.43,26.46) 159.59,26.46 159.93,26.79 JDIM2800.167 ; U400.DD24 U400.DD26 ; v1(14.59,19.25) 14.59,19.54 14.38,19.75 CON4300.71 ; v2(155.39,73.43) 155.44,73.48 R1576.2 ; v2(104.23,83.47) 104.17,83.47 U400.H8 ; v2(137.84,60.27) R801.2 ; v2(118.88,84) 118.88,83.44 v2(118.96,83.36) 119.28,83.04 U400.BB8 119.62,83.37 v2(119.82,83.37) 120.15,83.04 U400.BD8 120.33,83.04 120.6,83.32 v2(120.69,83.32) 120.85,83.32 U400.BF8 121.29,83.04 v2(121.61,83.37) 121.94,83.04 U400.BH8 ; v1(15.46,15.17) 15.28,14.98 14.63,14.98 14.39,14.75 CON4300.51 ; v1(103.72,22.14) 103.63,22.14 103.22,21.72 JDIM2900.248 ; v1(58.72,21.5) JDIM2900.78 ; v1(12.14,8.66) 12.14,7.57 12.47,7.25 CON4300.21 ; C1652.1 v2(157.44,64.76) ; JDIM2900.94 62.72,21.91 62.47,22.16 v1(62.22,22.16) 61.94,22.16 61.72,21.94 JDIM2900.90 ; JDIM2800.27 122.93,26.82 123.26,26.49 v1(123.42,26.49) 123.55,26.49 123.93,26.86 JDIM2800.31 ; v2(128.86,82.63) 128.9,82.58 U400.CC10 ; v1(40.46,26.99) JDIM2900.5 ; JDIM2900.43 49.97,26.5 48.66,25.19 v1(48.46,25.19) ; JDIM2900.197 90.47,27.46 90.55,27.37 90.55,25.6 90.13,25.18 v1(90.02,25.18) ; R6616.2 70.18,63.75 v1(70.71,64.29) ; v1(40.72,22.77) 40.51,22.77 39.72,21.97 JDIM2900.2 ; v1(137.17,23.44) 137.28,23.44 137.68,23.04 JDIM2800.86 ; JDIM2900.180 86.21,21.77 85.82,22.17 v1(85.72,22.17) ; v1(119.31,24.68) 118.99,24.68 118.18,25.49 118.18,27.2 118.42,27.45 JDIM2800.9 ; JDIM2800.19 120.93,26.84 121.3,26.47 v1(121.42,26.47) 121.52,26.47 121.93,26.87 JDIM2800.23 ; VRAM7000.H1 45.48,89.24 44.8,89.24 VRAM7000.H2 ; v1(101.96,27.1) JDIM2900.243 ; R6712.1 86.83,98.55 v1(86.99,98.39) ; U400.CP3 134.08,85.73 134.08,86.94 133.45,87.57 v2(133.29,87.57) ; U400.BK12 122.85,81.47 122.49,81.11 122.49,80.96 v2(122.53,80.92) ; JDIM2900.68 56.22,21.79 56.6,22.17 v1(56.72,22.17) ; v1(135.93,25.21) 135.81,25.21 135.43,25.6 JDIM2800.77 ; JDIM2800.176 162.17,23.05 161.83,23.4 v1(161.68,23.4) ; v1(14.9,13.42) 14.73,13.25 CON4300.45 ; v1(167.92,75.46) 167.3,76.08 CON7701.1 ; 76.24,4.52 76.24,2.31 v1(76.07,2.14) ; U400.DG27 139.55,74.63 v2(139.55,74.2) ; PC9916.2 v1(57.55,104.27) ; U400.DM27 v2(141.14,75.03) ; v2(133.5,81.4) 133.1,81.4 U400.CN12 ; JDIM2900.168 83.21,21.7 82.78,22.14 v1(82.65,22.14) ; v1(168.43,27.12) JDIM2800.201 ; U400.AT4 116.5,84.94 v2(116.11,84.94) 115.69,84.94 U400.AP4 U400.AM4 ; v1(117.42,27.09) JDIM2800.5
  BOTTOM w0.279: v1(28.98,5.43) 29.09,5.54 CON4400.4
  BOTTOM w0.305: v2(45.15,69.3) 45.14,69.3 VRAM7001.K2 ; VRAM7000.K14 35.55,87.29 v2(35.55,87.29) 35.55,87.29 35.55,87.31 VRAM7000.K13 ; PC8107.1 182.88,11.94 v1(182.5,12.32) ; U6600.AE20 62.84,68.2 v2(62.46,67.82) 62.88,67.41 U6600.AF20 ; VRAM7000.N14 35.09,85.3 v2(34.69,85.7) ; VRAM7001.K1 45.54,69.7 v2(45.94,69.3) ; VRAM7001.A1 45.81,77.17 v2(46.05,77.17) ; v2(60.76,72) 60.68,72 U6600.Y23 ; U6600.U23 60.34,74.8 v2(59.93,74.38) ; VRAM7001.E1 45.97,73.7 v2(46.09,73.58) ; VRAM7000.R3 v2(44.34,83.3) ; U6600.L23 60.34,79.76 v2(59.97,79.39) ; VRAM7001.A12 36.74,76.9 v2(37.14,77.3) ; VRAM7001.T5 v2(42.74,65.3) VRAM7001.R4 ; U6600.E14 v2(68.26,84.38) ; VRAM7000.H13 35.88,89.3 35.54,89.64 v2(35.54,89.7) VRAM7000.H14 ; VRAM7000.M5 42.34,86.13 v2(42.74,86.54) 42.38,86.9 VRAM7000.L5 ; VRAM7000.C14 34.74,93.7 v2(34.69,93.7) ; VRAM7001.C4 43.14,75.3 v2(43.54,75.7) 43.94,75.3 VRAM7001.C3 ; v2(34.71,64.53) 34.71,64.53 VRAM7001.U14 ; VRAM7001.R14 35.53,65.31 v2(35.53,65.31) ; CON4100.57 186.59,72.99 187.83,74.23 v1(188.58,74.23) ; CON5200.5 157.79,8.98 v2(157.83,9.01) ; C4218.1 189.63,41.59 v1(188.97,42.26) ; v2(44.37,65.3) 43.97,65.7 VRAM7001.R3 ; R5408.2 32.6,72.63 v1(32.38,72.84) ; VRAM7001.U3 43.94,63.86 v2(44.31,63.49) 44.32,63.47 v2(44.88,63.47) 45.5,64.1 VRAM7001.U1 ; VRAM7001.H14 v2(35.54,71.7) 35.94,71.3 VRAM7001.H13 ; 183.92,73.14 183.59,72.81 CON4100.45 ; VRAM7000.R12 36.74,83.7 v2(37.14,83.3) 37.14,83.3 VRAM7000.R11 37.54,83.7 v2(37.94,83.3) 38.34,82.9 VRAM7000.T10 ; v2(44.37,66.91) 43.98,67.3 VRAM7001.N3 ; VRAM7001.C14 35.14,75.3 v2(34.74,74.9) ; VRAM7001.C1 46.06,75.3 v2(46.06,75.3) ; VRAM7001.E12 36.74,73.7 v2(36.34,74.1) ; v2(59.17,70.28) 59.14,70.28 59.54,70.68 U6600.AB24 ; v2(45.85,65.3) 45.54,65.61 VRAM7001.R1 ; v2(46.54,92.83) 46.54,92.97 46.18,93.34 45.57,93.34 VRAM7000.C1 ; VRAM7000.L10 38.34,86.86 v2(37.94,86.47) 38.31,86.1 VRAM7000.M10 ; VRAM7000.C12 v2(36.34,93.7) ; PC9914.1 54.68,104.93 v1(54.68,104.54) ; VRAM7000.T5 42.34,82.9 v2(42.74,83.3) 43.14,83.7 VRAM7000.R4 ; VRAM7001.A14 v1(35.53,77.29) ; v2(44.35,91.31) 43.95,91.7 VRAM7000.E3 ; v2(44.34,85.7) 43.94,85.3 VRAM7000.N3 ; U6600.P26 57.96,77.3 v2(58.37,76.89) ; v1(135.35,15.92) 135.35,16.47 C7228.1 134.78,16.88 134.24,17.42 PC9211.2 ; v2(75.75,80.19) U6600.L5 ; VRAM7001.G5 v2(42.73,72.5) 42.73,72.51 VRAM7001.F5 ; v2(60.8,86.81) 60.42,87.2 U6600.B23 ; VRAM7000.N12 36.74,85.3 v2(36.34,84.9) ; v2(37.94,74.9) 38.34,74.5 VRAM7001.D10 ; VRAM7000.C11 v2(37.94,92.9) ; 185.09,72.88 CON4100.51 ; VRAM7001.K14 35.52,69.32 v2(35.56,69.32) VRAM7001.K13 ; v2(37.15,65.3) 37.14,65.3 ; 37.14,65.3 VRAM7001.R11 37.94,65.3 v2(37.98,65.3) 37.97,65.29 37.97,65.27 VRAM7001.T10 ; 37.14,65.3 36.74,65.7 VRAM7001.R12 ; VRAM7000.N1 45.59,85.3 v2(45.97,85.67) ; v2(35.14,81.26) 35.02,81.38 35.02,81.98 VRAM7000.U14 ; U6600.E20 v2(63.29,84.39) ; v2(35.54,74.08) 35.16,73.7 VRAM7001.E14 ; C1404.1 v1(141.25,93.99) ; v1(189.25,54.58) 189.58,54.58 189.63,54.53 PC8400.1 ; v2(36.55,95.48) 36.75,95.28 36.75,94.91 VRAM7000.A12 ; v2(37.98,67.71) 38.34,68.07 VRAM7001.M10 38.34,68.11 v2(37.97,68.48) 37.97,68.49 38.34,68.87 VRAM7001.L10 ; VRAM7000.R1 45.62,83.7 46,83.32 v2(46.03,83.32) ; VRAM7001.C12 36.74,75.3 v2(36.34,75.7) ; VRAM7000.A14 35.47,95.23 v2(35.47,95.34) ; PQ8402.1 v1(190.98,50.56) ; VRAM7000.K1 v2(45.15,87.31) 44.76,87.7 VRAM7000.K2 ; U6600.E25 v2(59.14,85.15) ; VRAM7001.U12 36.63,63.99 36.63,63.55 v2(36.35,63.26) ; v2(41.91,93.68) 41.91,93.64 41.93,93.64 41.93,93.69 VRAM7000.B5 ; VRAM7001.M5 42.34,68.15 v2(42.68,68.5) 42.34,68.84 VRAM7001.L5 ; VRAM7000.E1 45.64,91.6 v2(46.13,91.6) ; U6600.E22 v2(60.77,84.33) ; CON4100.63 188.09,72.87 v1(188.89,73.68) 189.59,72.98 CON4100.69 ; C1406.1 v1(143,93.99) ; v2(36.34,66.9) VRAM7001.N12 ; v1(203.81,43.74) 203.53,43.46 EC3702.2 ; CON4100.33 180.59,70.94 181.15,70.38 181.15,70.15 181.46,69.84 181.96,69.84 v1(182.19,70.07) ; VRAM7000.E14 35.5,92.06 v2(35.5,92.09) ; VRAM7001.C11 37.54,75.3 v2(37.14,75.7) ; U6600.H25 58.75,82.26 v2(59.14,82.65) ; v2(67.4,86.8) 67.8,87.2 U6600.B14 ; R7005.1 v1(31.44,70.58) ; v2(44.34,77.46) 44.34,77.3 VRAM7001.A3 ; VRAM7001.H2 44.74,71.35 v2(45.11,71.73) VRAM7001.H1 ; v1(31.44,69.49) 31.65,69.7 C7001.1 ; U6600.A26 57.79,88 v2(57.43,87.65) 57.43,87.49 U6600.B27 ; VRAM7000.A3 43.94,94.93 v2(44.35,95.35) 44.4,95.39 45.05,95.39 VRAM7000.A1 ; VRAM7000.U12 36.56,81.92 36.56,81.43 v2(36.4,81.27) ; U6600.H23 v2(59.92,82.68) ; v1(175.59,70.61) CON4100.13 ; U6600.Y26 58.31,71.97 v2(58.31,71.93) ; v2(46.07,67.83) VRAM7001.N1 ; VRAM7000.C3 v2(43.55,93.69) 43.16,93.3 VRAM7000.C4 ; VRAM7000.B10 v2(37.94,94.5) ; v2(46,89.76) VRAM7000.H1 ; VRAM7000.R14 34.78,83.7 v2(34.19,83.1) ; U6600.P23 v2(60.74,77.7) ; VRAM7000.E12 v2(36.34,92.1) ; v2(46.56,82.48) 46.56,82.3 46.23,81.96 45.68,81.96 VRAM7000.U1 45.05,81.61 44.43,81.61 VRAM7000.U3 ; VRAM7001.N14 v2(34.74,67.7) ; U6600.L25 58.74,79.73 59.09,79.38 v2(59.09,79.36) ; v1(76.34,105.23) PC9903.2 ; v2(37.98,66.9) 37.97,66.89 37.97,66.87 VRAM7001.P10 ; U6600.U26 57.94,74.84 v2(58.31,75.21)
  BOTTOM w0.381: Q501.1 v1(94.59,67.86) ; v1(94.16,67.08) 94.54,66.7 R513.1 ; C5604.2 201.22,31.36 v1(201.14,31.43) ; U6600.K15 66.98,81.16 U6600.L14 67.85,80.3 v1(68.36,79.79) 68.84,79.31 U6600.M13 U6600.N12 70.34,77.8 v1(70.34,77.7) 70.74,77.3 U6600.P11 U6600.R10 71.8,76.26 v1(72.35,75.71) ; C6808.2 v1(49.36,55.87) ; v1(31.44,72.87) 31.39,72.87 31.37,72.9 31.87,73.4 C7061.2 ; R1008.1 93.87,63.9 v1(94.7,64.73) ; D6306.2 207.93,106.16 207.19,106.91 v1(207.19,107.36) ; PC8411.2 87.05,16.96 v1(86.5,17.51) 86.23,17.78 PD8402.2 ; v1(81.61,77.49) 82.01,77.9 R6914.1 R6916.1 ; C6105.2 192.15,90.57 191.44,91.29 v2(191.44,91.31) ; C6680.1 v1(76.66,59.63) ; C6810.2 v1(38.09,58.53) ; v1(91.84,105.53) 91.84,105.37 91.39,104.92 PR8841.2 ; v1(40.59,78.44) 40.37,78.65 C7023.2 ; U6600.AD21 v2(62.44,68.6) ; PC9906.1 79.55,108.26 v1(79.14,108.26) ; v1(159.93,10.63) 159.87,10.57 C5203.3 ; PU8201.2 59.79,3.76 59.69,3.86 v1(59.41,3.86) ; C1646.1 152.91,81.31 v1(152.91,81.63) ; v1(186.38,103.97) 187.22,103.97 Y5900.2 ; v1(200.16,90.28) C6210.3 ; v1(210.4,111.74) 210.33,111.67 R6319.1 ; PQ8003.1 196.22,74.21 v1(195.51,74.93) ; PR10211.2 30.35,93.52 29.33,94.54 v1(29.13,94.54) ; C6216.1 200.02,82.62 200.08,82.56 200.08,82.47 v1(200.1,82.45) ; v1(206.83,22.55) 206.83,22.7 D4206.1 ; PC10208.2 32.64,91.07 v1(32.22,90.65) ; PQ8403.1 157.52,62.21 157.33,62.4 v2(157.33,62.66) ; v1(81.3,65.52) Q6600.1 ; C1644.1 148.85,65.49 149.12,65.76 v2(149.15,65.76) ; v1(58.97,61.83) C6633.1 ; C5406.2 93.68,81.88 v1(93.47,82.09) ; v1(190.82,105.36) 189.73,105.36 Y5900.4 ; Y6800.4 73.76,94.8 v1(72.97,95.59) ; PQ8400.3 188.57,56.82 v1(188.54,56.79) ; C6901.2 84.3,84.66 v1(83.89,84.25) ; D3702.2 213.63,28.7 v1(214.07,28.27) 214.07,27.89 213.31,27.12 CON7702.32 ; U6600.AD22 v2(61.62,68.62) ; v1(24.18,89.43) 24.25,89.51 PC10207.1 ; U6601.3 v1(77.33,60.21) ; CON4204.5 160.38,65.36 159.81,64.79 159.81,63.95 159.75,63.88 159.75,63.88 159.76,63.87 v2(159.76,63.87) ; v2(68.98,89.14) 68.98,90.33 68.04,91.26 R6912.1 ; v1(72.54,77.71) 72.43,77.71 U6600.N10 U6600.M11 v1(70.35,79.79) U6600.L12 U6600.K13 ; v1(33.16,61.07) 32.83,60.74 C5405.1 ; Q500.1 92.86,66.71 93.31,66.26 v1(93.39,66.18) ; v2(182.11,97.7) 182.07,97.66 C5918.1 ; v1(64.32,72.78) U6600.V17 U6600.U18 ; U6600.K17 65.15,80.99 U6600.L16 66,80.3 v1(66.42,79.88) 66.42,79.72 U6600.M15 U6600.N14 67.84,78.28 v1(68.28,77.84) 68.82,77.3 U6600.P13 U6600.R12 v1(70.34,75.8) U6600.T11 U6600.U10 72.28,73.86 v1(72.28,73.67) ; U6600.AC22 v2(61.64,69.4) ; v1(66.05,3.24) PC8225.1 ; U6600.L18 63.84,80.12 v1(64.19,79.77) 64.37,79.77 U6600.M17 64.98,79.16 U6600.N16 U6600.P15 U6600.R14 67.9,76.3 v1(68.45,75.75) 68.84,75.36 U6600.T13 U6600.U12 70.04,74.1 70.04,73.93 v1(70.32,73.64) 70.66,73.3 U6600.V11 ; v1(47.22,12.59) 47.76,12.06 C5045.1 ; v1(81.58,75.77) R6917.1 ; 174.85,68.46 173.6,69.72 173.6,70.18 ; v1(42.12,79.81) C7007.1 ; v1(81.8,70.53) 83.82,70.53 84.15,70.2 Q6901.4 ; C6211.3 199.57,69.6 v1(199.65,69.52) ; v1(26.34,92.12) 26.34,91.57 PC10218.1 ; v1(87.17,82.42) 86.93,82.66 Q6903.1 ; v1(44.6,79.17) C7033.1 ; v1(35.76,79.45) C7055.2 ; v1(169.46,80.79) 169.63,80.62 C4111.2 C4110.1 ; v1(135.35,15.92) 135.35,15.49 135.7,15.15 PC8602.1 PC8603.1 ; v2(207.71,26.48) 207.71,27.1 207.21,27.61 EC3701.2 ; v1(210.06,27.62) 209.45,27.62 EC3700.2 ; v1(74.32,11.56) 74.33,11.57 74.38,11.57 74.49,11.67 PC8217.2 PC8406.2 ; C7218.2 170.85,84.04 171.32,84.5 v1(171.32,84.83) ; U6600.L10 U6600.K11 v1(70.41,81.73) ; U6600.AF23 v2(60.79,67.8) ; U6600.V13 68.41,73.73 68.25,73.73 68.24,73.74 v1(68.24,73.75) 68.24,73.9 U6600.U14 U6600.T15 U6600.R16 U6600.P17 U6600.N18 ; 197.25,82.37 196.88,82 R6112.2 ; v1(33.66,56.8) Q5401.1 ; U6101.5 195.45,93.87 v1(195.17,93.6) ; PC8409.1 82.21,16.27 v1(82.73,16.8) 83.17,16.36 PC8410.1 ; U6600.V15 v1(66.43,73.71) U6600.U16 U6600.T17 U6600.R18 ; v1(195.5,79.84) 195.16,80.19 C6103.1 ; v1(88.24,66.68) 88.4,66.83 R511.1 ; PC9100.2 v1(110.39,107.75)
  BOTTOM w0.508: CON4204.8 164.85,68.58 v1(164.42,68.15) ; v1(174.88,59.51) 174.88,58.84 CON4204.11 ; PC8619.2 164.19,15.87 v1(164.27,15.8) ; U6901.3 83.08,100.25 v1(83.3,100.47) ; v1(81.51,78.89) R6915.1 ; CON5400.1 28.17,65.14 27.99,64.96 v1(27.19,64.96) ; 217.08,23.14 215.61,23.14 CON7702.35 ; D6307.2 208.64,112.98 v1(208.81,113.15) ; v1(180.34,89.23) 180.15,89.04 PC8004.2 ; CON7702.34 216.81,17.47 ; R6918.1 R6919.1 v1(81.56,80.11) ; v1(85.56,110.06) 84.78,110.84 PC8801.1 ; v1(91.31,98.27) 91.31,98.01 91.55,97.77 C6900.1 C6714.1 ; v3(93.39,94.6) 92.9,95.09 C711.2 ; v1(84.57,98.42) 84.7,98.29 84.7,97.87 U6701.3 ; v1(82.49,63.09) 82.3,62.9 Q6601.1
  vias: v1(0.79,9.04) v1(0.81,15.44) v1(0.84,3.83) v1(3.38,9.14) v1(4.16,9.14) v1(4.32,18.16) v1(4.6,14.35) v1(4.8,34.41) v1(4.8,28.82) v1(4.8,23.23) v1(5.16,0.85) v1(6.28,39.29) v1(6.74,30.43) v1(6.74,29.79) v1(6.74,29.16) v1(7.01,26.85) v1(7.01,26.22) v1(7.77,30.93) v1(7.77,29.44) v1(8,2.85) v1(8.66,17.14) v1(8.76,37.21) v1(8.74,36.57) v1(9.23,23.29) v1(9.41,18.95) v1(9.63,43.45) v1(10.74,0.85) v1(10.89,15.52) v1(10.96,14.32) v1(11.06,8.65) v1(12.13,39.5) v1(12.52,1.52) v1(12.61,48.15) v1(12.62,44.57) v1(13.16,45.64) v1(13.16,45.01) v1(14.3,28.39) v1(14.3,27.51) v1(14.92,53.18) v1(15.31,27.51) v1(15.39,39.7) v1(15.42,33.47) v1(15.42,32.84) v1(15.77,20.29) v1(15.97,40.82) v1(15.97,40.19) v1(16.42,18.72) v1(18.05,57.26) v1(18.5,67.66) v1(18.95,19.94) v1(19.15,62.64) v1(19.23,16) v1(19.54,29.59) v1(19.58,19.94) v1(19.68,7.95) v1(19.78,13.33) v1(19.78,12.39) v1(20.27,18.31) v1(20.57,22.58) v1(20.57,21.93) v1(20.61,25.43) v1(20.61,24.78) v1(20.67,20.7) v1(21.09,15.48) v1(21.2,17.35) v1(21.51,57.94) v1(21.76,14.57) v1(21.83,80.55) v1(21.87,6.55) v1(21.95,52.78) v1(22.24,49.01) v1(22.25,25.4) v1(22.29,8.59) v1(22.38,66.85) v1(22.3,33.81) v1(22.56,52.5) v1(22.55,22.16) v1(22.88,49.03) v1(22.95,15.21) v1(22.99,14.15) v1(23.06,79.02) v1(23.1,54.67) v1(23.26,85.85) v1(23.74,3.2) v1(24.23,11.03) v1(24.6,91.18) v1(25.12,11.03) v1(25.09,7.85) v1(25.24,63.01) v1(25.32,59.23) v1(25.4,53.34) v1(25.42,4.42) v1(25.67,64.01) v1(25.67,41.05) v1(26.02,96.51) v1(26,10.99) v1(26.16,22.76) v1(27.07,70.58) v1(27.07,69.95) v1(27.07,69.31) v1(27.11,76.71) v1(27.2,90.45) v1(27.19,64.33) v1(27.4,59.59) v1(27.76,92.73) v1(27.77,76.71) v1(27.78,76.06) v1(27.78,75.43) v1(27.71,70.61) v1(27.76,34.26) v1(27.91,64.41) v1(28.01,73.36) v1(28.01,72.74) v1(28.34,42.75) v1(28.75,50.24) v1(28.78,49.6) v1(29.16,85.42) v1(29.31,3.29) v1(29.49,57.71) v1(29.57,92) v1(29.59,42.67) v1(29.94,94.87) v1(30.6,92.12) v1(30.96,59.63) v1(31.16,24.58) v1(31.44,74.04) v1(32,11.12) v1(32.03,10.08) v1(32.6,44.26) v1(33.02,42.17) v1(33.02,41.07) v1(33.16,62.09) v1(33.16,59.58) v1(33.22,44.21) v1(33.25,32.41) v1(33.37,10.21) v1(33.48,24.55) v1(33.58,28) v1(33.7,29.64) v1(33.7,16.23) v1(33.7,14.86) v1(34.26,3.3) v1(34.52,104.09) v1(34.52,102.94) v1(35.23,14.5) v1(35.42,24.81) v1(35.66,104.06) v1(35.66,102.94) v1(36.8,59.31) v1(37.24,12.88) v1(38.38,96.54) v1(38.47,4.84) v1(38.61,83.03) v1(39.1,4.84) v1(39.39,40.77) v1(39.39,40.14) v1(39.54,47.47) v1(39.59,9.65) v1(39.85,3.3) v1(40.05,60.45) v1(40.08,47.78) v1(40.1,44.88) v1(40.23,13.59) v1(40.46,25.72) v1(40.87,14.22) v1(40.87,13.59) v1(41.48,15.52) v1(41.62,4.86) v1(42.98,12.89) v1(43.26,58.35) v1(43.65,12.82) v1(43.86,32.99) v1(43.89,58.35) v1(43.92,40.07) v1(44.06,56.71) v1(44.24,39.04) v1(44.35,53.59) v1(44.48,43.52) v1(44.46,25.2) v1(44.53,58.35) v1(45.16,58.35) v1(45.13,5.44) v1(45.44,3.3) v1(45.77,44.78) v1(45.77,5.44) v1(45.79,50.59) v1(46.22,79.26) v1(46.46,25.22) v1(46.4,5.44) v1(47.7,100.4) v1(47.83,13.99) v1(48.22,23.56) v1(48.44,101.09) v1(48.59,4.82) v1(49.07,48.92) v1(48.99,13.54) v1(48.99,12.04) v1(49.17,5.45) v1(49.58,42.24) v1(49.63,13.54) v1(49.63,12.04) v1(49.81,5.45) v1(50.06,45.74) v1(50.25,13.54) v1(50.25,12.04) v1(50.44,5.44) v1(50.77,98.17) v1(50.87,13.54) v1(50.87,12.04) v1(50.87,11.38) v1(51.03,3.3) v1(52.04,56) v1(52.07,46.17) v1(52.35,67.56) v1(52.88,67.97) v1(53.21,101.02) v1(53.72,50.34) v1(53.85,101.02) v1(54.81,8.48) v1(54.84,0.81) v1(55.15,57.12) v1(55.22,11.17) v1(55.57,3.71) v1(56.48,6.3) v1(56.48,5.3) v1(57.48,6.3) v1(57.48,5.3) v1(58.11,97.61) v1(58.48,6.3) v1(58.48,5.3) v1(58.75,97.61) v1(58.72,23.53) v1(58.85,61.06) v1(59.48,17.19) v1(59.46,16.56) v1(59.81,15.9) v1(60.12,17.19) v1(60.12,16.56) v1(60.3,55.4) v1(60.75,17.19) v1(60.93,56.06) v1(60.92,55.4) v1(61.34,14.39) v1(61.57,56.19) v1(61.56,55.53) v1(62.02,47.55) v1(62.15,13.84) v1(63.77,56.26) v1(64.23,73.91) v1(64.39,61.8) v1(64.77,9.22) v1(64.89,92.91) v1(65.02,61.82) v1(65.61,113.62) v1(65.99,61.83) v1(66.44,0.79) v1(66.75,22.95) v1(66.88,113.62) v1(67.1,24.56) v1(68.05,57.7) v1(68.15,113.62) v1(68.27,61.36) v1(69.42,113.62) v1(69.39,55.98) v1(70.11,90.95) v1(70.69,113.62) v1(71.58,8.58) v1(71.96,113.62) v1(71.96,7.31) v1(72.03,0.79) v1(72.2,92.09) v1(72.54,108.84) v1(72.54,108.18) v1(72.54,107.49) v1(73.23,113.62) v1(73.82,92.1) v1(74.5,113.62) v1(74.91,76.06) v1(75.52,110.36) v1(75.52,109.7) v1(75.52,109.07) v1(75.77,113.62) v1(77.04,113.62) v1(77.52,18.26) v1(77.95,17.45) v1(78.15,18.26) v1(78.28,66.32) v1(78.31,113.62) v1(78.46,88.29) v1(79.24,87.11) v1(79.37,84.78) v1(79.45,7.34) v1(79.58,113.62) v1(80.5,18.09) v1(80.85,113.62) v1(81.18,23.96) v1(81.23,72.72) v1(81.41,18.09) v1(83.06,81.46) v1(83.16,14.96) v1(83.28,83.94) v1(83.36,82.37) v1(83.51,76.27) v1(83.61,72.58) v1(83.87,99.39) v1(84.1,100.3) v1(84.21,112.02) v1(84.2,108) v1(84.2,105.86) v1(84.66,73.53) v1(84.88,101.7) v1(84.81,100.3) v1(85.04,7.34) v1(85.27,106.93) v1(86.08,24.97) v1(86.1,73.86) v1(86.31,108) v1(86.31,105.86) v1(86.33,70.08) v1(86.44,113.62) v1(86.5,68.77) v1(86.65,78.99) v1(87.78,17.07) v1(88.03,94.34) v1(88.26,74.47) v1(88.24,73.12) v1(88.75,97.3) v1(88.95,85.62) v1(89.3,81.18) v1(89.86,82.73) v1(90.17,84.81) v1(90.63,7.34) v1(90.83,13.84) v1(90.9,81.71) v1(91.72,73.2) v1(91.72,23.54) v1(92.03,113.62) v1(92.56,107.8) v1(93.4,104.95) v1(93.72,107.34) v1(93.72,106.71) v1(93.75,69.06) v1(94.14,105.59) v1(94.14,104.95) v1(94.64,10.46) v1(94.87,105.59) v1(94.87,104.95) v1(94.79,63.27) v1(94.97,25.22) v1(95.25,64.33) v1(95.27,10.46) v1(95.61,105.59) v1(95.61,104.95) v1(96.11,11.71) v1(96.33,24.03) v1(96.67,5.92) v1(96.99,111.94) v1(97.07,75.22) v1(97.14,74.57) v1(97.62,113.62) v1(97.61,75.55) v1(97.76,111.94) v1(101.02,86.76) v1(101.74,24.03) v1(103.07,8.28) v1(103.51,90.74) v1(103.75,12.11) v1(103.99,16.89) v1(104.12,91.56) v1(104.28,11.52) v1(104.29,111.05) v1(104.77,12.11) v1(104.77,10.94) v1(105.05,6.96) v1(105.57,105.23) v1(106.02,91.54) v1(106.32,107.69) v1(106.32,107.06) v1(106.31,105.23) v1(106.37,0.89) v1(106.41,105.86) v1(107.04,105.23) v1(107.47,26.59) v1(107.56,9.3) v1(107.65,105.86) v1(107.78,105.23) v1(108.25,25.22) v1(108.28,18.08) v1(108.38,91.69) v1(108.33,10.28) v1(108.81,35) v1(108.84,34.36) v1(108.91,18.08) v1(109.19,10.34) v1(109.29,35.46) v1(109.6,22.04) v1(109.65,12.47) v1(109.78,35.89) v1(109.8,3.66) v1(109.95,91.03) v1(109.9,24.64) v1(109.9,23.92) v1(109.93,23.26) v1(110.06,11.5) v1(110.06,10.87) v1(111.05,91.05) v1(111.09,28.56) v1(111.09,27.92) v1(111.09,27.29) v1(111.71,28.9) v1(111.71,28.27) v1(111.71,27.63) v1(112.16,91.06) v1(113.87,15.54) v1(113.81,12.18) v1(114.09,78.76) v1(114.48,13.74) v1(114.43,12.18) v1(114.6,15.01) v1(115.09,16.18) v1(115.05,12.12) v1(115.39,3.66) v1(115.67,12.17) v1(115.72,16.18) v1(115.87,8.1) v1(116.08,12.63) v1(116.69,97.74) v1(117.14,100.74) v1(117.14,100.1) v1(117.14,99.44) v1(117.42,25.82) v1(117.6,107.67) v1(117.71,101.11) v1(117.72,100.46) v1(117.72,99.8) v1(118.23,37.01) v1(118.23,36.37) v1(118.23,35.74) v1(118.23,35.1) v1(119.33,105.52) v1(120.7,95.49) v1(120.7,94.83) v1(120.72,17.22) v1(120.98,3.66) v1(121.33,95.48) v1(121.33,94.82) v1(121.63,17.38) v1(121.97,94.79) v1(122.27,17.38) v1(122.26,12.43) v1(122.77,10.8) v1(123.18,23.47) v1(123.42,25.22) v1(123.59,14.04) v1(123.92,94.33) v1(126.39,113.54) v1(126.44,17.56) v1(126.57,3.66) v1(126.82,77) v1(127.46,77) v1(127.56,12.48) v1(127.66,113.54) v1(127.66,112.27) v1(127.98,16.97) v1(128.09,77) v1(128.45,93.16) v1(128.52,17.57) v1(128.65,71.81) v1(128.74,77.03) v1(128.98,111) v1(128.98,91.05) v1(129,113.31) v1(129.08,93.16) v1(129.28,17.57) v1(129.61,11.76) v1(129.77,111.73) v1(129.79,110.16) v1(129.84,71.77) v1(130.22,11.76) v1(130.36,25.09) v1(130.5,105.53) v1(130.89,71.75) v1(131.55,71.74) v1(132.15,3.66) v1(132.46,6.58) v1(132.58,71.73) v1(132.69,94.56) v1(132.71,96.62) v1(132.71,95.68) v1(132.97,18.23) v1(133.6,18.23) v1(133.77,71.7) v1(133.93,25.2) v1(134.93,12.31) v1(135.68,23.66) v1(135.77,91.57) v1(135.81,14.4) v1(136.76,16.83) v1(137.39,16.78) v1(137.89,91.36) v1(138.03,16.78) v1(139.48,6.37) v1(139.9,93.98) v1(140.31,95.76) v1(140.44,13.61) v1(140.56,93.98) v1(140.72,16.6) v1(140.84,9.98) v1(143.33,96.01) v1(143.56,10.54) v1(144.23,24.06) v1(145.75,94.43) v1(146.6,17.73) v1(147.23,17.73) v1(147.65,5.61) v1(147.87,17.73) v1(148.55,7.62) v1(149.42,11.85) v1(150.04,11.85) v1(150.8,97.26) v1(151.97,20.7) v1(152.93,96.26) v1(154.43,51.33) v1(154.63,11.41) v1(154.84,22.79) v1(155.94,11.41) v1(155.93,6.44) v1(156.33,95.6) v1(156.33,93.24) v1(156.57,6.44) v1(156.87,95.25) v1(156.79,92.78) v1(156.99,24.52) v1(157,11.4) v1(158.12,107.62) v1(158.17,23.34) v1(159.05,14.65) v1(160.02,59.11) v1(160.07,14.65) v1(160.34,77.45) v1(161.52,89.28) v1(161.68,70.77) v1(161.8,7.59) v1(162.23,70.19) v1(162.79,63.83) v1(162.79,62.94) v1(162.79,62.05) v1(163.17,57.66) v1(163.11,24.92) v1(163.71,107.62) v1(164.06,63.83) v1(164.06,62.94) v1(164.06,62.05) v1(164.15,86.57) v1(164.49,8.1) v1(164.71,86.24) v1(165.02,13.15) v1(165.33,63.83) v1(165.33,62.94) v1(165.33,62.05) v1(165.85,78.27) v1(165.83,13.17) v1(166.49,106.1) v1(166.49,105.48) v1(166.57,13.17) v1(167.13,106.1) v1(167.13,105.48) v1(167.69,61.59) v1(167.71,62.96) v1(167.88,64.78) v1(167.99,13.15) v1(168.68,23.54) v1(168.73,13.15) v1(169.09,8.28) v1(169.16,106.11) v1(169.29,107.62) v1(169.42,35.02) v1(169.8,106.11) v1(169.87,26.48) v1(169.84,22.21) v1(170.08,61.06) v1(170.18,23.4) v1(170.38,68.37) v1(170.36,39.49) v1(170.43,106.11) v1(170.53,35.89) v1(170.77,41.4) v1(170.74,13.97) v1(171.07,106.11) v1(171.04,96.59) v1(171.32,66.98) v1(171.7,70.03) v1(171.92,25.22) v1(172.03,95.58) v1(173.23,23.98) v1(173.71,73.25) v1(174.22,100.78) v1(174.78,105.66) v1(174.88,107.62) v1(175.02,22.22) v1(175.23,68.46) v1(175.25,26.42) v1(175.25,25.15) v1(175.31,100.94) v1(175.93,68.46) v1(176.01,73) v1(176.43,63.52) v1(176.58,68.45) v1(176.93,25.39) v1(176.96,22.22) v1(177,24.13) v1(177.2,40.77) v1(177.27,39.07) v1(177.75,39.95) v1(177.85,6.32) v1(178.15,13.13) v1(178.37,51.27) v1(178.47,60.49) v1(178.45,39.03) v1(178.52,40.81) v1(178.84,23.65) v1(178.81,21.56) v1(179.3,51.81) v1(179.42,69.9) v1(179.42,67.73) v1(179.58,50.1) v1(179.75,102.54) v1(179.8,25.93) v1(180.01,71.63) v1(180.11,90.47) v1(180.2,22.42) v1(180.62,66.85) v1(180.85,94.49) v1(180.9,4.14) v1(181.3,17.75) v1(181.79,68.76) v1(181.79,68.04) v1(181.73,66.93) v1(181.96,26.41) v1(182.1,74.27) v1(182.38,59.65) v1(182.37,47.73) v1(183.36,52.07) v1(183.84,7.72) v1(184.73,74.57) v1(184.73,73.81) v1(184.81,17.68) v1(184.99,21.75) v1(184.96,20.72) v1(185.67,73.96) v1(185.67,73.2) v1(186.15,54.73) v1(186.1,5.41) v1(186.99,102.34) v1(187.14,35.12) v1(187.42,59.41) v1(187.6,101.59) v1(188.16,4.85) v1(188.64,45.57) v1(188.6,10.2) v1(188.78,4.85) v1(189.25,66.49) v1(189.2,58.72) v1(189.2,57.97) v1(190.27,7.31) v1(190.48,101.55) v1(190.5,10.61) v1(191.21,87.2) v1(191.21,85.29) v1(191.21,83.39) v1(191.49,102.97) v1(191.84,104.87) v1(192.02,86.1) v1(192.33,7.34) v1(193.11,87.2) v1(193.11,85.29) v1(193.11,83.39) v1(193.33,73.42) v1(193.31,72.78) v1(193.31,72.15) v1(193.33,50.8) v1(193.65,52.88) v1(193.62,39.44) v1(193.62,37.92) v1(193.62,36.93) v1(194,54.53) v1(194,50.8) v1(194,49.78) v1(194.46,37) v1(195.15,39.44) v1(195.15,37.92) v1(195.48,106.42) v1(195.42,78.65) v1(195.81,95.5) v1(196.09,69.9) v1(196.11,5.72) v1(196.49,103.81) v1(196.67,39.37) v1(196.59,37.84) v1(196.59,36.52) v1(197.29,83.08) v1(197.97,97.36) v1(198.06,84.14) v1(198.05,83.08) v1(198.14,99.46) v1(198.45,45.59) v1(198.68,67.03) v1(199.01,49.56) v1(199.31,45.59) v1(199.57,67.56) v1(199.63,49.57) v1(200.14,65.84) v1(200.43,52.93) v1(200.61,63.22) v1(200.71,44.4) v1(201.34,99.29) v1(201.55,90.29) v1(201.55,79.4) v1(201.57,6.72) v1(202.18,44.42) v1(202.26,10.21) v1(202.36,6.74) v1(202.87,97.66) v1(202.94,96.82) v1(204.19,111.73) v1(204.59,45.11) v1(204.85,62.86) v1(204.85,0.79) v1(204.92,52.91) v1(205.24,80.01) v1(205.33,64.76) v1(205.41,104.87) v1(205.46,101.98) v1(205.44,84.24) v1(205.61,99.6) v1(205.99,43.63) v1(206.32,113.04) v1(206.35,110.94) v1(206.55,107.16) v1(206.65,107.8) v1(206.68,104.87) v1(206.67,62.32) v1(206.65,61.66) v1(207.24,110.69) v1(207.39,104.87) v1(207.33,62.38) v1(207.53,46.78) v1(207.64,57.84) v1(207.87,110.69) v1(207.85,61.06) v1(208.54,107.92) v1(208.68,104.87) v1(208.76,111.35) v1(208.73,0.78) v1(209.17,83) v1(209.32,102.11) v1(209.5,82.17) v1(209.77,113.24) v1(209.73,64.24) v1(209.88,100.01) v1(209.87,80.57) v1(210.24,43.36) v1(210.94,101.68) v1(210.98,83.86) v1(211.57,101.68) v1(211.88,61.15) v1(212.21,101.68) v1(212.27,10.56) v1(212.95,103.32) v1(213.99,119.45) v1(214.35,81.92) v1(214.36,63.53) v1(214.45,101.25) v1(216.18,114.22) v1(216.38,103.12) v1(216.48,12.15) v1(216.99,21.46) v1(217.02,26.87) v1(217.93,114.2) v2(34.74,74.08) v2(34.74,66.9) v2(37.15,87.31) v2(37.14,69.37) v2(37.95,91.34) v2(38.93,69.82) v2(41.27,88.51) v2(41.54,74.26) v2(41.56,71.21) v2(42.74,76.5) v2(44.34,73.33) v2(47.74,91.49) v2(52.73,71.84) v2(53.73,74.6) v2(53.87,73.23) v2(54.07,77.4) v2(54.71,81.47) v2(54.76,75.79) v2(55.24,78.37) v2(55.45,71.78) v2(55.5,77.01) v2(55.6,70.53) v2(55.86,74.44) v2(56.51,75.21) v2(56.56,69.54) v2(56.72,68.53) v2(60.74,79.38) v2(60.88,91.09) v2(60.86,74.39) v2(62.02,91.06) v2(62.45,69.39) v2(63.29,70.28) v2(64.11,68.61) v2(64.92,89.25) v2(64.93,68.59) v2(64.96,67.76) v2(65.37,90.86) v2(65.5,89.89) v2(65.79,68.59) v2(65.79,67.8) v2(66.57,70.25) v2(67.42,68.6) v2(67.4,67.76) v2(67.52,89.27) v2(69.91,70.19) v2(69.91,68.68) v2(70.74,70.22) v2(71.55,61.24) v2(71.55,59.6) v2(72.82,61.24) v2(72.82,59.6) v2(72.97,81.94) v2(73.22,70.22) v2(74.09,61.24) v2(74.09,59.6) v2(74.17,81.84) v2(74.89,86.8) v2(74.93,81.84) v2(75.36,61.24) v2(75.36,59.6) v2(75.54,66.93) v2(75.74,81.86) v2(75.74,81.02) v2(75.77,72.76) v2(76.52,76.9) v2(76.54,76.04) v2(76.58,74.42) v2(76.55,72.76) v2(77.32,76.88) v2(77.35,76.04) v2(78.14,74.42) v2(78.26,69.58) v2(95.33,69.19) v2(96.41,71.6) v2(96.72,65.84) v2(96.91,68.42) v2(97.01,69.27) v2(98.03,68.42) v2(98.03,67.11) v2(98.56,64.25) v2(98.68,69.27) v2(99.71,68.42) v2(99.69,67.22) v2(100.1,65.74) v2(102.01,83.94) v2(102.08,59.81) v2(102.28,63.64) v2(102.36,68.03) v2(102.87,61.16) v2(103.09,77.26) v2(103.15,63.48) v2(103.21,81.82) v2(103.21,71.77) v2(103.57,58.89) v2(103.6,57.76) v2(103.74,77.26) v2(103.83,71.78) v2(104.25,84.1) v2(104.37,60.31) v2(104.39,79.14) v2(104.41,78.13) v2(104.39,77.26) v2(104.48,71.77) v2(104.52,61.97) v2(104.89,67.3) v2(104.89,66.73) v2(105.04,77.26) v2(105.08,71.78) v2(105.69,77.26) v2(105.7,71.77) v2(106.19,60.9) v2(106.35,79.22) v2(106.39,78.19) v2(106.3,71.78) v2(106.4,77.26) v2(106.72,66.67) v2(106.94,85.02) v2(107.22,56.97) v2(107.53,66.63) v2(107.66,77.8) v2(107.68,64.22) v2(107.67,59.95) v2(108.3,77.82) v2(108.44,60.78) v2(108.55,68.62) v2(108.55,67.32) v2(108.55,66.1) v2(108.78,85.01) v2(108.93,62.18) v2(109.21,59.15) v2(109.29,78.8) v2(109.43,67.97) v2(109.71,71.94) v2(110.29,71.94) v2(110.38,66.67) v2(110.58,83.73) v2(110.88,71.94) v2(110.86,61.47) v2(110.86,60.35) v2(111.33,78.11) v2(111.47,85.28) v2(111.92,78.11) v2(112.08,88.72) v2(112.07,87.07) v2(112.28,71.94) v2(112.21,67.97) v2(112.21,67.32) v2(112.21,66.05) v2(112.47,78.11) v2(112.51,62.13) v2(112.86,71.94) v2(113,87.27) v2(113.03,78.11) v2(113.24,60.68) v2(113.24,57.89) v2(113.58,78.11) v2(114.15,78.11) v2(114.28,71.95) v2(114.65,59.62) v2(114.67,57.92) v2(114.67,56.81) v2(114.66,55.12) v2(114.7,78.11) v2(114.86,71.95) v2(114.93,67.97) v2(114.95,67.32) v2(114.95,66.69) v2(114.95,66.07) v2(115.11,83.44) v2(115.17,61.93) v2(115.26,78.11) v2(115.44,71.95) v2(115.55,75.68) v2(116.12,75.68) v2(116.2,87.96) v2(116.58,78.12) v2(116.69,75.68) v2(116.79,71.95) v2(117.25,75.67) v2(117.37,71.95) v2(117.47,89.61) v2(117.47,87.86) v2(117.7,67.97) v2(117.7,67.32) v2(117.7,66.67) v2(117.7,66.07) v2(117.81,75.67) v2(117.97,71.95) v2(118.09,78.18) v2(118.42,79.76) v2(118.43,75.65) v2(118.62,89.61) v2(118.62,87.86) v2(118.98,75.65) v2(118.96,62.13) v2(118.96,60.46) v2(118.96,57.1) v2(118.96,55.43) v2(118.96,54.31) v2(119.55,75.65) v2(119.76,88.72) v2(119.82,83.98) v2(120.11,75.65) v2(120.44,67.97) v2(120.44,67.32) v2(120.44,66.15) v2(120.69,83.94) v2(121.46,62.03) v2(121.5,60.91) v2(121.5,57.56) v2(121.5,55.88) v2(121.61,83.95) v2(122.22,71.7) v2(122.54,83.93) v2(122.53,83.37) v2(122.78,71.7) v2(122.77,61.6) v2(123.24,67.32) v2(123.24,66.07) v2(123.34,71.7) v2(123.78,61.8) v2(123.78,60.13) v2(123.78,56.77) v2(123.87,74.06) v2(123.86,73.49) v2(123.88,71.7) v2(124.33,83.89) v2(124.43,74.06) v2(124.41,73.49) v2(124.47,71.7) v2(124.53,78.4) v2(124.87,78.9) v2(124.98,74.06) v2(124.97,73.49) v2(125.02,66.67) v2(125.14,78.38) v2(125.5,78.85) v2(125.53,74.06) v2(125.8,88.87) v2(126.45,61.04) v2(126.45,59.36) v2(126.57,87.98) v2(126.85,67.97) v2(126.85,67.32) v2(126.85,66.67) v2(127.54,89.06) v2(127.53,87.31) v2(128.34,59.85) v2(128.43,61.52) v2(128.55,88.9) v2(128.5,78.38) v2(128.68,66.67) v2(128.88,83.38) v2(129.06,78.4) v2(129.43,88.73) v2(129.63,60.48) v2(130.58,88.72) v2(130.51,67.97) v2(130.51,67.32) v2(130.51,66.67) v2(130.51,66.05) v2(130.75,82.69) v2(131.43,88.69) v2(131.49,91.62) v2(131.66,82.7) v2(131.86,62.23) v2(131.86,60.56) v2(131.86,58.88) v2(132.43,88.86) v2(132.89,60.27) v2(133.05,91.03) v2(133.25,67.97) v2(133.25,67.32) v2(133.25,66.67) v2(133.7,75.61) v2(134.11,84.73) v2(134.27,78.8) v2(134.29,79.37) v2(134.43,62.26) v2(134.45,60.58) v2(134.44,58.9) v2(135.08,89.84) v2(135.43,80.13) v2(135.47,64.42) v2(135.66,62.7) v2(135.91,79.42) v2(135.94,78.79) v2(136.07,88.68) v2(136,85) v2(136.08,75.44) v2(136,66.65) v2(136,66.07) v2(136.17,61.8) v2(136.14,60.72) v2(136.69,71.3) v2(136.96,89.16) v2(137.52,88.32) v2(137.57,61.63) v2(138.08,88.29) v2(138.42,64.27) v2(138.74,71.44) v2(138.85,66.92) v2(139.47,88.55) v2(139.47,59.64) v2(139.5,62.25) v2(141.67,66.91) v2(141.77,77.82) v2(142.71,62.16) v2(143.47,76.57) v2(146.16,68.43) v2(146.49,66.58) v2(146.51,65.2) v2(147.04,71.92) v2(148.31,75.97) v2(153.71,101.04) v2(154.25,101.04) v2(154.76,78.43) v2(155.37,75.53) v2(155.97,66.6) v2(156.65,69.26) v2(170.1,72.64) v2(170.3,76.56) v2(175.52,96.76) v2(175.93,99.14) v2(175.93,94.63) v2(177.33,96.79) v2(177.67,67.94) v2(177.72,99.16) v2(177.78,94.6) v2(177.72,92.23) v2(178.43,92.91) v2(178.61,98.68) v2(178.92,95.48) v2(179.75,94.13) v2(180.06,96.57) v2(180.08,95.55) v2(180.11,97.91) v2(187.45,20.81) v2(187.63,17.65) v2(189.25,14.68) v2(190.68,95.24) v2(190.68,93.09) v2(190.76,98.3) v2(191.36,14.97) v2(191.77,100.29) v2(192.47,98.32) v2(192.48,95.26) v2(192.47,93.08) v2(192.78,91.95) v2(193.14,27.12) v2(193.28,95.74) v2(193.29,94.66) v2(193.58,100.32) v2(193.95,93.17) v2(194.13,100.84) v2(194.16,97.77) v2(194.21,99.54) v2(194.45,25.47) v2(196.06,25.68) v2(196.81,97.52) v2(199.24,88.54) v2(199.51,20.42) v2(201.29,22.04) v2(202.21,15.83) v2(205.08,11.28) v3(30.17,85.88) v3(30.17,85.14) v3(30.17,84.41) v3(30.17,83.67) v3(30.85,85.48) v3(30.85,84.74) v3(30.84,84) v3(30.85,83.28) v3(30.89,86.21) v3(48.38,100.4) v3(49.12,101.14) v3(49.12,100.4) v3(49.27,101.85) v3(49.86,100.4) v3(52.3,99.79) v3(53.03,99.82) v3(53.77,99.85) v3(61.75,7.94) v3(61.75,7.21) v3(61.75,6.47) v3(62,5.73) v3(62.48,7.94) v3(62.48,7.21) v3(62.48,6.47) v3(62.74,5.73) v3(63.47,5.73) v3(64.18,103.99) v3(64.92,111.43) v3(64.92,110.67) v3(64.92,109.9) v3(64.92,109.14) v3(64.92,108.38) v3(64.92,107.62) v3(65.02,103.99) v3(65.45,112.09) v3(66.88,103.99) v3(67.74,103.99) v3(67.84,17.83) v3(67.84,17.09) v3(68.58,17.83) v3(68.58,17.09) v3(68.63,103.99) v3(69.31,17.83) v3(69.31,17.09) v3(69.44,103.99) v3(70.2,103.99) v3(71.8,112.72) v3(72.57,112.72) v3(73.33,112.72) v3(74.09,112.72) v3(74.34,110.49) v3(74.34,109.73) v3(74.34,108.96) v3(78.76,110.97) v3(89.18,11.78) v3(89.74,15.08) v3(89.91,11.78) v3(90.47,15.08) v3(90.65,11.78) v3(91.21,15.08) v3(91.39,11.78) v3(94.13,94.57) v3(94.86,94.57) v3(95.6,94.57) v3(96.15,103.98) v3(96.76,17.58) v3(96.8,104.96) v3(97.57,104.95) v3(97.52,18.33) v3(97.52,17.6) v3(98.26,18.33) v3(98.26,17.6) v3(98.36,104.94) v3(98.36,104.17) v3(98.99,18.33) v3(98.99,17.6) v3(99.73,18.33) v3(102.4,105.73) v3(102.41,105) v3(103.13,105.73) v3(103.14,105) v3(103.88,105.75) v3(103.88,105) v3(104.85,104.29) v3(109.89,103.22) v3(110.69,103.22) v3(112.6,108.91) v3(113.21,109.34) v3(113.23,108.56) v3(117.12,108.51) v3(117.92,108.51) v3(118.68,108.51) v3(124.03,102.49) v3(124.79,102.49) v3(125.55,102.49) v3(126.31,102.49) v3(127.07,102.49) v3(127.84,102.49) v3(128.6,102.49) v3(129.26,101.83) v3(129.36,102.57) v3(130,101.85) v3(130.12,102.56) v3(130.73,101.85) v3(130.89,102.56) v3(169.59,13.22) v3(173.03,15) v3(173.76,15) v3(174.56,15) v3(175.29,15)

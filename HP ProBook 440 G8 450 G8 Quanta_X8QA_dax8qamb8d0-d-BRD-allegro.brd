# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.8V_DEEP_SUS on TOP (solid shape): outline of 81 points within 149.12,78.36 153.9,81.1
+1.8V_DEEP_SUS on TOP (solid shape): outline of 359 points within 86.23,55.12 97.86,69.9
+1.8V_DEEP_SUS on BOTTOM (solid shape): 175.59,65.35 176.1,65.35 176.22,65.22 176.22,64.72 176.1,64.59 175.33,64.59 174.06,65.86 173.68,65.86 173.18,66.37 173.18,66.75 173.3,66.88 174.06,66.88
+1.8V_DEEP_SUS on BOTTOM (solid shape): 150.43,71.54 150.43,71.17 150.72,70.88 151,70.88 151.35,70.53 151.35,69.64 151.58,69.41 151.59,69.19 151.53,69.14 151.18,69.14 151.13,69.19 151.13,69.59 151.04,69.68 150.84,69.68 150.72,69.8 150.72,70.28 150.59,70.41 150.29,70.41 150.11,70.58 149.6,70.58 149.5,70.69 149.5,71.02 149.57,71.09 149.96,71.09 150.11,71.24 150.11,71.52 150.16,71.57 150.39,71.57
+1.8V_DEEP_SUS on BOTTOM (solid shape): outline of 392 points within 134.97,74.83 138.64,78.9
+1.8V_DEEP_SUS on SVCC (solid shape): outline of 851 points within 75,13.79 185.72,85.42
+1.8V_DEEP_SUS on IN2 (solid shape): 77.11,20.09 77.11,18.11 76.95,17.94 73.11,17.94 72.97,18.08 72.97,20.09 73.07,20.19 77.01,20.19
+1.8V_DEEP_SUS on IN2 (solid shape): 136.88,75.61 136.88,75.38 136.35,74.85 136.35,74.02 136.31,73.93 136.34,73.68 136.46,73.56 136.47,73.56 137.01,73.02 137.01,72.08 136.45,71.52 136.42,71.48 136.38,71.39 136.37,71.3 136.39,71.19 136.45,71.09 136.45,70.3 136.17,70.03 136.16,70.02 136.04,69.91 136,69.75 136,69.71 136.01,69.67 135.99,69.58 135.91,69.54 135.51,69.54 135.4,69.65 135.41,69.68 135.43,69.74 135.43,69.8 135.42,69.89 135.38,69.98 135.38,70.2 135.95,70.77 135.95,71.28 135.95,71.31 135.95,71.74 136.02,71.8 136.04,71.81 136.25,71.9 136.34,72.12 136.3,72.27 136.19,72.39 136.19,72.77 136.12,72.84 136.11,72.89 136.08,72.91 135.84,73.15 135.84,73.48 135.84,73.49 135.84,75.04 135.87,75.12 135.95,75.15 136.01,75.12 136.08,75.12 136.09,75.12 136.3,75.2 136.41,75.4 136.42,75.41 136.42,75.61 136.5,75.69 136.8,75.69
+1.8V_DEEP_SUS on IN2 (solid shape): outline of 402 points within 46.3,38.63 65.38,45.16
+1.8V_DEEP_SUS on IN2 (solid shape): outline of 795 points within 32.74,19.05 39.52,29.87
+1.8V_DEEP_SUS on IN3 (solid shape): 180.79,30.89 180.79,30.71 180.8,30.65 180.83,30.61 181.65,29.79 181.65,29.51 181.49,29.35 180.94,29.35 180.85,29.41 180.86,29.52 180.92,29.62 180.94,29.74 180.84,29.98 180.6,30.08 180.52,30.07 180.45,30.05 180.36,30.04 180.31,30.1 180.24,30.21 180.15,30.29 180.1,30.35 180.11,30.43 180.14,30.51 180.16,30.6 180.13,30.73 180.05,30.84 180.02,30.91 180.05,30.98 180.23,31.16 180.51,31.16
+1.8V_DEEP_SUS on IN3 (solid shape): outline of 85 points within 171.81,41.07 174.04,43.99
+1.8V_DEEP_SUS_F on TOP (solid shape): 12.36,13.33 12.36,12.56 12.36,12.56 12.36,11.74 12.28,11.66 11.41,11.66 10.55,12.51 10.47,12.51 10.47,12.53 9.87,12.53 9.86,12.51 9.69,12.51 9.6,12.6 9.6,12.73 9.72,12.85 9.84,12.85 9.86,12.83 10.47,12.83 10.47,12.84 11.05,13.42 12.27,13.42
+1.8V_DEEP_SUS_R on TOP (solid shape): 174.81,71.13 174.81,70.95 174.79,70.93 174.64,70.8 174.59,70.61 174.7,70.35 174.95,70.25 174.99,70.25 175.05,70.26 175.28,70.02 175.28,69.2 175.23,69.15 175.14,69.15 175.1,69.19 175.1,69.95 175.09,69.96 174.89,69.96 174.87,69.93 174.87,69.13 174.8,69.06 174.19,69.06 173.66,68.53 171.96,68.53 171.63,68.86 171.63,69.4 172.1,69.88 172.1,70.16 172.08,70.18 172.08,70.19 171.99,70.34 171.84,70.43 171.83,70.43 171.63,70.64 171.63,71.32 171.61,71.33 171.61,71.96 171.28,72.29 170.46,72.29 170.41,72.34 170.41,72.49 170.44,72.64 170.41,72.79 170.41,73.2 170.69,73.48 172.46,73.48
+1.8V_R on TOP (solid shape): 177.87,72.49 177.87,71.63 177.98,71.52 178.43,71.52 178.84,71.11 178.84,69.94 178.46,69.56 178.46,69.09 178.38,69.01 177.28,69.01 177.23,69.02 176.8,69.02 176.7,69.12 176.7,69.14 177.09,69.14 177.09,69.94 176.88,69.94 176.88,69.14 176.7,69.14 176.7,70.19 176.71,70.21 176.73,70.26 176.74,70.31 176.75,70.36 176.75,70.41 176.74,70.45 176.73,70.5 176.71,70.55 176.7,70.57 176.7,71.31 176.73,71.35 176.73,72.57 176.78,72.62 177.75,72.62
+1.8VPCU_R on TOP (solid shape): 131.62,16.36 131.62,13.97 131.29,13.64 130.68,13.64 130.02,12.98 128.83,12.98 128.7,13.1 128.7,13.38 128.55,13.53 128.55,16.38 128.73,16.56 131.42,16.56
+1.8VPCU_R on BOTTOM (solid shape): 132.69,17.75 132.69,16.82 132.66,16.75 132.59,16.72 132.4,16.65 132.28,16.5 132.22,16.45 132.15,16.44 132.09,16.46 132.03,16.47 131.77,16.36 131.66,16.1 131.74,15.88 131.93,15.75 131.99,15.71 132,15.63 131.99,15.6 131.99,15.57 132.1,15.31 132.36,15.2 132.65,15.2 132.79,15.06 132.79,13.23 132.68,13.11 132.63,12.95 132.63,12.9 130.35,12.9 130.2,12.75 130.2,12.27 130.1,12.16 129.26,12.16 129.16,12.27 129.16,12.74 128.52,13.38 128.52,16.88 128.83,17.19 130.41,17.19 130.89,17.67 130.91,17.72 130.91,17.74 130.91,18.08 130.94,18.11 132.33,18.11
+2.5VSUS on TOP (solid shape): 109.52,26.82 109.52,26.39 109.42,26.29 108.05,26.29 107.92,26.41 107.92,26.82 107.74,27 107.31,27 106.14,28.17 106.14,28.9 106.42,29.18 107.16,29.18
+2.5VSUS on TOP (solid shape): 171.81,22.9 171.82,22.88 171.81,22.83 171.81,22.79 171.81,22.73 171.83,22.66 171.83,22.28 171.81,22.21 171.81,22.15 171.81,22.09 171.83,22.03 171.83,21.65 171.81,21.58 171.81,21.52 171.81,21.46 171.83,21.39 171.83,21.33 171.98,21.18 172.02,21.18 172.1,21.16 172.18,21.15 172.23,21.15 172.3,21.17 172.33,21.16 172.44,21.05 172.44,20.11 171.98,19.66 171.33,19.66 170.15,20.83 170.15,21.24 170.16,21.27 170.17,21.28 170.32,21.58 170.17,21.87 170.16,21.88 170.15,21.91 170.15,22.01 170.16,22.02 170.2,22.11 170.21,22.21 170.2,22.31 170.16,22.4 170.15,22.41 170.15,22.58 170.77,23.2 171.51,23.2
+2.5VSUS on TOP (solid shape): outline of 198 points within 177.67,19.61 184.35,28.65
+2.5VSUS on BOTTOM (solid shape): 107.72,29.33 107.72,27.56 107.44,27.28 105.51,27.28 105.33,27.46 105.33,27.54 105.84,27.54 105.84,29.29 105.59,29.29 105.59,27.54 105.34,27.54 105.34,29.29 105.33,29.29 105.33,29.46 105.37,29.5 107.56,29.5
+2.5VSUS on BOTTOM (solid shape): 184.03,29.27 184.03,26.74 183.79,26.5 183.59,26.5 183.56,26.48 183.51,26.46 183.48,26.42 183.44,26.39 183.42,26.34 183.4,26.31 183.3,26.21 182.58,26.21 182.58,26.21 182.52,26.21 182.33,26.41 182.33,26.56 182.27,26.62 182.27,26.87 182.29,26.91 182.3,26.96 182.31,27.02 182.31,27.07 182.3,27.13 182.29,27.18 182.26,27.23 182.23,27.27 182.2,27.32 182.2,27.34 182.3,27.46 182.3,27.54 182.8,27.54 182.8,29.29 182.55,29.29 182.55,27.54 182.3,27.54 182.3,29.31 182.42,29.44 183.87,29.44
+2.5VSUS on IN2 (solid shape): 171.8,22.83 171.8,20.17 170.92,19.28 164.49,19.28 164.35,19.15 127.48,19.15 127.38,19.25 127.38,20.37 127.73,20.72 157.83,20.72 158.49,20.72 158.64,20.88 170.13,20.88 170.45,21.2 170.45,21.27 170.53,21.36 170.53,22.32 171.19,22.98 171.65,22.98
+2.5VSUS on IN2 (solid shape): outline of 927 points within 105.92,19.2 120.55,29.79
+2.5VSUS_S on TOP (solid shape): 186.54,27.58 186.54,26.8 186.31,26.58 185.04,26.58 184.85,26.77 184.85,27.83 184.86,27.87 184.9,27.88 186.23,27.88
+2.5VSUS_S on BOTTOM (solid shape): outline of 226 points within 183.69,14.09 187.75,27.58
+3V on TOP (solid shape): 16.08,26.41 16.08,23.29 15.83,23.05 12.18,23.05 12.11,23.11 12.11,24.2 12.22,24.31 14.22,24.31 14.53,24.61 14.53,26.39 14.68,26.54 15.95,26.54
+3V on TOP (solid shape): 88.36,70.36 88.36,68.14 87.45,67.23 87.45,64.46 86.03,63.04 86.03,59.23 85.98,59.18 85.11,59.18 84.94,59.36 84.94,61.47 85.06,61.59 85.06,63.66 86.31,64.9 86.31,67.46 87.42,68.58 87.42,70.69 87.58,70.84 87.87,70.84
+3V on TOP (solid shape): 106.42,26.29 106.42,25.83 106.3,25.7 105.47,25.7 105.44,25.72 105.44,25.74 105.31,25.91 105.12,25.98 105.05,26.01 105.03,26.08 104.82,26.29 104.24,26.29 104.11,26.41 104.11,27 104.24,27.12 105.59,27.12
+3V on TOP (solid shape): 23.44,60.35 23.44,59.28 23.28,59.11 21.76,59.11 21.66,59.17 21.54,59.18 21.44,59.17 21.34,59.12 21.33,59.11 21.27,59.11 21.02,58.86 21.02,58.1 20.58,57.67 20.58,53.95 20.41,53.77 19.61,53.77 19.15,54.23 19.15,57.06 19.17,57.14 19.28,57.25 19.28,57.7 19.83,60.57 20.04,60.78 23.01,60.78
+3V on TOP (solid shape): 30.33,11.6 30.33,9.67 30.21,9.41 30.32,9.14 30.33,9.12 30.33,9.11 30.58,8.86 30.58,7.66 30.41,7.5 29,7.5 28.9,7.59 28.9,10.4 28.75,10.55 28.75,11.55 28.82,11.62 30.21,11.62 30.26,11.63 30.3,11.63
+3V on TOP (solid shape): 153.17,11.97 153.17,10.69 153.06,10.58 152.33,10.58 152.03,10.28 147.48,10.28 147.23,10.04 146.99,10.04 146.83,10.2 146.83,10.79 146.88,10.84 146.91,10.85 146.93,10.85 146.98,10.85 147.09,10.88 147.18,10.96 147.18,10.96 147.39,11.17 150.04,11.17 150.32,11.45 152.02,11.45 152.11,11.54 152.19,11.61 152.25,11.7 152.25,11.71 152.29,11.75 152.29,11.96 152.45,12.11 153.03,12.11
+3V on TOP (solid shape): 58.58,53.52 58.66,53.56 58.74,53.54 59.91,52.36 59.91,51.97 59.62,51.68 59.55,51.63 59.5,51.58 55.83,51.58 55.83,51.59 54.58,51.59 54.15,52.02 54.15,53.15 54.43,53.43 57.9,53.43 58.03,53.29 58.22,53.24 58.43,53.3 58.56,53.48
+3V on TOP (solid shape): 150.7,74.55 150.7,74.38 150.67,74.35 150.65,74.35 150.54,74.28 150.46,74.16 150.46,73.91 150.53,73.81 150.62,73.74 150.62,73.2 150.48,73.07 150.48,72.32 150.62,72.18 150.62,72.03 150.56,71.97 150.14,71.97 150.09,72.01 150.09,72.36 150.21,72.49 150.21,72.97 150.09,73.09 149.52,73.09 149.41,72.97 149.15,72.97 149.12,73.01 149.12,73.41 149.16,73.46 149.41,73.46 149.51,73.56 149.91,73.56 149.98,73.63 149.98,74.29 150.34,74.65 150.61,74.65
+3V on TOP (solid shape): 199.03,54.94 199.03,54.73 199.04,54.71 199.05,54.64 199.05,54.25 199.04,54.22 199.04,53.5 199.04,53.5 199.16,53.39 199.16,53.03 199.16,52.86 199.25,52.71 199.26,52.7 199.26,52.68 199.26,51.31 199.39,51.18 200.66,51.18 200.76,51.08 200.76,50.8 200.66,50.7 199.11,50.7 198.87,50.94 198.87,51.37 198.78,51.46 197.46,51.46 197.27,51.64 197.27,52.11 198.14,52.98 198.14,54.99 198.22,55.06 198.91,55.06
+3V on TOP (solid shape): 18.64,10.97 18.64,10.67 18.69,10.61 19.05,10.61 19.91,9.75 19.91,9.42 20.22,9.12 20.22,8.91 20.19,8.89 19.84,8.89 19.32,8.37 18.77,8.37 18.65,8.25 18.49,8.25 18.25,8.35 18,8.25 17.81,8.25 17.65,8.27 17.56,8.27 17.53,8.27 17.49,8.25 17.4,8.25 17.24,8.41 17.24,9.09 17.25,9.09 17.25,9.24 17.35,9.34 17.35,9.93 17.4,9.98 17.8,9.98 17.98,10.16 17.98,10.61 18.08,10.72 18.11,10.72 18.44,11.05 18.57,11.05
+3V on TOP (solid shape): 92.58,17.63 92.58,16.23 92.89,15.91 92.89,15.45 92.97,15.37 93.02,15.33 93.07,15.28 93.35,15.28 93.44,15.19 93.44,10.06 93.52,9.98 93.52,9.4 92.42,9.4 92.25,9.57 92.25,9.57 92,9.83 92,11.86 91.69,12.16 91.69,15.06 91.62,15.13 91.62,15.15 91.5,15.37 91.28,15.49 91.26,15.49 91.16,15.59 91.16,16.68 91.21,16.78 91.22,16.89 91.21,17 91.16,17.1 91.16,17.5 91.16,17.7 91.31,17.85 92.35,17.85
+3V on TOP (solid shape): 202.8,62.95 203.16,62.95 203.43,62.68 203.43,60.4 203.3,60.27 202.16,60.27 202.03,60.4 202.03,61.03 201.83,61.23 201.5,61.23 201.39,61.23 201.14,61.23 200.93,61.44 200.93,62.09 200.93,62.24 200.8,62.43 200.58,62.51 200.44,62.48 200.32,62.4 199.55,62.4 199.38,62.23 199.38,61.77 199.18,61.57 199.18,61.21 199.06,61.08 198.88,61.08 198.73,61.24 198.73,62.51 198.74,62.59 199.01,62.86 199.87,62.86 199.93,62.85 199.97,62.85 200.02,62.85 200.07,62.86 200.51,62.86 200.56,62.85 200.61,62.85 200.65,62.85 200.76,62.86 200.8,62.91 200.86,62.95 200.9,62.96 202.79,62.96
+3V on TOP (solid shape): outline of 87 points within 189.53,11.58 191.95,13.08
+3V on TOP (solid shape): 186.9,44 186.9,43.82 186.94,43.79 186.91,43.73 186.9,43.72 186.8,43.6 186.76,43.43 186.76,43.41 186.83,43.19 187.02,43.06 187.04,43.05 187.46,42.63 187.54,42.63 187.56,42.55 187.54,42.51 187.53,42.51 187.45,42.38 187.42,42.24 187.52,41.98 187.78,41.87 188.03,41.97 188.14,42.22 188.15,42.26 188.39,42.26 189.11,41.54 189.12,41.53 189.18,41.42 189.28,41.36 189.3,41.36 189.38,41.36 189.43,41.35 189.48,41.34 189.52,41.35 189.57,41.36 190.35,41.36 190.51,41.34 190.55,41.33 190.6,41.34 190.76,41.36 191.22,41.36 191.29,41.43 192.07,41.43 193.09,40.41 193.09,39.65 193.06,39.62 192.04,39.62 191.97,39.69 191.62,39.69 191.5,39.8 191.34,39.85 191.32,39.85 191.15,40.02 191.15,40.17 191.15,40.2 190.88,40.46 189.1,40.46 188.8,40.76 188.8,40.99 188.74,41.14 188.59,41.21 187.53,41.21 187.47,41.21 187.39,41.19 187.32,41.14 187.29,41.13 187.26,41.14 187.25,41.15 185.88,42.52 185.88,43.94 186,44.07 186.84,44.07
+3V on TOP (solid shape): outline of 1585 points within 161.99,38.83 189.42,56.11
+3V on BOTTOM (solid shape): 86.95,64.77 86.95,63.89 86.8,63.74 85.21,63.74 85.09,63.86 85.09,64.36 85.35,64.62 85.36,64.63 86.01,64.63 86.25,64.86 86.85,64.86
+3V on BOTTOM (solid shape): 38.46,8.97 38.46,8.11 38.38,8.02 37.56,8.02 37.49,8.09 37.49,8.74 37.62,8.86 37.62,8.91 37.74,9.03 37.79,9.08 38.36,9.08
+3V on BOTTOM (solid shape): 207.74,25.5 207.74,24.15 207.8,24.1 207.8,23.62 207.64,23.47 207.34,23.47 207.11,23.7 207.11,23.93 207.2,24.11 207.16,24.31 207.16,25.45 207.29,25.58 207.67,25.58
+3V on BOTTOM (solid shape): 93.07,82.15 93.07,81.95 93.27,81.76 93.27,80.97 93.44,80.8 93.53,80.8 94.28,80.05 94.48,80.05 95.67,80.05 95.73,79.98 95.73,79.68 95.63,79.58 93.7,79.58 93.46,79.82 93.15,79.82 92.17,80.8 92.12,80.8 92.03,80.82 91.95,80.83 91.93,80.83 91.84,80.92 91.84,81.43 91.87,81.46 92.02,81.46 92.78,82.22 93,82.22
+3V on BOTTOM (solid shape): 154.34,78.87 154.34,78.51 154.35,78.5 154.35,78.41 154.44,78.32 154.45,78.3 154.5,78.25 154.54,78.21 154.58,78.17 154.63,78.12 154.65,78.11 155.78,76.99 155.78,76.83 155.6,76.65 155.45,76.65 155.27,76.83 155.27,76.86 155.26,76.88 155.23,76.96 155.18,77.03 153.96,78.24 153.96,78.48 153.88,78.56 153.88,78.81 153.88,78.85 153.87,78.89 153.87,78.99 153.95,79.07 154.15,79.07
+3V on BOTTOM (solid shape): 86.89,71.32 86.89,70.75 86.53,70.39 86.49,70.4 86.42,70.43 86.33,70.44 86.08,70.33 85.97,70.08 85.98,69.99 86.01,69.91 86.02,69.88 85.3,69.16 85.3,68.29 85.19,68.18 84.79,68.18 84.34,68.63 84.31,68.66 84.31,69.32 84.56,69.57 84.56,69.82 84.59,69.86 84.59,70.65 85.32,71.37 86.84,71.37
+3V on BOTTOM (solid shape): 165.07,36.49 165.05,36.46 165.02,36.45 164.18,36.45 163.83,36.8 163.83,39.44 163.93,39.57 163.96,39.72 163.94,39.84 163.89,39.95 163.88,40 164.03,40.15 164.05,40.17 164.11,40.17 164.19,40.18 164.28,40.21 165.07,40.21
+3V on BOTTOM (solid shape): 32,37.29 32.53,37.29 32.56,37.28 32.7,37.03 32.94,36.94 33.14,37 33.28,37.16 33.35,37.22 33.44,37.19 33.47,37.16 33.47,35.87 33.34,35.73 30.5,35.73 30.48,35.74 30.3,35.86 30.12,35.9 30.1,35.91 30.04,35.96 30.04,36.18 30.11,36.24 30.11,37.22 30.21,37.32 31.97,37.32
+3V on BOTTOM (solid shape): 201.72,14.93 202.39,14.93 202.81,14.51 202.81,14.49 202.82,14.43 202.83,14.37 203.02,14.19 203.08,14.17 203.15,14.16 203.18,14.16 203.21,14.17 203.27,14.16 203.34,14.17 203.4,14.19 203.49,14.27 203.68,14.27 203.71,14.3 204.77,14.3 204.84,14.22 204.92,14.17 205.05,14.17 205.18,14.17 205.26,14.22 205.32,14.28 205.33,14.3 205.38,14.3 205.48,14.2 205.48,13.84 205.2,13.56 204.2,13.56 204.15,13.57 203.98,13.57 203.97,13.58 202.91,13.58 202.59,13.9 202.18,13.9 201.75,14.33 201.62,14.46 201.33,14.46 201.22,14.58 201.22,14.96 201.27,15.01 201.32,15.03 201.35,15.06 201.6,15.06
+3V on BOTTOM (solid shape): outline of 195 points within 187.13,36.24 192.5,41
+3V on BOTTOM (solid shape): outline of 197 points within 176.63,27.47 182.88,31.91
+3V on BOTTOM (solid shape): outline of 207 points within 148.62,71.42 152.14,81
+3V on BOTTOM (solid shape): outline of 442 points within 19.46,50.87 30,59.98
+3V on IN1 (solid shape): outline of 201 points within 188.14,49.48 199.41,53.53
+3V on IN1 (solid shape): outline of 564 points within 26.66,49.21 56.34,54.18
+3V on IN1 (solid shape): outline of 2002 points within 19.1,53.72 80.37,108.86
+3V on SVCC (solid shape): outline of 132 points within 149.17,39.32 172.16,77.42
+3V on SVCC (solid shape): outline of 1698 points within 2.03,2.03 216.01,56.33
+3V on IN2 (solid shape): 189.39,50.69 189.39,50.47 189.18,50.26 188.42,50.26 188.28,50.4 188.28,50.71 187.89,51.09 187.89,51.45 188.06,51.61 188.47,51.61
+3V on IN2 (solid shape): 92.77,18.7 92.77,18.56 92.63,18.42 92.63,17.65 92.2,17.22 91.21,17.22 91.12,17.26 91.11,17.36 91.13,17.43 91.14,17.5 91.04,17.74 90.8,17.84 90.76,17.84 90.68,17.87 90.65,17.94 90.65,18.44 91.08,18.87 92.61,18.87
+3V on IN2 (solid shape): 106.7,26.95 106.7,25.09 106.7,25.06 106.68,25.05 106.34,24.49 106.44,23.85 106.45,23.81 106.44,23.79 106.14,23.49 105.28,23.49 105,23.77 105,24.51 105.03,24.58 105.33,24.71 105.43,24.95 105.4,25.09 105.32,25.21 105.28,25.28 105.32,25.36 105.4,25.47 105.43,25.61 105.33,25.85 105.03,25.99 105,26.06 105,26.87 105.31,27.18 106.47,27.18
+3V on IN2 (solid shape): outline of 210 points within 30.83,31.82 33.98,38.2
+3V on IN2 (solid shape): outline of 385 points within 198.35,51.64 203.6,61.8
+3V on IN2 (solid shape): outline of 453 points within 86.89,70.13 94.56,82.7
+3V_ALW on TOP (solid shape): 17.12,46.66 17.12,45.26 16.91,45.06 16.61,45.06 16.38,45.29 16.38,46.66 16.51,46.78 16.99,46.78
+3V_ALW on BOTTOM (solid shape): 190.02,14.15 190.02,13.59 189.7,13.28 189.33,13.28 189.26,13.25 189.22,13.17 189.22,12.76 189.26,12.69 189.33,12.65 189.84,12.65 189.92,12.69 189.95,12.76 189.95,12.96 190.04,13.05 190.45,13.05 190.56,12.94 190.56,12.42 190.56,12.41 190.56,12.27 190.52,12.22 190.5,12.15 190.49,12.09 190.5,12.02 190.52,11.96 190.57,11.9 190.57,11.6 190.33,11.36 188.92,11.36 188.88,11.33 188.8,11.33 188.71,11.42 188.71,13.33 189.62,14.25 189.91,14.25
+3V_ALW on IN2 (solid shape): outline of 137 points within 92.86,7.62 104.65,10.95
+3V_ALW on IN2 (solid shape): outline of 1237 points within 138.28,3.68 190.75,13.13
+3V_ALW on IN2 (solid shape): outline of 1385 points within 10.51,4.3 70.03,20.7
+3V_CAM on TOP (solid shape): 27.58,43.81 27.58,42.77 27.48,42.67 24.74,42.67 24.61,42.8 24.61,43.74 24.79,43.91 27.48,43.91
+3V_CAM on TOP (solid shape): 28.14,51.74 28.14,49.93 27.93,49.72 27.93,48.83 27.64,48.54 27.62,48.54 27.49,48.49 27.38,48.38 27.34,48.35 25.95,48.35 25.75,48.54 25.75,49.43 25.88,49.55 26.47,49.55 26.6,49.46 26.75,49.42 27.01,49.53 27.11,49.79 27.08,49.93 27,50.06 27,50.26 27.08,50.38 27.11,50.52 27.1,50.6 27.07,50.68 27.06,50.76 27.11,50.82 27.26,50.95 27.32,51.15 27.29,51.28 27.21,51.4 27.18,51.48 27.21,51.55 27.28,51.64 27.32,51.75 27.33,51.79 28.09,51.79
+3V_CAM on IN3 (solid shape): outline of 136 points within 25.45,42.64 27.76,49.12
+3V_CAM_R on TOP (solid shape): 20.37,26.76 21.08,26.76 21.16,26.67 21.16,26.55 19.44,24.82 16.67,24.82 16.61,24.89 16.61,26.36 16.71,26.47 18,26.47 18.26,26.72 18.33,26.75 18.41,26.71 18.45,26.67 18.5,26.66 19.31,26.66 19.39,26.69 19.42,26.77 19.42,26.92 20.2,26.92
+3V_CLICK on BOTTOM (solid shape): 41.42,10.96 41.5,10.88 41.54,10.88 41.53,10.76 41.64,10.5 41.9,10.39 41.94,10.4 42.01,10.41 42.47,9.96 42.47,7.16 42.26,6.96 41.08,6.96 40.88,7.16 40.88,7.53 40.85,7.61 40.77,7.64 40.57,7.64 40.49,7.61 40.46,7.53 40.46,7.36 40.27,7.17 38.26,7.17 38.2,7.11 36.45,7.11 36.27,6.93 36.27,5.92 36.19,5.84 35.43,5.84 35.43,5.9 35.44,5.91 35.44,6.17 35.37,6.28 35.26,6.35 35.23,6.37 35.23,7.72 35.35,7.85 39.76,7.85 40.04,8.13 40.04,10.63 40.04,10.63 40.04,10.8 40.21,10.96 40.6,10.96
+3V_CM_PWR on TOP (solid shape): 26.57,35.35 26.57,34.41 26.26,34.11 25.75,34.11 25.68,34.19 25.68,34.35 25.74,34.42 25.74,34.85 26,35.11 26,35.4 25.85,35.55 25.68,35.55 25.63,35.6 25.63,35.78 25.68,35.84 26.08,35.84
+3V_CM_PWR on TOP (solid shape): 23.51,28.3 23.89,28.3 24.36,27.84 24.97,27.84 25.04,27.77 25.04,27.23 24.98,27.18 24.71,27.18 24.48,26.95 24.48,26.71 24.47,26.7 24.47,26.43 24.07,26.03 24.06,26.03 23.9,25.89 23.84,25.69 23.86,25.58 23.91,25.47 23.91,25.46 23.91,25.42 23.91,25.4 23.9,25.38 23.7,25.18 23.26,25.18 23.22,25.22 23.22,25.62 23.08,25.76 22.34,25.76 22.29,25.76 22.25,25.77 22.21,25.76 22.17,25.76 21.67,25.76 21.42,25.51 21.42,25.23 21.35,25.16 21.17,25.16 21.03,25.29 21.03,26.09 21.34,26.4 21.34,26.66 21.43,26.74 21.53,26.74 21.61,26.67 21.61,26.27 21.75,26.13 23.49,26.13 24.08,26.72 24.08,27.38 23.76,27.7 23.45,27.7 22.93,28.22 22.78,28.22 22.73,28.23 22.68,28.23 22.64,28.23 22.59,28.22 22.34,28.22 22,27.88 22,27.37 21.94,27.31 21.81,27.31 21.76,27.36 21.76,27.91 21.42,28.25 20.9,28.25 20.8,28.23 20.71,28.19 19.53,28.19 19.33,28.39 19.33,28.5 19.55,28.73 22.75,28.73 22.78,28.76 23.05,28.76
+3V_CR on TOP (solid shape): 180.79,51.09 180.79,50.18 180.82,50.15 180.82,50.13 181.14,49.81 181.14,49.42 181.4,49.16 181.82,49.16 181.97,49.01 181.97,48.25 181.89,48.17 181.39,48.17 181.2,47.98 181.2,47.32 181.12,47.23 179.98,47.23 179.86,47.36 179.86,49.8 179.98,49.93 179.98,51.21 180.05,51.28 180.59,51.28
+3V_CR on TOP (solid shape): 182.06,40.64 182.42,40.64 182.8,40.26 182.8,38.38 182.59,38.18 182.46,38.18 182.16,38.18 182.12,38.18 181.36,38.18 181.32,38.18 181.02,38.18 180.98,38.18 180.78,38.18 180.56,38.4 180.56,38.92 180.22,39.26 179.23,39.26 179.19,39.3 179.19,39.4 179.24,39.45 180.22,39.45 180.23,39.47 181.3,39.47 181.48,39.65 181.48,40.28 181.41,40.35 181.41,40.56 181.54,40.69 182.01,40.69
+3V_CR on TOP (solid shape): 172.67,41.1 173.45,41.1 173.5,41.11 173.52,41.1 173.87,40.75 173.98,40.75 173.99,40.74 174.97,40.74 175.01,40.72 175.02,40.69 175.02,40.65 175.99,40.65 176.03,40.64 176.05,40.6 176.05,40.5 176.03,40.47 175.99,40.45 175.02,40.45 175.02,40.43 175.01,40.4 174.97,40.38 173.73,40.38 173.48,40.13 173.2,40.13 172.74,39.67 171.93,39.67 171.83,39.77 171.83,41.32 171.91,41.41 171.98,41.41 172.03,41.43 172.34,41.43
+3V_DEEP_SUS on TOP (solid shape): 158.24,77.01 158.24,76.83 157.53,76.12 156.97,76.12 156.92,76.17 156.92,76.83 157,76.91 157.38,76.91 157.73,77.26 157.99,77.26
+3V_DEEP_SUS on TOP (solid shape): 154.05,7.18 154.05,6.5 153.75,6.2 151.38,6.2 151.31,6.27 151.31,6.69 151.98,7.36 153.88,7.36
+3V_DEEP_SUS on TOP (solid shape): 194.41,6.45 194.92,6.45 195.02,6.35 195.02,5.74 194.94,5.66 193.88,5.66 193.72,5.81 191.84,5.81 191.75,5.91 191.75,6.28 191.84,6.37 193.7,6.37 193.93,6.6 194.26,6.6
+3V_DEEP_SUS on TOP (solid shape): 170.1,96.82 170.1,96.29 170.41,95.98 170.91,95.98 171.68,95.22 171.68,92.45 171.5,92.28 170.48,92.28 170.37,92.39 170.37,93.03 170.51,93.16 170.51,93.28 170.64,93.28 170.72,93.32 170.75,93.39 170.75,94.21 170.72,94.28 170.64,94.32 170.51,94.32 170.51,94.89 169.44,95.96 169.44,96.42 169.26,96.59 169.26,97.2 169.31,97.25 169.67,97.25
+3V_DEEP_SUS on TOP (solid shape): 155.12,67.84 155.12,67.7 154.96,67.54 154.93,67.54 154.83,67.47 154.75,67.36 154.75,67.11 154.83,67 154.93,66.93 154.94,66.93 155.15,66.72 155.17,66.68 155.17,65.83 154.61,65.28 153.79,65.28 153.59,65.48 153.59,65.6 153.78,65.79 154.07,65.79 154.18,65.89 154.18,66.41 153.13,67.45 153.02,67.45 152.96,67.51 152.96,67.79 153.03,67.86 153.82,67.86 153.88,67.91 155.04,67.91
+3V_DEEP_SUS on TOP (solid shape): outline of 158 points within 150.11,72.03 156.64,78.23
+3V_DEEP_SUS on BOTTOM (solid shape): 152.65,82.42 152.65,82.01 152.52,81.88 152.52,81.25 152.65,81.12 152.65,79.78 152.42,79.55 152.42,79.22 152.33,79.13 152.32,79.13 152.14,78.94 151.69,78.94 151.6,79.03 151.6,80 152.09,80.49 152.09,80.66 152.1,80.69 152.1,80.73 152.1,80.76 152.09,80.8 152.09,81.06 151.96,81.2 151.96,82.37 152.16,82.57 152.5,82.57
+3V_DEEP_SUS on BOTTOM (solid shape): 91.89,69.24 91.89,69.19 91.41,68.71 91.41,67.21 90.83,66.62 90.82,66.62 90.72,66.55 90.65,66.45 90.65,66.44 90.37,66.16 90.37,65.54 90.32,65.49 90.17,65.49 90.09,65.48 90.01,65.45 89.05,65.45 88.9,65.6 88.9,66.17 89.13,66.39 89.28,66.39 89.28,66.53 89.31,66.54 89.37,66.58 89.39,66.64 89.39,67.03 89.67,67.32 89.71,67.3 89.74,67.28 89.78,67.27 90.49,67.27 90.54,67.29 90.58,67.32 90.59,67.33 90.75,67.33 90.75,67.9 90.62,68.04 90.56,68.04 90.52,68.05 90.49,68.06 89.78,68.06 89.7,68.03 89.66,67.95 89.66,67.93 89.56,67.83 88.86,67.83 88.72,67.97 88.72,68.49 90.6,68.49 90.6,68.49 90.72,68.49 91.55,69.31 91.82,69.31
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 89 points within 154.35,65.78 156.46,68.86
+3V_DEEP_SUS on IN2 (solid shape): outline of 228 points within 136.37,5.08 164.03,7.11
+3V_DEEP_SUS on IN2 (solid shape): outline of 1328 points within 179.58,2.11 207.09,29.17
+3V_DEEP_SUS on IN2 (solid shape): outline of 1473 points within 169.52,37.07 184.17,93.42
+3V_DEEP_SUS on IN2 (solid shape): outline of 2202 points within 7.72,2.39 71.37,19.64
+3V_DEEP_SUS on IN3 (solid shape): outline of 197 points within 135.37,72.16 146.42,73.45
+3V_DEEP_SUS_PRIME on TOP (solid shape): 138.17,74.98 138.17,72.72 137.77,72.31 137.77,72.14 137.77,71.68 137.49,71.4 137.49,71.02 137.39,70.91 137.03,70.91 136.93,71.02 136.93,71.07 136.97,71.13 136.99,71.17 136.99,71.43 136.98,71.46 136.95,71.51 136.93,71.54 136.93,71.68 136.94,71.71 136.94,71.73 136.94,71.93 136.94,71.96 136.93,71.98 136.93,72.08 136.83,72.18 136.45,72.18 136.14,71.88 135.84,71.88 135.56,72.16 135.28,72.16 135.23,72.21 135.23,72.36 135.29,72.45 135.4,72.43 135.44,72.39 135.51,72.37 135.57,72.36 135.63,72.37 135.7,72.39 135.88,72.57 135.89,72.63 135.9,72.7 135.89,72.76 135.88,72.82 135.68,73.01 135.68,73.11 135.7,73.13 135.7,73.16 135.7,73.52 135.74,73.56 136.01,73.56 136.14,73.43 136.14,72.84 136.29,72.69 136.83,72.69 136.93,72.79 136.93,73.15 137.29,73.51 137.35,73.52 137.4,73.54 137.58,73.71 137.6,73.84 137.58,73.97 137.4,74.15 137.34,74.17 137.34,74.95 137.44,75.05 138.1,75.05
+3V_DEEP_SUS_PRIME on BOTTOM (solid shape): 153.26,70.71 153.26,69.34 153.41,69.19 153.82,69.19 153.9,69.26 153.9,69.62 153.95,69.67 154.18,69.67 154.56,69.29 154.56,68.02 154.46,67.92 153.59,67.92 152.88,68.63 152.58,68.63 152.5,68.7 152.5,69.49 152.3,69.7 151.92,69.7 151.79,69.82 151.79,70.71 151.92,70.84 153.13,70.84
+3V_DEEP_SUS_PRIME on SVCC (solid shape): 145.33,72.65 145.38,72.58 145.45,72.52 145.69,72.28 145.77,72.23 145.87,72.21 150.61,72.21 150.7,72.17 150.8,72.15 150.9,72.17 150.99,72.21 152.6,72.21 152.98,71.83 152.98,70.81 153,70.72 153.06,70.63 153.49,70.2 153.49,69.52 152.88,68.91 149.95,68.91 149.83,69 149.69,69.03 149.54,69 149.43,68.91 149.39,68.91 149.27,69.01 149.12,69.04 148.97,69.01 148.85,68.91 144.71,68.91 143.89,69.72 143.81,69.78 143.71,69.8 142.16,69.8 142.05,69.88 141.91,69.91 141.77,69.88 141.65,69.8 141.5,69.8 141.38,69.88 141.25,69.91 141.11,69.88 141,69.8 140.74,69.8 140.63,69.87 140.5,69.89 140.38,69.87 140.27,69.8 140.14,69.8 140.03,69.87 139.9,69.89 139.78,69.87 139.67,69.8 139.48,69.8 139.37,69.88 139.23,69.91 139.09,69.88 138.97,69.8 137.24,69.8 137.14,70.04 136.9,70.13 136.72,70.08 136.6,69.94 136.49,70.04 136.35,70.08 136.35,72.04 136.35,72.08 136.36,72.12 136.35,72.17 136.35,72.21 136.35,74.37 143.61,74.37
+3V_DEEP_SUS_PRIME on IN3 (solid shape): outline of 429 points within 135.74,70.52 144.73,72.36
+3V_DEEP_SUS_R on TOP (solid shape): 155.61,10.01 155.75,9.87 155.75,9.42 155.51,9.18 155.48,9.15 155.45,9.12 155.27,8.99 155.21,8.78 155.24,8.63 155.34,8.5 155.37,8.43 155.35,8.36 155.21,8.22 155.21,7.93 155.04,7.76 154.39,7.76 154.13,7.5 153.96,7.5 153.96,7.61 153.93,7.68 153.86,7.72 153.04,7.72 152.97,7.68 152.93,7.61 152.93,7.5 152.07,7.5 151.97,7.6 151.97,8.25 151.97,8.32 151.98,8.34 151.98,8.44 152.13,8.6 152.5,8.6 152.63,8.6 153.13,8.6 153.33,8.6 153.35,8.61 153.4,8.61 153.56,8.77 153.56,9.13 153.55,9.14 153.55,9.19 153.44,9.3 153.44,9.99 153.64,10.18 154.48,10.18 155.06,10.77 155.61,10.77
+3V_ECACC on BOTTOM (solid shape): outline of 102 points within 191.97,11.06 196.45,13.61
+3V_F on TOP (solid shape): 11.93,22.82 13.59,22.82 13.76,22.65 13.76,21.08 13.66,20.98 12.02,20.98 10.46,22.55 9.75,22.55 9.69,22.6 9.69,23.02 9.86,23.02 9.86,22.83 10.47,22.83 10.47,22.83 10.47,23.03 9.87,23.03 9.69,23.02 9.69,23.24 9.78,23.32 11.43,23.32
+3V_FR on TOP (solid shape): 152.34,9.72 153.2,9.72 153.31,9.61 153.31,9.27 153.38,9.2 153.38,9.18 153.39,9.13 153.42,9.09 153.44,9.07 153.44,8.86 153.29,8.71 152.02,8.71 151.86,8.56 151.86,8.38 151.74,8.26 150.17,8.26 150.05,8.38 149.27,8.38 149.12,8.54 149.12,9.49 149.75,10.12 151.94,10.12
+3V_FR on BOTTOM (solid shape): outline of 354 points within 143.06,6.28 160.92,9.99
+3V_R on TOP (solid shape): 29.86,14.11 29.84,14.07 29.82,14 29.81,13.92 29.92,13.66 30.17,13.56 30.2,13.56 30.3,13.46 30.3,13.33 30.25,13.28 30.25,12.09 30.24,12.08 30.24,11.97 30.17,11.91 28.84,11.91 28.81,11.9 28.77,11.88 28.55,11.88 28.47,11.96 27.13,11.96 27,11.83 26.27,11.83 26.22,11.88 26.22,12.66 26.02,12.66 26.02,11.9 25.97,11.85 25.87,11.85 25.82,11.89 25.82,12.66 25.8,12.68 25.8,12.79 25.94,12.92 25.99,13.1 25.91,13.33 25.72,13.46 25.68,13.47 25.68,14.12 25.73,14.17 29.79,14.17
+3V_RTC on TOP (solid shape): 159.38,69.92 159.38,68.65 159.28,68.55 159.18,68.55 158.93,68.3 158.93,67.87 158.9,67.87 158.9,67.15 158.93,67.15 158.93,65.91 158.75,65.74 158.38,65.74 158.29,65.65 158.24,65.61 158.2,65.57 158.07,65.43 157.58,65.43 157.33,65.68 156.92,65.68 156.72,65.88 156.7,65.92 156.66,65.94 156.56,66.04 156.24,66.04 156.22,66.06 156.22,66.27 156.26,66.3 156.26,66.44 156.27,66.47 156.27,66.73 156.2,66.83 156.1,66.9 156.09,66.91 155.95,67.05 155.95,67.44 156.09,67.57 156.45,67.57 156.53,67.49 156.53,67.29 156.76,67.06 156.76,66.6 156.9,66.45 157.44,66.45 157.81,66.09 158.09,66.09 158.24,66.24 158.24,66.71 158.43,66.9 158.43,67.25 158.24,67.44 158.24,68.92 158.36,69.05 158.36,69.62 158.82,70.08 159.23,70.08
+3V_RTC on BOTTOM (solid shape): 199.79,16.18 199.79,15.75 199.57,15.52 198.52,15.52 198.4,15.64 198.4,16.48 198.5,16.58 199.39,16.58
+3V_RTC on IN2 (solid shape): 159.53,69.85 159.53,69.5 159.94,69.09 159.94,68.25 159.93,68.23 159.9,68.19 159.88,68.15 159.86,68.1 159.85,68.05 159.85,68 159.86,67.95 159.88,67.9 159.9,67.86 159.93,67.81 159.94,67.79 159.94,67.36 159.64,67.05 159.2,67.05 158.48,67.77 158.48,68.14 158.96,68.14 158.96,68.09 158.98,68.04 159,67.99 159.02,67.95 159.06,67.9 159.1,67.87 159.14,67.84 159.19,67.82 159.24,67.81 159.29,67.8 159.34,67.8 159.4,67.81 159.44,67.83 159.49,67.85 159.53,67.89 159.57,67.92 159.6,67.97 159.62,68.01 159.64,68.07 159.65,68.12 159.65,68.17 159.64,68.22 159.62,68.27 159.6,68.32 159.57,68.36 159.53,68.4 159.49,68.43 159.44,68.46 159.4,68.47 159.34,68.49 159.29,68.49 159.24,68.48 159.19,68.47 159.14,68.45 159.1,68.42 159.06,68.38 159.02,68.34 159,68.3 158.98,68.25 158.96,68.2 158.96,68.14 158.48,68.14 158.48,68.43 158.88,68.83 158.88,69.98 158.98,70.08 159.31,70.08
+3V_RTC on IN2 (solid shape): outline of 86 points within 164.74,44.85 166.83,47.34
+3V_RTC_0 on TOP (solid shape): 172.93,7.57 173.35,7.39 174.06,6.68 174.85,6.68 175.11,6.42 175.11,5.53 174.98,5.41 174.6,5.41 174.47,5.53 174.47,6.03 174.32,6.18 173.94,6.18 173.92,6.17 173.68,6.17 173.41,6.44 173.41,6.6 173.17,6.84 173.1,6.93 172.97,7.04 172.81,7.04 172.79,7.06 171.91,7.06 171.78,7.19 171.78,7.44 171.91,7.57
+3V_RTC_0 on BOTTOM (solid shape): 87.83,16.7 88.58,16.7 88.92,16.36 88.92,16.05 88.77,15.9 88.19,15.9 88.01,15.72 87.93,15.72 87.78,15.65 87.71,15.5 87.7,15.4 87.7,15.35 87.7,15.26 87.53,15.09 87.22,15.09 87.17,15.1 87.12,15.1 87.07,15.1 87.02,15.09 85.25,15.09 85.14,15.19 85.14,15.8 85.24,15.9 86.23,15.9 86.29,15.89 86.34,15.88 86.39,15.89 86.46,15.9 87.02,15.9 87.17,16.05 87.27,16.05 87.34,16.11 87.4,16.18 87.4,16.26 87.4,16.51 87.59,16.7
+3V_RTC_0 on IN2 (solid shape): outline of 499 points within 133.51,8.05 158.14,10.31
+3V_RTC_1 on TOP (solid shape): 173.3,6.55 173.3,6.04 173.18,5.92 172.69,5.92 172.03,6.58 172.03,6.68 172.16,6.8 172.57,6.8 172.69,6.93 172.92,6.93
+3V_RTC_1 on TOP (solid shape): 158.8,70.97 158.8,70.43 157.93,69.57 157.88,69.55 157.82,69.49 157.68,69.49 157.3,69.87 157.3,70 158.42,71.12 158.65,71.12
+3V_RTC_1 on BOTTOM (solid shape): outline of 103 points within 163.5,41.68 165.43,47.11
+3V_RTC_1 on IN2 (solid shape): outline of 140 points within 179.15,24.03 180.55,27.46
+3V_RTC_1 on IN2 (solid shape): outline of 176 points within 179.98,16.3 185.19,20.83
+3V_SSD on TOP (solid shape): outline of 196 points within 5.03,2.7 18.64,12.11
+3V_SSD on BOTTOM (solid shape): outline of 1041 points within 5.01,2.38 11.32,23.92
+3V_SSD on IN1 (solid shape): 16.84,8.82 16.84,7.82 15.24,6.22 14.8,6.22 14.57,6.31 14.33,6.22 10.69,6.22 9.83,7.08 8.94,7.08 8.93,7.08 7.71,5.87 6.96,5.87 6.49,6.34 6.49,8.01 7.01,8.53 9.24,8.53 9.25,8.53 9.33,8.5 9.4,8.49 9.48,8.5 9.55,8.53 9.56,8.53 10.69,8.53 10.89,8.33 10.98,8.33 11.02,8.32 11.06,8.32 11.1,8.32 11.14,8.33 14.07,8.33 14.38,8.64 14.46,8.6 14.55,8.59 14.79,8.68 14.89,8.92 14.88,9.01 14.84,9.1 14.98,9.24 16.42,9.24
+3V_SSD on IN3 (solid shape): outline of 95 points within 6.07,3.1 9.93,8.07
+3V_VCC on TOP (solid shape): 202.21,20.29 202.21,19.91 202.05,19.76 201.65,19.76 201.5,19.61 201.5,19.45 201.06,19.01 199.47,19.01 199.39,19.09 199.3,19.09 199.29,19.1 198.87,19.1 198.79,19.18 198.79,19.31 198.91,19.42 199.5,19.42 199.53,19.39 200.53,19.39 200.57,19.43 200.59,19.43 200.84,19.54 200.94,19.78 200.94,19.8 201.43,20.29 201.5,20.3 201.55,20.32 201.65,20.42 202.08,20.42
+3V_VCC on TOP (solid shape): 192.71,14.83 192.71,14.65 192.35,14.29 192.3,14.27 192.28,14.25 192.07,14.03 192.07,13.99 191.55,13.47 190.79,13.47 190.39,13.07 189.75,13.07 189.75,13.07 189.39,13.07 189.24,12.93 188.69,12.93 188.62,13 188.62,13.41 188.69,13.49 189.91,13.49 190.06,13.64 190.29,13.64 190.82,14.16 191.23,14.16 191.25,14.14 191.3,14.13 191.36,14.12 191.42,14.13 191.47,14.14 191.65,14.31 191.66,14.36 191.78,14.48 191.83,14.47 191.86,14.46 192.02,14.52 192.11,14.66 192.11,14.67 192.4,14.96 192.58,14.96
+3V_VCC on TOP (solid shape): 187.79,20.64 187.87,20.61 188.06,20.42 188.06,19.61 188.22,19.44 189.98,19.44 190.55,18.87 191.1,18.87 191.16,18.81 191.43,18.81 191.46,18.81 191.51,18.83 191.96,18.83 192.07,18.72 192.07,18.54 191.97,18.43 191.83,18.43 191.8,18.47 191.66,18.47 191.62,18.51 190.12,18.51 189.99,18.39 189.96,18.4 189.71,18.4 189.6,18.33 189.53,18.22 189.53,17.97 189.54,17.94 189.25,17.65 189.12,17.65 189.08,17.66 189.05,17.66 188.67,17.66 188.56,17.78 188.56,18.42 188.09,18.88 187.44,18.88 187.39,18.83 187.34,18.78 187.32,18.76 186.95,18.76 186.89,18.82 186.89,20.45 187.04,20.59 187.12,20.62 187.19,20.59 187.25,20.53 187.32,20.49 187.58,20.49 187.66,20.54 187.72,20.6
+3V_VCC on IN2 (solid shape): outline of 578 points within 189.53,13.38 202.03,19.89
+3V_VCC_CR on TOP (solid shape): 175.02,40.25 176.02,40.25 176.06,40.24 176.07,40.2 176.07,40.1 176.06,40.07 176.02,40.05 175.02,40.05 175.02,40.02 174.88,39.88 174.88,39.7 174.64,39.46 173.97,39.46 173.11,38.61 173.11,37.83 172.74,37.46 172.31,37.46 172.18,37.59 172.18,39.09 172.57,39.47 172.67,39.47 172.77,39.57 172.79,39.57 173.24,40.03 173.52,40.03 173.78,40.28 175,40.28
+3V_WLAN_C on TOP (solid shape): 199.34,77.06 199.34,76.81 199.85,76.3 199.86,76.26 199.88,76.21 199.91,76.17 199.93,76.15 199.93,75.24 200.06,75.11 200.06,73.97 199.99,73.89 199.19,73.89 199.18,73.9 199.06,73.9 197.84,75.11 197.84,75.39 197.84,75.4 197.83,75.43 197.82,75.46 197.8,75.48 197.77,75.49 197.74,75.5 197.69,75.5 197.3,75.89 199.03,75.89 199.04,75.84 199.05,75.79 199.07,75.74 199.1,75.69 199.13,75.65 199.17,75.61 199.21,75.58 199.26,75.55 199.31,75.54 199.36,75.53 199.42,75.52 199.47,75.53 199.52,75.54 199.57,75.56 199.62,75.59 199.66,75.63 199.7,75.67 199.73,75.71 199.75,75.76 199.76,75.81 199.77,75.87 199.77,75.92 199.76,75.97 199.75,76.02 199.73,76.07 199.7,76.12 199.66,76.16 199.62,76.19 199.57,76.22 199.52,76.24 199.47,76.26 199.42,76.26 199.36,76.26 199.31,76.25 199.26,76.23 199.21,76.21 199.17,76.18 199.13,76.14 199.1,76.1 199.07,76.05 199.05,76 199.04,75.95 199.03,75.89 197.3,75.89 197.09,76.1 197.09,76.9 197.24,77.05 198.09,77.05 198.1,77.06 198.17,77.06 198.3,77.19 199.21,77.19
+3V_WLAN_P on TOP (solid shape): outline of 1144 points within 174.47,69.38 200.02,79.53
+3V_WLAN_P on BOTTOM (solid shape): 191.68,80.32 191.68,80.31 191.7,80.28 191.72,80.26 191.75,80.24 191.76,80.24 193.14,78.86 193.14,78.18 192.99,78.03 192.63,78.03 192.59,78.06 192.51,78.11 192.42,78.16 192.34,78.21 192.24,78.24 192.15,78.27 192.05,78.29 191.96,78.31 191.86,78.31 191.76,78.31 191.66,78.3 191.57,78.28 191.47,78.26 191.38,78.22 191.29,78.18 191.2,78.14 191.12,78.08 191.04,78.02 190.97,77.95 190.91,77.88 190.84,77.8 190.79,77.72 190.74,77.64 190.72,77.59 190.57,77.44 189.33,77.44 188.97,77.8 188.97,78.28 189.13,78.43 190.11,78.43 190.19,78.51 190.19,78.59 190.69,78.59 190.69,80.14 190.49,80.14 190.49,78.59 190.19,78.59 190.19,80.18 190.29,80.29 191.22,80.29 191.35,80.41 191.59,80.41
+3V_WLAN_P on BOTTOM (solid shape): outline of 120 points within 170.61,75.91 176.12,82.18
+3V_WLAN_P on IN2 (solid shape): outline of 99 points within 184.91,77.29 187.2,83.26
+3V_WWAN_P on TOP (solid shape): 187.93,4.04 187.93,3.38 187.75,3.19 186.7,3.19 186.48,2.97 186.48,2.33 186.38,2.23 185.02,2.23 184.71,2.54 184.71,2.96 184.99,3.24 184.99,3.7 184.99,3.79 184.99,4.08 185.17,4.26 187.7,4.26
+3V_WWAN_P on TOP (solid shape): outline of 136 points within 195.58,2.05 205.62,5.64
+3V_WWAN_P on BOTTOM (solid shape): 202.2,3.62 202.21,3.56 202.23,3.47 202.26,3.39 202.29,3.31 202.33,3.23 202.38,3.16 202.44,3.09 202.47,3.06 202.47,2.74 202.3,2.57 202.3,0.69 202.19,0.58 201.62,0.58 201.51,0.69 201.82,0.69 201.82,0.69 202.01,0.69 202.01,2.24 201.82,2.24 201.82,0.69 201.51,0.69 201.51,2.34 201.36,2.49 201.11,2.49 200.72,2.87 200.72,3.52 201.27,4.06 201.76,4.06
+3V_WWAN_P on BOTTOM (solid shape): outline of 576 points within 183.88,0.7 198.6,7.16
+3V_WWAN_P on IN2 (solid shape): outline of 968 points within 184.7,2.07 203.12,6.19
+3VLANVCC on TOP (solid shape): 17.35,13.15 17.35,12.27 17.3,12.22 17.3,12.11 16.65,11.47 16.65,10.86 15.44,9.65 13.49,9.65 13.26,9.88 13.26,10.4 14.53,10.4 14.54,10.35 14.55,10.29 14.57,10.24 14.59,10.2 14.63,10.15 14.67,10.12 14.71,10.08 14.76,10.06 14.81,10.04 14.86,10.03 14.92,10.03 14.97,10.04 15.02,10.05 15.07,10.07 15.12,10.1 15.16,10.13 15.19,10.17 15.22,10.22 15.25,10.27 15.26,10.32 15.27,10.37 15.27,10.43 15.26,10.48 15.25,10.53 15.22,10.58 15.19,10.62 15.16,10.66 15.12,10.7 15.07,10.73 15.02,10.75 14.97,10.76 14.92,10.77 14.86,10.77 14.81,10.76 14.76,10.74 14.71,10.71 14.67,10.68 14.63,10.65 14.59,10.6 14.57,10.56 14.55,10.51 14.54,10.45 14.53,10.4 13.26,10.4 13.26,11.35 13.43,11.53 15.24,11.53 15.72,12.01 15.72,12.93 16.08,13.28 17.22,13.28
+3VLANVCC_F on TOP (solid shape): 11.34,11.49 12.33,11.49 12.65,11.17 12.65,9.93 12.45,9.73 10.9,9.73 10.77,9.85 10.77,10.29 10.53,10.53 9.55,10.53 9.42,10.66 9.42,11.02 9.86,11.02 9.86,10.83 10.47,10.83 10.47,10.83 10.47,11.03 9.87,11.03 9.42,11.02 9.42,11.52 9.86,11.52 9.86,11.33 10.47,11.33 10.47,11.33 10.47,11.53 9.87,11.53 9.42,11.52 9.42,11.89 9.55,12.02 9.86,12.02 9.86,11.83 10.47,11.83 10.47,11.83 10.47,12.03 9.87,12.03 9.55,12.02 9.86,12.33 10.5,12.33
+3VLANVCC_R on TOP (solid shape): 18.16,16.18 18.16,15.77 18.39,15.54 20.27,15.54 21.45,14.37 21.49,14.31 21.56,14.26 21.86,13.95 21.86,13.4 21.86,13.21 21.89,13.17 21.9,13.16 22.02,12.95 22.25,12.87 22.41,12.91 22.53,13 22.74,13 22.86,12.91 23.01,12.87 23.27,12.98 23.38,13.24 23.37,13.3 23.58,13.51 23.8,13.51 23.86,13.48 23.91,13.48 23.98,13.48 24.07,13.42 24.06,13.32 24.01,13.22 23.99,13.1 24.02,12.96 24.11,12.84 24.41,12.54 24.41,11.86 24.33,11.78 23.67,11.78 23.59,11.86 23.36,11.86 23.35,11.87 23.13,11.87 23.08,11.87 22.78,11.87 22.63,11.87 22.49,11.72 22.49,11.68 22.15,11.34 21.32,11.34 20.88,11.78 20.88,13.3 20.74,13.44 20.74,13.45 20.67,13.55 20.57,13.62 20.56,13.62 20.32,13.86 19.61,13.86 19.45,14.02 19.29,14.02 19.23,14.03 19.19,14.03 19.14,14.03 19.09,14.02 18.77,14.02 18.51,14.27 17.4,14.27 17.24,14.12 17.24,13.94 17.23,13.88 17.23,13.83 17.23,13.78 17.24,13.72 17.24,13.66 17.21,13.63 16.39,13.63 16.38,13.64 16.38,15.39 17.35,16.36 17.98,16.36
+3VLCD_CON on TOP (solid shape): 26.66,36.79 27.09,36.79 27.45,36.43 27.45,36.16 27.48,36.08 27.56,36.05 27.83,36.05 27.91,35.96 28.34,35.96 28.41,35.89 28.41,35.27 28.34,35.2 27.66,35.2 27.33,35.53 27.33,35.54 27.23,35.74 27.03,35.84 27.02,35.84 26.49,36.37 25.3,36.37 25.19,36.47 25.19,37.01 25.28,37.09 26.35,37.09
+3VLCD_CON on BOTTOM (solid shape): 31.54,44.39 31.54,39.43 31.52,39.39 31.11,38.98 31.11,38.71 30.32,37.91 30,37.91 29.54,37.45 29.54,36.59 29.37,36.42 29.12,36.42 29.08,36.45 29.06,36.47 29.04,36.49 29,36.52 28.99,36.6 27.69,36.6 27.68,36.52 27.64,36.49 27.62,36.47 27.6,36.45 27.59,36.42 27.59,36.32 27.57,36.3 27.57,35.96 27.37,35.76 27.19,35.76 27.17,35.78 27.11,35.81 27.06,35.83 27,35.84 26.94,35.84 26.89,35.83 26.83,35.81 26.78,35.78 26.76,35.76 26.46,35.76 26.45,35.77 25.97,35.77 25.78,35.96 25.78,36.9 28.99,36.9 28.99,37.1 27.69,37.1 27.69,36.9 25.78,36.9 25.78,37.18 26.05,37.46 27.69,37.46 27.69,37.4 28.99,37.4 29,37.48 29.04,37.51 29.06,37.53 29.08,37.55 29.09,37.58 29.09,37.6 29.09,37.84 29.77,38.52 29.94,38.52 30.1,38.68 30.15,38.68 30.19,38.69 30.23,38.71 30.26,38.73 30.29,38.76 30.31,38.79 30.33,38.83 30.34,38.87 30.34,38.9 30.33,39.24 30.33,39.39 30.54,39.6 30.54,39.67 30.85,39.98 30.85,41.4 30.89,41.44 30.89,44.4 30.96,44.47 31.46,44.47
+3VPCU on TOP (solid shape): 17.98,44.7 17.98,44.29 17.97,44.28 17.97,43.74 18.34,43.37 18.74,43.37 18.88,43.24 18.88,42.91 18.72,42.75 16.99,42.75 16.62,43.11 16.62,44.49 17.02,44.88 17.8,44.88
+3VPCU on TOP (solid shape): 199.65,72.72 199.65,71.73 199.59,71.66 199.07,71.66 198.41,72.32 195.8,72.32 195.19,71.71 194.14,71.71 193.93,71.92 193.93,72.98 194.09,73.13 194.53,73.13 194.72,73.33 194.72,73.69 195.07,74.03 198.34,74.03
+3VPCU on TOP (solid shape): 163.45,84.94 166.19,84.94 166.39,84.73 166.39,84.43 166.24,84.27 163.14,84.27 162.91,84.5 162.66,84.5 162.47,84.32 162.47,84.26 162.47,84.24 162.43,84.08 162.47,83.91 162.47,83.9 162.47,83.62 162.47,83.61 162.43,83.44 162.47,83.27 162.47,83.26 162.47,82.74 162.43,82.69 161.5,82.69 161.29,82.91 161.29,83.14 161.87,83.73 161.87,84.71 162.51,85.34 163.04,85.34
+3VPCU on TOP (solid shape): 189.18,20.58 189.18,20.5 189.18,20.38 189.52,20.04 190.16,20.04 190.18,20.06 191,20.06 191.09,19.98 191.09,19.77 190.97,19.65 190.94,19.61 190.92,19.55 190.92,19.5 190.06,19.5 190.02,19.54 189.94,19.54 189.9,19.57 189.87,19.58 189.61,19.58 189.58,19.57 189.54,19.54 188.35,19.54 188.21,19.68 188.21,20.47 188.33,20.59 188.95,20.59 188.98,20.59 189.02,20.6 189.16,20.6
+3VPCU on TOP (solid shape): 23.49,10.54 24,10.54 24.02,10.54 24.24,10.54 24.25,10.54 24.38,10.54 24.42,10.5 24.42,9.65 24.34,9.57 24.34,9.56 24.33,9.55 24.33,9.26 24.27,9.19 24.22,9.09 24.22,9.08 24.18,9.04 22.98,9.04 22.88,8.93 22.83,8.93 22.78,8.93 22.72,8.9 22.71,8.9 22.5,8.9 22.4,8.94 22.29,8.96 22.25,8.96 22.17,9.04 22.17,10.13 22.6,10.56 22.6,10.84 22.73,10.97 23.06,10.97
+3VPCU on TOP (solid shape): 27.68,10.28 27.68,9.65 27.84,9.5 28.17,9.5 28.4,9.27 28.4,7.8 27.99,7.39 27.4,7.39 27.28,7.52 27.28,7.57 27.02,7.82 26.63,7.82 26.46,7.99 26.46,8.3 26.38,8.39 26.37,8.4 26.3,8.51 26.17,8.54 25.87,8.54 25.8,8.53 25.68,8.66 25.68,9.52 25.78,9.62 25.8,9.62 25.8,9.69 25.82,9.71 25.82,10.36 25.97,10.51 27.46,10.51
+3VPCU on TOP (solid shape): 21.17,50.59 21.43,50.59 21.46,50.59 21.78,50.59 21.91,50.46 21.91,50.25 21.71,50.06 21.71,49.48 21.54,49.31 21.02,49.31 20.73,49.02 20.18,49.02 19.72,49.48 19.6,49.49 19.3,49.49 19.25,49.48 19.17,49.48 18.64,48.94 18.11,48.94 18.01,49.05 18.01,49.76 18.35,50.1 19.6,50.1 19.66,50.15 19.68,50.18 20.2,50.7 21.07,50.7
+3VPCU on TOP (solid shape): 155.98,15.5 155.98,15.19 156.04,15.04 156.19,14.98 156.38,14.98 156.46,14.9 156.46,14.51 156.43,14.44 156.1,14.3 156,14.04 156,14.01 156.01,13.95 155.79,13.73 155.79,13.09 155.6,12.9 155.6,12.11 155.54,12.05 154.73,12.05 154.42,12.37 151.48,12.37 151.43,12.42 151.43,15.39 151.74,15.69 155.78,15.69
+3VPCU on TOP (solid shape): 125.22,107.06 125.22,105.56 124.31,104.65 123.8,104.65 123.31,105.13 123.06,105.13 122.98,105.2 122.98,106.7 123.11,106.83 124.04,106.83 124.08,106.82 124.09,106.78 124.46,106.42 124.82,106.78 124.8,106.89 124.75,107 124.74,107.1 124.83,107.16 125.12,107.16
+3VPCU on TOP (solid shape): 172.9,104.82 173.81,104.82 173.85,104.86 174.06,104.86 174.16,104.76 174.16,103.82 173.77,103.44 173.68,103.44 173.37,103.12 172.03,103.12 171.86,102.94 171.52,102.94 171.4,102.82 171.4,102.18 171.27,102.05 169.49,102.05 169.24,102.31 169.24,103.71 169.37,103.83 169.87,103.83 170,103.71 170,102.94 170.08,102.87 170.08,102.85 170.21,102.66 170.43,102.58 170.69,102.69 170.8,102.94 170.79,103.02 170.76,103.1 170.76,103.93 171.82,104.99 171.83,104.99 171.97,105.13 172.59,105.13
+3VPCU on TOP (solid shape): 177.87,60.51 177.87,60.24 177.88,60.23 177.88,60.17 177.87,60.16 177.81,60.05 177.8,59.94 177.82,59.81 177.88,59.71 177.89,59.69 177.89,59.65 177.82,59.59 177.82,58.58 177.99,58.41 178.5,58.41 178.56,58.47 178.56,59.13 178.74,59.31 179.22,59.31 179.3,59.23 179.3,58.82 178.97,58.49 178.97,58.17 179.18,57.95 179.38,57.95 179.43,57.91 179.43,57.7 179.4,57.68 178.76,57.68 178.43,58.01 177.66,58.01 177.34,58.33 177.34,59.41 177.21,59.54 177.11,59.54 176.75,59.54 176.68,59.54 175.92,58.77 174.72,58.77 174.62,58.88 174.62,59.06 174.7,59.14 175.12,59.14 175.29,59.3 175.29,59.53 175.61,59.85 175.9,59.85 176.12,60.07 176.12,60.4 176.37,60.65 177.74,60.65
+3VPCU on TOP (solid shape): 170.14,47.87 170.28,47.72 170.47,47.67 170.49,47.67 171.1,47.06 171.1,47 171.13,46.92 171.21,46.89 171.27,46.89 171.4,46.76 171.91,46.76 171.96,46.71 171.96,46.33 171.91,46.28 171.22,46.28 170.87,46.63 170.83,46.66 170.81,46.69 170.77,46.72 170.74,46.76 170.41,46.76 170.36,46.71 170.29,46.77 170.31,46.8 170.34,46.89 170.35,46.97 170.25,47.23 169.99,47.34 169.73,47.23 169.63,46.97 169.73,46.72 169.99,46.61 170.08,46.62 170.16,46.65 170.26,46.65 170.3,46.56 170.3,46.25 170.24,46.18 170.22,46.18 170.13,46.16 170.06,46.12 168.91,46.12 168.78,46.25 168.78,47.27 169.42,47.9 170.13,47.9
+3VPCU on TOP (solid shape): outline of 124 points within 143.63,90.99 149.4,93.59
+3VPCU on TOP (solid shape): outline of 267 points within 195.6,3.12 207.82,10.31
+3VPCU on BOTTOM (solid shape): 69.14,60.7 69.7,60.7 69.9,60.5 69.9,59 69.83,58.93 68.24,58.93 67.97,59.2 67.97,60.7 68.12,60.86 68.98,60.86
+3VPCU on BOTTOM (solid shape): 32.94,76.68 32.94,76.5 32.74,76.3 32.54,76.3 32.38,76.15 32.38,75.38 32.26,75.26 32.1,75.26 32.05,75.31 32.05,75.74 31.95,75.84 31.72,75.84 31.62,75.94 31.62,76.4 31.72,76.5 32.21,76.5 32.51,76.81 32.81,76.81
+3VPCU on BOTTOM (solid shape): 194.66,80.92 194.66,79.96 194.54,79.83 193.88,79.83 193.47,80.24 192.97,80.24 192.85,80.32 192.71,80.35 192.65,80.34 192.6,80.33 192.57,80.32 192.53,80.36 192.53,80.49 192.66,80.62 193.8,80.62 193.95,80.77 193.95,80.92 194.02,80.99 194.6,80.99
+3VPCU on BOTTOM (solid shape): 191.54,90.68 191.54,90.35 191.37,90.17 191.21,90.17 191.21,89.66 191.11,89.56 189.79,89.56 189.71,89.63 189.71,90.04 189.94,90.27 190.1,90.27 190.2,90.23 190.3,90.21 190.46,90.25 190.59,90.36 190.68,90.45 190.68,90.78 190.9,91.01 191.21,91.01
+3VPCU on BOTTOM (solid shape): 184.06,13.35 184.5,13.35 184.61,13.24 184.61,12.24 184.45,12.09 184.2,12.09 184.09,12.2 184.1,12.27 184.11,12.32 184,12.58 183.74,12.68 183.69,12.68 183.64,12.72 182.94,12.72 182.79,12.88 182.79,13.45 182.88,13.54 183.61,13.54 183.74,13.54 183.77,13.55 183.8,13.56 183.84,13.56
+3VPCU on BOTTOM (solid shape): 133.36,16.88 133.42,16.89 133.92,16.89 133.99,16.88 134.06,16.89 134.31,16.89 134.49,16.71 134.49,16.66 134.97,16.18 134.97,15.01 134.82,14.86 133.14,14.86 132.98,15.02 132.98,15.46 133.21,15.58 133.31,15.82 133.21,16.07 132.98,16.18 132.98,16.7 133.17,16.89
+3VPCU on BOTTOM (solid shape): 185.81,54.62 186.15,54.37 186.5,54.62 186.51,54.65 188.64,54.65 188.77,54.53 188.77,54.53 188.77,53.57 187.4,52.21 187.28,52.21 187.22,52.14 187.09,52.14 186.5,51.55 185.91,51.55 185.69,51.33 182.48,51.33 182.4,51.35 182.32,51.36 182.15,51.32 181.99,51.17 181.97,51.17 181.7,51.17 181.69,51.15 181.51,51.15 181.3,51.36 181.3,52.76 181.54,52.99 182.16,52.99 182.24,52.91 183.06,52.91 183.19,52.78 183.31,52.69 183.46,52.66 183.87,52.66 184.02,52.69 184.14,52.78 184.27,52.91 185.22,53.86 185.22,54.53 185.25,54.57 185.26,54.62 185.27,54.65 185.8,54.65
+3VPCU on BOTTOM (solid shape): 58.93,9.19 58.93,8.58 58.9,8.5 58.89,8.43 58.96,8.22 59.14,8.09 59.15,8.08 59.79,7.44 59.79,6.63 60.04,6.37 60.73,6.37 61.9,5.2 64.62,5.2 65.17,4.65 65.17,3.83 65.07,3.73 64.7,3.73 64.14,4.29 61.92,4.29 60.63,5.59 60.49,5.74 60.3,5.8 60.1,5.74 59.97,5.59 59.21,4.82 59.2,4.82 59.1,4.75 59.03,4.65 59.03,4.65 58.88,4.49 58.21,4.49 58.1,4.38 58.1,4 58.05,3.95 57.11,3.95 57.08,3.95 57.05,3.93 56.34,3.93 56,4.26 55.5,4.26 55.07,3.83 54.89,3.83 54.58,4.14 54.58,4.57 54.94,4.93 55.18,4.93 55.2,4.91 58.64,4.91 58.86,5.13 58.86,5.17 58.88,5.18 58.88,7.39 58.86,7.4 58.86,7.46 58.15,8.17 58.15,8.99 58.11,9.02 58.11,9.04 57.91,9.24 57.43,9.24 57.15,9.52 57.15,9.93 57.3,10.08 58.04,10.08
+3VPCU on BOTTOM (solid shape): outline of 85 points within 153.64,66.72 157.4,70.84
+3VPCU on BOTTOM (solid shape): 199.9,22.64 199.9,22.45 199.91,22.41 199.87,22.37 199.85,22.31 199.85,22.23 199.18,21.56 199.11,21.56 199,21.45 192.73,21.45 192.67,21.43 192.62,21.4 192.6,21.38 192.22,21.38 192.1,21.26 192.1,19.76 192.02,19.68 190.78,19.68 190.65,19.81 190.65,20.1 190.67,20.17 190.68,20.21 190.68,20.49 190.67,20.54 190.65,20.6 190.65,21.36 190.07,21.94 190.07,21.95 190,22.04 189.9,22.11 189.89,22.11 189.84,22.17 189.6,22.17 189.49,22.06 189.32,22.06 189.24,22.13 189.24,22.31 189.57,22.63 191.24,22.63 191.24,22.59 191.23,22.55 191.23,22.3 191.3,22.19 191.41,22.11 191.67,22.11 191.76,22.17 191.83,22.26 192.03,22.26 192.46,21.83 193.54,21.83 193.75,22.04 193.85,22.04 193.91,22.07 193.97,22.12 194.04,22.15 194.11,22.12 194.17,22.07 194.23,22.04 194.49,22.04 194.6,22.11 194.67,22.22 194.67,22.41 194.82,22.45 194.93,22.56 195.01,22.63 195.06,22.71 195.24,22.71 195.27,22.68 195.48,22.68 195.53,22.63 196.5,22.63 196.79,22.34 196.79,22.33 196.87,22.23 196.97,22.16 197.24,22.16 197.6,22.16 198.16,22.72 199.83,22.72
+3VPCU on BOTTOM (solid shape): outline of 140 points within 197.81,8.42 200.84,14.11
+3VPCU on IN1 (solid shape): outline of 186 points within 199.31,17.35 202.19,22.75
+3VPCU on IN1 (solid shape): outline of 188 points within 163.23,102.69 172.25,105.09
+3VPCU on IN1 (solid shape): outline of 803 points within 143.71,52.91 178.02,60.69
+3VPCU on IN1 (solid shape): outline of 1398 points within 16.58,43.3 62.38,52.78

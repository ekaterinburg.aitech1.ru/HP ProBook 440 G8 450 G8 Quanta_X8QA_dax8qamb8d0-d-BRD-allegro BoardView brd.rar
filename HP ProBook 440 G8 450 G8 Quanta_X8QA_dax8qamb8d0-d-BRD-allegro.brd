# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Nets (continued)
LCD_P: C1806.1 L3400.1 U1802.D3 U3400.1(OUT)
LED_PWRSTBY#: Q5000.2 R4735.1 R4746.2 R5013.1 U4701.6
LED_PWRSTBY#_CNTR: Q5000.3 R5000.1 R5013.2
LID_OFF_CN: C3401.2 Q3403.2 Q3404.3 R3407.1
LID_SW#_3: CON7602.15 Q7502.3 R7505.2 R7508.2
LID_SW#_EC: Q5201.2 Q7502.1(S) R3411.2 R4803.1 U4700.H4
LIMIT_SIGNAL: EC4.1 PCN8000.4 PR8404.2
LP#: PR8623.1 Q801.3
LPC_ESPI_CLK_R_R: CON7702.11 R7717.1
LPC_ESPI_RESET#_R_R: CON7702.12 R7718.1
M_0_DQ_0<0>: JDIM2800.225 U400.CU49
M_0_DQ_0<1>: JDIM2800.229 U400.CU50
M_0_DQ_0<2>: JDIM2800.228 U400.CU52
M_0_DQ_0<3>: JDIM2800.224 U400.CU53
M_0_DQ_0<4>: JDIM2800.212 U400.CP49
M_0_DQ_0<5>: JDIM2800.215 U400.CP50
M_0_DQ_0<6>: JDIM2800.211 U400.CP52
M_0_DQ_0<7>: JDIM2800.216 U400.CP53
M_0_DQ_1<0>: JDIM2800.208 U400.CL49
M_0_DQ_1<1>: JDIM2800.204 U400.CL50
M_0_DQ_1<2>: JDIM2800.207 U400.CL52
M_0_DQ_1<3>: JDIM2800.203 U400.CL53
M_0_DQ_1<4>: JDIM2800.194 U400.CH49
M_0_DQ_1<5>: JDIM2800.190 U400.CH50
M_0_DQ_1<6>: JDIM2800.195 U400.CH52
M_0_DQ_1<7>: JDIM2800.191 U400.CH53
M_0_DQ_2<0>: JDIM2800.249 U400.CV41
M_0_DQ_2<1>: JDIM2800.236 U400.CT41
M_0_DQ_2<2>: JDIM2800.245 U400.CV42
M_0_DQ_2<3>: JDIM2800.232 U400.CT42
M_0_DQ_2<4>: JDIM2800.246 U400.CV45
M_0_DQ_2<5>: JDIM2800.233 U400.CT45
M_0_DQ_2<6>: JDIM2800.250 U400.CV47
M_0_DQ_2<7>: JDIM2800.237 U400.CT47
M_0_DQ_3<0>: JDIM2800.174 U400.CK41
M_0_DQ_3<1>: JDIM2800.186 U400.CM41
M_0_DQ_3<2>: JDIM2800.182 U400.CM42
M_0_DQ_3<3>: JDIM2800.170 U400.CK42
M_0_DQ_3<4>: JDIM2800.187 U400.CM45
M_0_DQ_3<5>: JDIM2800.169 U400.CK45
M_0_DQ_3<6>: JDIM2800.183 U400.CM47
M_0_DQ_3<7>: JDIM2800.173 U400.CK47
M_0_DQ_4<0>: JDIM2800.49 U400.BH49
M_0_DQ_4<1>: JDIM2800.50 U400.BH50
M_0_DQ_4<2>: JDIM2800.45 U400.BH52
M_0_DQ_4<3>: JDIM2800.46 U400.BH53
M_0_DQ_4<4>: JDIM2800.63 U400.BF49
M_0_DQ_4<5>: JDIM2800.59 U400.BF50
M_0_DQ_4<6>: JDIM2800.58 U400.BF52
M_0_DQ_4<7>: JDIM2800.62 U400.BF53
M_0_DQ_5<0>: JDIM2800.38 U400.BC49
M_0_DQ_5<1>: JDIM2800.41 U400.BC50
M_0_DQ_5<2>: JDIM2800.42 U400.BC52
M_0_DQ_5<3>: JDIM2800.37 U400.BC53
M_0_DQ_5<4>: JDIM2800.29 U400.AY49
M_0_DQ_5<5>: JDIM2800.25 U400.AY50
M_0_DQ_5<6>: JDIM2800.24 U400.AY52
M_0_DQ_5<7>: JDIM2800.28 U400.AY53
M_0_DQ_6<0>: JDIM2800.70 U400.BH41
M_0_DQ_6<1>: JDIM2800.84 U400.BK41
M_0_DQ_6<2>: JDIM2800.80 U400.BK42
M_0_DQ_6<3>: JDIM2800.66 U400.BH42
M_0_DQ_6<4>: JDIM2800.67 U400.BH45
M_0_DQ_6<5>: JDIM2800.71 U400.BH47
M_0_DQ_6<6>: JDIM2800.79 U400.BK45
M_0_DQ_6<7>: JDIM2800.83 U400.BK47
M_0_DQ_7<0>: JDIM2800.17 U400.BD41
M_0_DQ_7<1>: JDIM2800.21 U400.BD42
M_0_DQ_7<2>: JDIM2800.7 U400.BB41
M_0_DQ_7<3>: JDIM2800.3 U400.BB42
M_0_DQ_7<4>: JDIM2800.8 U400.BB45
M_0_DQ_7<5>: JDIM2800.16 U400.BD45
M_0_DQ_7<6>: JDIM2800.4 U400.BB47
M_0_DQ_7<7>: JDIM2800.20 U400.BD47
M_1_DQ_0<0>: JDIM2900.224 U400.AP49
M_1_DQ_0<1>: JDIM2900.225 U400.AP50
M_1_DQ_0<2>: JDIM2900.228 U400.AP52
M_1_DQ_0<3>: JDIM2900.229 U400.AP53
M_1_DQ_0<4>: JDIM2900.216 U400.AL49
M_1_DQ_0<5>: JDIM2900.212 U400.AL50
M_1_DQ_0<6>: JDIM2900.211 U400.AL52
M_1_DQ_0<7>: JDIM2900.215 U400.AL53
M_1_DQ_1<0>: JDIM2900.194 U400.AH49
M_1_DQ_1<1>: JDIM2900.190 U400.AH50
M_1_DQ_1<2>: JDIM2900.191 U400.AH52
M_1_DQ_1<3>: JDIM2900.195 U400.AH53
M_1_DQ_1<4>: JDIM2900.208 U400.AF49
M_1_DQ_1<5>: JDIM2900.204 U400.AF50
M_1_DQ_1<6>: JDIM2900.203 U400.AF52
M_1_DQ_1<7>: JDIM2900.207 U400.AF53
M_1_DQ_2<0>: JDIM2900.250 U400.AV47
M_1_DQ_2<1>: JDIM2900.237 U400.AR47
M_1_DQ_2<2>: JDIM2900.246 U400.AV45
M_1_DQ_2<3>: JDIM2900.233 U400.AR45
M_1_DQ_2<4>: JDIM2900.249 U400.AV41
M_1_DQ_2<5>: JDIM2900.232 U400.AR42
M_1_DQ_2<6>: JDIM2900.245 U400.AV42
M_1_DQ_2<7>: JDIM2900.236 U400.AR41
M_1_DQ_3<0>: JDIM2900.183 U400.AL47
M_1_DQ_3<1>: JDIM2900.187 U400.AL45
M_1_DQ_3<2>: JDIM2900.174 U400.AJ47
M_1_DQ_3<3>: JDIM2900.170 U400.AJ45
M_1_DQ_3<4>: JDIM2900.182 U400.AL42
M_1_DQ_3<5>: JDIM2900.186 U400.AL41
M_1_DQ_3<6>: JDIM2900.169 U400.AJ42
M_1_DQ_3<7>: JDIM2900.173 U400.AJ41
M_1_DQ_4<0>: JDIM2900.63 U400.E47
M_1_DQ_4<1>: JDIM2900.59 U400.D46
M_1_DQ_4<2>: JDIM2900.62 U400.B46
M_1_DQ_4<3>: JDIM2900.58 U400.A46
M_1_DQ_4<4>: JDIM2900.45 U400.E44
M_1_DQ_4<5>: JDIM2900.49 U400.D43
M_1_DQ_4<6>: JDIM2900.50 U400.B43
M_1_DQ_4<7>: JDIM2900.46 U400.A43
M_1_DQ_5<0>: JDIM2900.21 U400.A40
M_1_DQ_5<1>: JDIM2900.17 U400.B40
M_1_DQ_5<2>: JDIM2900.16 U400.D40
M_1_DQ_5<3>: JDIM2900.20 U400.E41
M_1_DQ_5<4>: JDIM2900.8 U400.A38
M_1_DQ_5<5>: JDIM2900.3 U400.B38
M_1_DQ_5<6>: JDIM2900.7 U400.D38
M_1_DQ_5<7>: JDIM2900.4 U400.E38
M_1_DQ_6<0>: JDIM2900.79 U400.J47
M_1_DQ_6<1>: JDIM2900.66 U400.G47
M_1_DQ_6<2>: JDIM2900.83 U400.J45
M_1_DQ_6<3>: JDIM2900.71 U400.G45
M_1_DQ_6<4>: JDIM2900.80 U400.J42
M_1_DQ_6<5>: JDIM2900.84 U400.J41
M_1_DQ_6<6>: JDIM2900.70 U400.G41
M_1_DQ_6<7>: JDIM2900.67 U400.G42
M_1_DQ_7<0>: JDIM2900.38 U400.N38
M_1_DQ_7<1>: JDIM2900.42 U400.L38
M_1_DQ_7<2>: JDIM2900.24 U400.L36
M_1_DQ_7<3>: JDIM2900.28 U400.N36
M_1_DQ_7<4>: JDIM2900.37 U400.H38
M_1_DQ_7<5>: JDIM2900.25 U400.H36
M_1_DQ_7<6>: JDIM2900.29 U400.G36
M_1_DQ_7<7>: JDIM2900.41 U400.G38
M_A_A0: JDIM2800.144 U400.BV41
M_A_A1: JDIM2800.133 U400.CE52
M_A_A2: JDIM2800.132 U400.BV47
M_A_A3: JDIM2800.131 U400.CD53
M_A_A4: JDIM2800.128 U400.CD51
M_A_A5: JDIM2800.126 U400.BY50
M_A_A6: JDIM2800.127 U400.BY52
M_A_A7: JDIM2800.122 U400.CA50
M_A_A8: JDIM2800.125 U400.BY53
M_A_A9: JDIM2800.121 U400.BU50
M_A_A10: JDIM2800.146 U400.BV42
M_A_A11: JDIM2800.120 U400.BT51
M_A_A12: JDIM2800.119 U400.BU53
M_A_A13: JDIM2800.158 U400.CF41
M_A_ACT#: JDIM2800.114 U400.BT53
M_A_ALERT#: JDIM2800.116 U400.AU50
M_A_BG#0: JDIM2800.115 U400.BL52
M_A_BG#1: JDIM2800.113 U400.BN50
M_A_BS#0: JDIM2800.150 U400.BV44
M_A_BS#1: JDIM2800.145 U400.CB42
M_A_CAS#: JDIM2800.156 U400.CB44
M_A_CB0: JDIM2800.92 R2802.2
M_A_CB1: JDIM2800.91 R2803.2
M_A_CB2: JDIM2800.101 R2804.2
M_A_CB3: JDIM2800.105 R2805.2
M_A_CB4: JDIM2800.88 R2806.2
M_A_CB5: JDIM2800.87 R2807.2
M_A_CB6: JDIM2800.100 R2808.2
M_A_CB7: JDIM2800.104 R2809.2
M_A_CKE0: JDIM2800.109 U400.BL50
M_A_CKE1: JDIM2800.110 U400.BU52
M_A_CLKN0: JDIM2800.139 U400.CC53
M_A_CLKN1: JDIM2800.140 U400.BT41
M_A_CLKP0: JDIM2800.137 U400.CC52
M_A_CLKP1: JDIM2800.138 U400.BT42
M_A_CS#0: JDIM2800.149 U400.CF47
M_A_CS#1: JDIM2800.157 U400.CF42
M_A_DQSN0: JDIM2800.219 U400.CR50
M_A_DQSN1: JDIM2800.198 U400.CK50
M_A_DQSN2: JDIM2800.240 U400.CV44
M_A_DQSN3: JDIM2800.177 U400.CM44
M_A_DQSN4: JDIM2800.53 U400.BG50
M_A_DQSN5: JDIM2800.32 U400.BA50
M_A_DQSN6: JDIM2800.74 U400.BH44
M_A_DQSN7: JDIM2800.11 U400.BD44
M_A_DQSN8: JDIM2800.95 R2816.2
M_A_DQSP0: JDIM2800.221 U400.CR51
M_A_DQSP1: JDIM2800.200 U400.CK51
M_A_DQSP2: JDIM2800.242 U400.CT44
M_A_DQSP3: JDIM2800.179 U400.CK44
M_A_DQSP4: JDIM2800.55 U400.BG51
M_A_DQSP5: JDIM2800.34 U400.BA51
M_A_DQSP6: JDIM2800.76 U400.BK44
M_A_DQSP7: JDIM2800.13 U400.BB44
M_A_DQSP8: JDIM2800.97 R2810.2
M_A_ODT0: JDIM2800.155 U400.CF45
M_A_ODT1: JDIM2800.161 U400.CF44
M_A_PARITY: JDIM2800.143 U400.BV45
M_A_RAS#: JDIM2800.152 U400.CB47
M_A_WE#: JDIM2800.151 U400.CB45
M_B_A0: JDIM2900.144 U400.U41
M_B_A1: JDIM2900.133 U400.AC52
M_B_A2: JDIM2900.132 U400.U47
M_B_A3: JDIM2900.131 U400.AA53
M_B_A4: JDIM2900.128 U400.AA51
M_B_A5: JDIM2900.126 U400.U50
M_B_A6: JDIM2900.127 U400.U52
M_B_A7: JDIM2900.122 U400.W50
M_B_A8: JDIM2900.125 U400.U53
M_B_A9: JDIM2900.121 U400.P50
M_B_A10: JDIM2900.146 U400.U42
M_B_A11: JDIM2900.120 U400.N51
M_B_A12: JDIM2900.119 U400.P53
M_B_A13: JDIM2900.158 U400.AE41
M_B_ACT#: JDIM2900.114 U400.N53
M_B_ALERT#: JDIM2900.116 U400.AU53
M_B_BG#0: JDIM2900.115 U400.J52
M_B_BG#1: JDIM2900.113 U400.K50
M_B_BS#0: JDIM2900.150 U400.U44
M_B_BS#1: JDIM2900.145 U400.AA42
M_B_CAS#: JDIM2900.156 U400.AA44
M_B_CB0: JDIM2900.92 R2908.2
M_B_CB1: JDIM2900.91 R2909.2
M_B_CB2: JDIM2900.101 R2910.2
M_B_CB3: JDIM2900.105 R2911.2
M_B_CB4: JDIM2900.88 R2912.2
M_B_CB5: JDIM2900.87 R2913.2
M_B_CB6: JDIM2900.100 R2914.2
M_B_CB7: JDIM2900.104 R2915.2
M_B_CKE0: JDIM2900.109 U400.J50
M_B_CKE1: JDIM2900.110 U400.P52
M_B_CLKN0: JDIM2900.139 U400.Y53
M_B_CLKN1: JDIM2900.140 U400.R42
M_B_CLKP0: JDIM2900.137 U400.Y52
M_B_CLKP1: JDIM2900.138 U400.R41
M_B_CS#0: JDIM2900.149 U400.AE47
M_B_CS#1: JDIM2900.157 U400.AE42
M_B_DQSN0: JDIM2900.219 U400.AN50
M_B_DQSN1: JDIM2900.198 U400.AG50
M_B_DQSN2: JDIM2900.240 U400.AR44
M_B_DQSN3: JDIM2900.177 U400.AL44
M_B_DQSN4: JDIM2900.53 U400.D45
M_B_DQSN5: JDIM2900.11 U400.C39
M_B_DQSN6: JDIM2900.74 U400.J44
M_B_DQSN7: JDIM2900.32 U400.K38
M_B_DQSN8: JDIM2900.95 R2921.2
M_B_DQSP0: JDIM2900.221 U400.AN51
M_B_DQSP1: JDIM2900.200 U400.AG51
M_B_DQSP2: JDIM2900.242 U400.AV44
M_B_DQSP3: JDIM2900.179 U400.AJ44
M_B_DQSP4: JDIM2900.55 U400.C45
M_B_DQSP5: JDIM2900.13 U400.D39
M_B_DQSP6: JDIM2900.76 U400.G44
M_B_DQSP7: JDIM2900.34 U400.K36
M_B_DQSP8: JDIM2900.97 R2918.2
M_B_ODT0: JDIM2900.155 U400.AE45
M_B_ODT1: JDIM2900.161 U400.AE44
M_B_PARITY: JDIM2900.143 U400.U45
M_B_RAS#: JDIM2900.152 U400.AA47
M_B_WE#: JDIM2900.151 U400.AA45
MAIN_BAT_DET#: C4806.1 PC8403.2 PR8226.1 PR8412.1 PR8414.1 U4700.E11
MBP2#: R1035.2 U400.M4
MBP3#: R1036.2 U400.Y1
MD_CH_SEL: R1553.1 U400.DW15
MD_ID1: R1519.2 U400.DR35
MD_ID2: R1518.2 U400.DT32
MD_ID3: R1517.2 U400.DV35
MD_ID4: R1516.2 U400.DW35
ME_UNLOCK#: Q1501.2 R4802.1 U4700.G4
MF_A0: R7007.2 TP7000.1 VRAM7000.J1
MF_A2: R7009.2 R7013.2 TP7001.1 VRAM7001.J1
MIC2-VREFO: R3600.2 U3600.23
MIPI60_OVERRIDE_N: CON7703.1 PQ9601.2 R7707.1 R7726.2
MOD_ID1: R6110.2 R6112.1 U6100.25
MODEM_CLKREQ: R4154.2 U400.DJ10
MODEM_CLKREQ_L: CON4100.14 R4154.1
MP2941_BST1: PR9107.1 PU9100.13
MP2941_BST2: PR9112.1 PU9100.10
MP2941_CLM: PR9111.1 PU9100.14
MP2941_EN: PC9121.2 PR9114.2 PU9100.8
MP2941_FS: PR9117.1 PU9100.7
MP2941_MODE: PR9116.1 PU9100.15
MP2941_PG: PR9108.1 PR9109.2 PU9100.9
MP2941_RGND: PR9118.2 PR9125.2 PU9100.17
MP2941_SW1: PC9109.2 PC9119.2 PL9101.1 PR9110.1 PU9100.11 PU9100.12
MP2941_VCC: PC9100.1 PR9104.2 PU9100.18
MP2941_VID0: PR9106.2 PU9100.6
MP2941_VID1: PR9105.2 PU9100.5
MP2941_VOUT: PR9115.2 PR9124.2 PU9100.16(VOUT)
MP2988_EN: PC9802.2 PD9800.2 PQ9800.2 PR9817.2 PR9832.1 PU9800.2
MP2988_PSI: PR9808.1 PR9810.2 PR9812.1 PU9800.3
MP2988_PWM1: PR9814.2 PU9800.20
MP2988_PWM2: PR9816.2 PU9800.19
MP2988_PWMVID: PR9804.2 PR9805.2 PU9800.6
MP2988_SCL: PR9802.2 PR9803.2 PU9800.5
MP2988_SDA: PR9800.2 PR9801.2 PU9800.4
MP2988_VCC33: PC9803.1 PR9819.2 PU9800.17
MP2988_VDD12: PC9801.1 PU9800.7
MP2988_VINSEN: PC9800.2 PR9806.1 PR9807.2 PU9800.12(VINSEN)
MP2988_VORTN: PR9811.1 PU9800.9
MP2988_VOSEN: PR9813.1 PU9800.10
MSATA_DET#: Q4300.3 R1308.2 R4309.1 U400.DF41
MSATA_DET#_R: CON4300.69 Q4300.2 R4308.1 R4309.2
MSR_ENABLE_N: CON7703.60 R5637.2
N12E_SCL: R6928.1 U6600.C9
N12E_SDA: R6929.1 U6600.C8
NB680A_VOUT: PR8607.1 PU8602.5(VOUT)
NB680ABST: PR8602.1 PU8602.8
NB680ABST_S: PC8609.1 PR8602.2
NB680ABSW: PC8609.2 PL8601.1 PR8605.2 PU8602.7
NB680AEN: PC8616.1 PR8606.2 PR8608.2 PU8602.11
NB680APG: PR8600.2 PU8602.3
NB691_BS: PR9203.2 PU9200.7
NB691_BST: PC9210.1 PR9203.1
NB691_EN: PC9217.1 PR9209.2 PR9210.1 PR10625.2 PU9200.11
NB691_LX: PC9210.2 PL9200.1 PR9207.2 PU9200.6
NB691_PG: PR9206.1 PR9214.1 PU9200.5
NFC_3S_SMCLK: C4406.1 CON4402.8 R806.1 R5208.2 U400.DV18
NFC_3S_SMDATA: C4405.1 CON4402.9 R805.1 R5211.2 U400.DW18
NFC_DETECT#: CON4402.1 R1120.1 R4406.2 U400.DW9
NFC_DWL_REQ: CON4402.5 R4408.2 R4409.1 U4400.4
NFC_DWL_REQ_PCH: R4404.2 R4408.1 U400.DC52 U4400.3
NFC_IRQ: CON4402.11 Q4401.2 R802.1 R4413.2 U400.CY53
NFC_RST#: CON4402.6 CON7704.2 R801.1 U400.CY52
NFC_TAG_INT#: CON7704.3 R4726.2 U4700.F10
NGFF_RESET#_R: C4204.1 CON4202.67 Q4200.3 R4213.2 R4214.1
NMI_SMI_DBG#: CON7702.5 Q4800.1(S) R804.1 U400.CY49
NPCE576H_AGND: C4708.1 C4709.1 C4710.1 C4711.1 C4720.2 C4721.1 R4720.2 U4700.E1
NUM_LOCK_LED#: CON7702.15 R4805.1 R5028.1 U4700.D7
NVVDD: C6605.2 C6607.2 C6608.2 C6613.2 C6614.2 C6616.2 C6617.2 C6622.2 C6626.2 C6631.2 C6637.2 C6638.2 C6639.2 C6641.2 C6644.2 C6647.2 C6649.2 C6662.2 C6663.2 C6664.2 C6665.1 C6666.2 C6667.1 C6668.2 C6669.1 C6670.2 C6671.2 C6672.2 C6674.2 C6675.2 C6677.2 C6686.2 PC9909.1 PC9920.1 PL9900.2 PL9901.2 PR9815.2 PR9825.1 U6600.G1 U6600.G2 U6600.G3 U6600.G4 U6600.G5 U6600.G6 U6600.G7 U6600.H3 U6600.H4 U6600.H6 U6600.J1 U6600.J2 U6600.J3 U6600.J4 U6600.J5 U6600.J6 U6600.J7 U6600.K1 U6600.K2 U6600.K3 U6600.K4 U6600.K5 U6600.K6 U6600.K7 U6600.K10 U6600.K12 U6600.K14 U6600.K16 U6600.K18 U6600.L3 U6600.L4 U6600.L11 U6600.L13 U6600.L15 U6600.L17 U6600.M1 U6600.M2 U6600.M3 U6600.M4 U6600.M5 U6600.M7 U6600.M10 U6600.M12 U6600.M14 U6600.M16 U6600.M18 U6600.N1 U6600.N2 U6600.N3 U6600.N4 U6600.N5 U6600.N7 U6600.N11 U6600.N13 U6600.N15 U6600.N17 U6600.P3 U6600.P4 U6600.P6 U6600.P10 U6600.P12 U6600.P14 U6600.P16 U6600.P18 U6600.R1 U6600.R2 U6600.R3 U6600.R4 U6600.R5 U6600.R6 U6600.R7 U6600.R11 U6600.R13 U6600.R15 U6600.R17 U6600.T1 U6600.T2 U6600.T3 U6600.T4 U6600.T5 U6600.T6 U6600.T7 U6600.T10 U6600.T12 U6600.T14 U6600.T16 U6600.T18 U6600.U3 U6600.U4 U6600.U6 U6600.U11 U6600.U13 U6600.U15 U6600.U17 U6600.V1 U6600.V2 U6600.V3 U6600.V4 U6600.V5 U6600.V6 U6600.V7 U6600.V10 U6600.V12 U6600.V14 U6600.V16 U6600.V18 U6600.W1 U6600.W2 U6600.W3 U6600.W4
NVVDD_PG_LOOP_OVT: Q6903.5 Q6903.6 Q6904.3 R6954.1
NVVDDPG: PR9828.2 PU9800.1 Q6904.2 R6957.1
OCP_CHG#: PR8225.1 PR8410.1
OCP_ID_ADC2: PR8405.1 PR8408.1 R4714.2
OCP_ID_SEL: PQ8402.2 PR8409.2 R4741.1 U4700.K9
OCP_PWM_OUT: PQ8403.2 U4700.G6
OLED_EN: CON3400.36 R3428.1
OLED_EN_R: R3428.2
ON_OFF#: C5031.1 CON5000.7 Q7500.3 R5027.2 R7500.2 R7501.1 R7502.1 VC5001.1
ON_OFF#1_Q: CON7700.11 Q7500.1(S) R4818.2 R7501.2 R7504.1 R7702.2
OVP_DET: PQ8205.2 PQ8405.3 PR8242.2 PR8417.2
PCH_DISP_ON: R3414.2 U400.DM8 U3400.3
PCH_DPST_PWM: R3420.2 R3433.2 R4730.1 U400.DG10
PCH_DPST_PWM_R: R3434.2 U3405.4
PCH_DSWROK: R1527.1 R1529.1 U400.DK35
PCH_IST_TP_0: TP1000.1 U400.DU53
PCH_IST_TP_1: TP1002.1 U400.DT52
PCH_JTAGX: R609.1 U400.D8
PCH_KBC_CLK: PU8201.1 Q5404.6 Q6900.3 R4724.2 U4700.K8
PCH_KBC_DATA: PU8201.5(SMBDATA) Q5404.3 Q6900.6 R4723.2 U4700.K7
PCH_LVDS_BLON: R3402.2 R3405.2 R3425.2 U400.DN8
PCH_OPI_RCOMP: R608.2 U400.CB9
PCH_PWROK: R1513.1 R1574.1 U400.DN35
PCH_SLP_S0IX#: R813.1 R818.1 U400.DU19 U4700.J3
PCH_SLP_SUS#: R1544.2 U400.DV49 U4700.J6
PCH_SMB_CLK: Q1100.6 R1125.1 R1140.1 U400.DK21
PCH_SMB_DATA: Q1100.3 R1126.1 R1133.1 U400.DM19
PCH_SMBCLK: CON7703.53 JDIM2800.253 JDIM2900.253 Q1100.1(S) R1114.1 R1140.2
PCH_SMBDATA: CON7703.51 JDIM2800.254 JDIM2900.254 Q1100.4 R1116.1 R1133.2
PCH_SPI1_CLK: R5110.1 R5601.2 R5602.1 TP5601.1 U5100.19 U5602.6 U5604.6
PCH_SPI1_CLK_E1: R4708.2 R5601.1
PCH_SPI1_CLK_E2: R4708.1 U4700.F12
PCH_SPI1_CLK_R1: C1100.1 R1100.2 R5602.2
PCH_SPI1_CLK_R2: R1100.1 U400.DJ37
PCH_SPI1_SI: R5603.2 R5604.1 R5624.1 R5635.1 TP5602.1 U5100.21 U5602.5 U5604.5
PCH_SPI1_SI_E1: R4709.2 R5603.1
PCH_SPI1_SI_E2: R4709.1 U4700.H11
PCH_SPI1_SI_R1: R1104.2 R1238.1 R5604.2
PCH_SPI1_SI_R2: R1104.1 U400.DJ35
PCH_SPI1_SO: R5108.2 R5605.2 R5606.1 TP5603.1 U5100.24 U5602.2 U5604.2
PCH_SPI1_SO_E1: R4711.2 R5605.1
PCH_SPI1_SO_E2: R4711.1 U4700.G12
PCH_SPI1_SO_R1: R1103.2 R5606.2
PCH_SPI1_SO_R2: R1103.1 U400.DJ33
PCH_SPI_CS0#: R5612.2 R5613.1 R5623.2 TP5600.1 U5602.1 U5604.1
PCH_SPI_CS0#_E1: R4707.2 R5612.1
PCH_SPI_CS0#_E2: R4707.1 U4700.G11
PCH_SPI_CS0#_R1: R1105.2 R5613.2
PCH_SPI_CS0#_R2: R1105.1 U400.DG37
PCH_SPI_IO2: R1245.2 R1246.2 R1248.1 R5607.2 R5626.1 R5627.1 R5637.1 TP5611.1 U5602.3(W\P\(IO2)) U5604.3(W\P\(IO2))
PCH_SPI_IO2_R1: R1102.2 R1246.1 R5607.1
PCH_SPI_IO2_R2: R1102.1 U400.DJ39
PCH_SPI_IO3: R5608.2 R5625.2 TP5610.1 U5602.7 U5604.7
PCH_SPI_IO3_R1: R1101.2 R1221.1 R1224.1 R5608.1
PCH_SPI_IO3_R2: R1101.1 U400.DG35
PCH_TBT_PERST#: R803.1 R1572.2 U400.DJ31 U1502.2
PCH_TCK: CON7703.55 R620.1 TP605.1 U400.A7
PCH_TDI: R610.1 R613.1 U400.B12
PCH_TDO: R607.1 R612.1 U400.E12
PCH_TMS: R605.1 R611.1 U400.A9
PCH_TRST#: R615.1 R618.1 U400.H4
PCH_WLAN_RST#: R812.1 U400.DV19 U4102.2
PCI_PLTRST#: CON4300.50 CON7602.40 Q4800.2 Q5101.2 R1533.1 R1536.2 R1550.2 R4137.1 R4210.1 R5120.1 R7602.1 U1501.4 U1502.1 U4102.1 U4200.1 U6601.2 U7600.1
PCI_PLTRST#_R: CON4202.50 R4209.2 R4210.2 U4200.4(Y)
PCIE4_RCOMPN: R1304.1 U400.V12
PCIE4_RCOMPP: R1304.2 U400.Y12
PCIE_CLKREQ_CR#: Q7600.3 R1411.1 U400.DF23
PCIE_CLKREQ_CR#_R: Q7600.1 U7600.2
PCIE_CLKREQ_LAN#: CON7602.27 R1406.1 U400.DT30
PCIE_CLKREQ_SSD#: C4315.2 CON4300.52 R1408.1 U400.DW30
PCIE_CLKREQ_WLAN#: Q4104.1(S) R1404.1 R4117.2 U400.DG25
PCIE_CLKREQ_WWAN#: C4203.1 CON4202.52 R1403.1 U400.DV30
PCIE_RCOMPN: R1300.1 U400.DT9
PCIE_RCOMPP: R1300.2 U400.DV9
PCIE_REQ_GPU#: Q6600.3 R1402.1 U400.DT24
PCIE_RXN5_LAN: CON7602.24 U400.CK4
PCIE_RXN6_SD: C7605.2 U400.CL3
PCIE_RXN6_SD_C: C7605.1 U7600.8
PCIE_RXN7_WLAN: CON4100.43 U400.CK2
PCIE_RXN8_WWAN: CON4202.41 U400.CN1
PCIE_RXN9_SSD: CON4300.5 U400.CG4
PCIE_RXN10_SSD: CON4300.17 U400.CG1
PCIE_RXN11_SSD: CON4300.29 U400.CF3
PCIE_RXN12_SSD: CON4300.43 U400.CE1
PCIE_RXP5_LAN: CON7602.25 U400.CK5
PCIE_RXP6_SD: C7604.2 U400.CL4
PCIE_RXP6_SD_C: C7604.1 U7600.7
PCIE_RXP7_WLAN: CON4100.41 U400.CK1
PCIE_RXP8_WWAN: CON4202.43 U400.CN2
PCIE_RXP9_SSD: CON4300.7 U400.CG5
PCIE_RXP10_SSD: CON4300.19 U400.CG2
PCIE_RXP11_SSD: CON4300.31 U400.CF4
PCIE_RXP12_SSD: CON4300.41 U400.CE2
PCIE_TXN5_LAN_C: CON7602.21 U400.CB7
PCIE_TXN6_SD: C1305.2 U7600.4
PCIE_TXN6_SD_C: C1305.1 U400.CG7
PCIE_TXN7_WLAN: C1303.1 CON4100.37
PCIE_TXN7_WLAN_C: C1303.2 U400.CD8
PCIE_TXN8_WWAN: C1301.2 CON4202.47
PCIE_TXN8_WWAN_C: C1301.1 U400.CJ7
PCIE_TXN9_SSD: C4304.2 U400.BY8
PCIE_TXN9_SSD_C: C4304.1 CON4300.11
PCIE_TXN10_SSD: C4307.2 U400.BV8
PCIE_TXN10_SSD_C1: C4307.1 CON4300.23
PCIE_TXN11_SSD: C4309.2 U400.BV9
PCIE_TXN11_SSD_C: C4309.1 CON4300.35
PCIE_TXN12_SSD: C4311.2 U400.BT8
PCIE_TXN12_SSD_C: C4311.1 CON4300.47
PCIE_TXP5_LAN_C: CON7602.22 U400.CB8
PCIE_TXP6_SD: C1304.2 U7600.3
PCIE_TXP6_SD_C: C1304.1 U400.CG8
PCIE_TXP7_WLAN: C1302.1 CON4100.35
PCIE_TXP7_WLAN_C: C1302.2 U400.CD9
PCIE_TXP8_WWAN: C1300.2 CON4202.49
PCIE_TXP8_WWAN_C: C1300.1 U400.CJ8
PCIE_TXP9_SSD: C4306.2 U400.BY7
PCIE_TXP9_SSD_C: C4306.1 CON4300.13
PCIE_TXP10_SSD: C4308.2 U400.BV7
PCIE_TXP10_SSD_C1: C4308.1 CON4300.25
PCIE_TXP11_SSD: C4310.2 U400.BT9
PCIE_TXP11_SSD_C: C4310.1 CON4300.37
PCIE_TXP12_SSD: C4312.2 U400.BT7
PCIE_TXP12_SSD_C: C4312.1 CON4300.49
PCIE_WAKE#: CON7602.28 Q4112.3 R1515.1 R4139.2 R4206.2 U400.DK39
PCIE_WAKE#_C: CON4202.23 R4206.1
PD_ADP_DIS1: PQ8003.2 PR8013.2 U4700.H7
PD_I2C_SCL: CON7701.6 R1106.2 R1130.1 U6100.13
PD_I2C_SCL3: CON7701.2 R4739.1 U4700.F8 U6100.32
PD_I2C_SDA: CON7701.7 R1107.2 R1131.1 U6100.16
PD_I2C_SDA3: CON7701.3 R4733.1 U4700.F9 U6100.33
PDB: C3624.1 D3600.2 Q3600.3 R3618.1 R3619.2 U3600.40
PEG_RXN1: C1313.1 U6600.AB9
PEG_RXN1_C: C1313.2 U400.V2
PEG_RXN2: C1309.1 U6600.AC10
PEG_RXN2_C: C1309.2 U400.T2
PEG_RXN3: C1312.2 U6600.AC11
PEG_RXN3_C: C1312.1 U400.R2
PEG_RXN4: C1307.2 U6600.AB12
PEG_RXN4_C: C1307.1 U400.N2
PEG_RXP1: C1311.1 U6600.AC9
PEG_RXP1_C: C1311.2 U400.V1
PEG_RXP2: C1308.1 U6600.AB10
PEG_RXP2_C: C1308.2 U400.T1
PEG_RXP3: C1310.2 U6600.AD11
PEG_RXP3_C: C1310.1 U400.R1
PEG_RXP4: C1306.2 U6600.AC12
PEG_RXP4_C: C1306.1 U400.N1
PEG_TXN1: C6610.1 U400.Y7
PEG_TXN1_C: C6610.2 U6600.AG7
PEG_TXN2: C6634.1 U400.V7
PEG_TXN2_C: C6634.2 U6600.AE7
PEG_TXN3: C6643.1 U400.T7
PEG_TXN3_C: C6643.2 U6600.AF9
PEG_TXN4: C6657.1 U400.P7
PEG_TXN4_C: C6657.2 U6600.AG10
PEG_TXP1: C6609.1 U400.Y5
PEG_TXP1_C: C6609.2 U6600.AG6
PEG_TXP2: C6625.1 U400.V5
PEG_TXP2_C: C6625.2 U6600.AF7
PEG_TXP3: C6640.1 U400.T5
PEG_TXP3_C: C6640.2 U6600.AE9
PEG_TXP4: C6656.1 U400.P5
PEG_TXP4_C: C6656.2 U6600.AG9
PEGX_RST#: C6603.1 Q6902.2 R6611.2 R6944.1 R6954.2 U6600.AC7 U6601.4
PEX_CLKREQ#: Q6601.2 R6602.1 U6600.AC6
PEX_EN_1: PC10504.1 PQ10500.2 PR10506.2 PR10508.1 PU10500.1
PEX_FB: PC10505.2 PR10510.1 PR10511.2 PU10500.6
PEX_FB_1: PC10505.1 PR10505.1 PR10510.2
PEX_LX: PL10500.1 PU10500.3
PEX_PG_3: PR10501.2 PR10503.1 PU10500.5
PEX_TERMP: R6617.2 U6600.AF25
PEX_TSTCLK: R6612.2 U6600.AF22
PEX_TSTCLK#: R6612.1 U6600.AE22
PEX_VDD: C6600.2 C6601.2 C6602.2 C6604.1 C6606.1 C6612.1 C6615.1 C6687.1 C6688.1 C6689.1 C6693.2 PR10502.2 PR10504.1 R6808.2 TP6600.1 U6600.AA22 U6600.AB23 U6600.AC24 U6600.AD25 U6600.AE26 U6600.AE27
PEX_VDD_PG: PR10503.2 R6710.2 U6701.2
PEXVDD_EN: PR10506.1 U6902.4
PEXVDD_EN1: C6901.1 D6901.2 R6960.2 R6961.2 U6902.2
PLAY_MUTE_LED: Q5004.3 R5009.1
PLAY_MUTE_LED_CNTR: R3611.1 R5018.1 U3600.3
PLT_DET: R4823.1 R4824.1 U4700.D2
PLT_ID1: R1134.2 R1135.1 U400.DN15
PLT_ID2: R1136.2 R1137.1 U400.DJ15
PLT_ID4: R1141.2 R1142.1 U400.DM13
PLTRST#: Q1502.2 R1509.2 R1536.1 U1501.1 U1501.2 U4700.J5
PLTRST#_PCH: R1509.1 U400.DD41
PM_EXTTS#0: JDIM2800.134 R2801.2
PM_EXTTS#1: JDIM2900.134 R2901.2
PM_PWROK: R4811.1 U400.DF10 U4700.K4
PM_SLP_A#: CON7700.6 PR8110.2 R1537.2 U400.DR41
PM_THRMTRIP#: R604.1 U400.M5
PP_DETECT#: Q3405.3 U4700.G10
PP_DETECT#_EDP: CON3400.12 Q3405.2 R3431.2 U3405.6
PP_HVA: CON3400.31 R4821.1 U4700.H6
PRE: R3504.1 R3505.1 U3501.15
PRIVACY_LED#_R: R5002.1 U4700.D4
PROCHOT#_CPU: R603.2 U400.E2
PROCPWRGD: R1549.2 U400.BM9
PSI: PR9810.1 R6951.1 U6600.A4
PVADPTR: PC8200.1 PC8201.2 PD8001.1 PD8202.2 PQ8006.1 PQ8006.2 PQ8006.3(S3) PQ8007.1 PQ8007.2 PQ8007.3(S3) PQ8012.1 PQ8013.1 PR8200.1 PR8201.2 PR8210.2 PR8240.1 PR8400.1 PR8413.2
PVCORE_PG: PR8825.1 PR9109.1 R1513.2
PVT_CS#: R4701.2 R5629.2 TP5617.1 U5603.1 U5605.1
PVT_CS#_L: R4701.1 U4700.L10
PVT_DIO2: R4705.2 R5633.1 TP5612.1
PVT_DIO2_L: R4705.1 U4700.M11
PVT_DIO3: R4706.2 R5634.2
PVT_DIO3_L: R4706.1 U4700.L11
PVT_HOLD: R5631.2 R5634.1 TP5613.1 U5603.7 U5605.7
PVT_MOSI: R4703.2 TP5615.1 U5603.5 U5605.5
PVT_MOSI_L: R4703.1 U4700.K12
PVT_SCLK: R4702.2 TP5614.1 U5603.6 U5605.6
PVT_SCLK_L: R4702.1 U4700.L12
PVT_SPI_MISO: R4704.2 R5630.1
PVT_SPI_MISO_L: R4704.1 U4700.M12
PVT_SPI_MISO_R: R5630.2 TP5616.1 U5603.2 U5605.2
PWM1: PR8902.1 PU8800.14
PWM1_R: PR8902.2 PU8900.22
PWM2: PR8909.1 PU8800.15
PWM2_R: PR8909.2 PU8901.22
PWM_EC_IN: C4713.1 R4731.2 R4732.1 U4700.F3
PWM_EC_OUT: R3432.2 U4700.K5
PWM_EC_OUT_R: R3432.1 U3405.1
PWM_LED#: Q5006.2 U4700.H10
PWR_BTN_OUT#: R4817.2 R4819.1 U400.DK41 U4700.D9
PWR_BUT_OUT: R7504.2 U7500.7
PWR_GOOD_3: C4807.1 D1500.1(CATHODE) PC8104.2 PR8115.2 PR8117.1 PU8100.1 R3309.1 U4700.M4
PWR_LEVEL: D6902.2 R6950.2 U6600.D7
PWRBTN#: C4808.2 R4816.2 R4818.1 R4819.2 U4700.G5
R_INB0_SCL: CON1900.2 R1901.1
R_INB0_SDA: CON1900.3 R1902.1
R_INB1_SCL: CON1900.9 R1903.1
R_INB1_SDA: CON1900.8 R1904.1
R_SPK+: C3628.2 CON3601.4 U3600.38
R_SPK-: C3627.2 CON3601.3 U3600.37
REC_MUTE_LED: Q5001.3 R5007.1
RECORD_MUTE_LED_CNTRL: R3616.2 R5016.1
REGN6V: PC8210.1 PD8203.1 PU8200.24
REQ_WLAN#: C4109.1 CON4100.53 Q4104.3 R4113.2 R4117.1
RFFE_SCLK: CON4203.3 R4228.2
RFFE_SCLK_R: C4218.2 CON4202.56 R4228.1 R4230.1
RFFE_SDATA: CON4203.2 R4229.2
RFFE_SDATA_R: C4219.2 CON4202.58 R4229.1
RFID_BEEP: Q4400.3 R4404.1 U4400.1
RFID_BEEP_EN#: Q4400.2 R1414.1 U400.DK25
RFID_CODEC_WAKE#: Q4401.3 R1407.1 R3610.1 R4413.1 U400.DN25
RFID_MOS_BEEP: Q4400.4 R4411.1
RFID_PRESENT: R4405.2 U400.DM25
ROM_CS: R6831.2 TP6902.1 U6600.D12
ROM_CS_R: R6826.2 R6831.1 TP6800.1 U6801.1
ROM_SCLK: R6838.2 R6904.1 R6913.2 U6600.C12
ROM_SCLK_R: R6838.1 TP6806.1 U6801.6
ROM_SI: R6828.1 R6902.1 R6911.2 U6600.B12
ROM_SI_R: R6828.2 TP6805.1 U6801.5
ROM_SO: R6903.1 R6912.2 TP6803.1 U6600.A12 U6801.2
RSMRST#: Q1000.3 Q4703.6 R1005.1 R4808.2 R7705.1 R7724.1 U400.DM35
RSMRST#_R: R4808.1 R4809.1 U4700.M10
RSMRST_PG: PR8116.2 PR8118.2 PU8100.7(OUT) U4700.H9
RSVD_TP_2: TP1021.1 U400.AL10
RSVD_TP_3: TP1022.1 U400.AM12
RSVD_TP_4: TP1024.1 U400.AH12
RSVD_TP_5: TP1026.1 U400.AJ10
RSVD_TP_6: TP1027.1 U400.AR1
RSVD_TP_7: TP1003.1 U400.A51
RSVD_TP_8: TP1001.1 U400.B51
RSVD_TP_9: TP1005.1 U400.C1
RSVD_TP_10: TP1006.1 U400.D2
RSVD_TP_11: TP1007.1 U400.CP39
RSVD_TP_12: TP1008.1 U400.CU40
RSVD_TP_13: TP1009.1 U400.DV4
RSVD_TP_14: TP1010.1 U400.DW3
RSVD_TP_15: TP1013.1 U400.DU1
RSVD_TP_16: TP1014.1 U400.DT2
RSVD_TP_17: TP1015.1 U400.DW2
RSVD_TP_18: TP1016.1 U400.DV2
RSVD_TP_19: TP1017.1 U400.E1
RSVD_TP_20: TP1018.1 U400.F1
RSVD_TP_21: TP1019.1 U400.DR1
RSVD_TP_22: TP1020.1 U400.DR2
RSVD_TP_23: TP1023.1 U400.DR53
RSVD_TP_24: TP1025.1 U400.DW5
RTC_DET#: Q1400.3 R820.1 U400.DT19
RTC_REST1#_CL: R7506.2 U7500.3
RTC_RST2_CL1: R7503.1 R7509.1 U7500.6
RTC_RST2_CL2: Q7507.2 R7516.1
RTC_RST2_CL3: Q7508.2 R7518.1
RTC_RST#: C1400.1 CON7700.9 Q7508.3 R1416.2 R1421.1 U400.DN37
RTC_SR01#_CL: Q7506.2 R7502.2 U7500.2
RTC_X1: R1423.1 U400.DR47
RTC_X1_R: C1403.2 R1423.2 R1425.1 Y1400.1
RTC_X2: R1428.1 U400.DT47
RTC_X2_R: C1405.2 R1425.2 R1427.1 R1428.2
SC_PWRSV#: CON4400.3 R1525.2 U400.DG31
SCL_BAT_CHG: PD8401.2 PR8224.2 PR8419.2 R4721.2 U4700.C12
SD_CD#_R: CON7600.9 R7611.2
SD_CMD_R: CON7600.3 R7610.2
SD_MMC_CD#: R7611.1 U7600.30
SD_MMC_CLK: C7606.1 CON7600.5 R7605.2
SD_MMC_CLK_C: R7605.1 U7600.17
SD_MMC_CMD: R7610.1 U7600.19
SD_MMC_DATA0: C7608.1 CON7600.7 R7608.2
SD_MMC_DATA0_C: R7608.1 U7600.16
SD_MMC_DATA1: C7609.1 CON7600.8 R7609.2
SD_MMC_DATA1_C: R7609.1 U7600.15
SD_MMC_DATA2: C7602.1 CON7600.1 R7603.2
SD_MMC_DATA2_C: R7603.1 U7600.21
SD_MMC_DATA3: C7603.1 CON7600.2 R7604.2
SD_MMC_DATA3_C: R7604.1 U7600.20
SD_MMC_WP: R7613.2 U7600.29
SD_PWR_EN#_R: TP609.1 U400.DV32
SDA_BAT_CHG: PD8400.2 PR8223.2 PR8418.2 R4722.2 U4700.B12
SEN_A0: R7004.2 VRAM7000.J10
SEN_A2: R7006.2 VRAM7001.J10
SG_IN: R1143.2 R1144.1 U400.DN10
SKTOCC#: R1007.1 U400.D52
SLEEVE_C: C3701.2 CON3700.3 D3703.1 R3700.1
SLEEVE_L: R3600.1 R3700.2 U3600.14
SLG4E_SR1: R7505.1 U7500.4
SLP_LAN#: R1540.2 R4751.2 U400.DN39
SLP_S0#: CON7700.15 R1521.1 R1522.1 U400.DD42
SLP_S3#_3R: PD9600.2 PQ8703.2 PR8109.2 PR9514.1 PR9518.1 PR9520.1 PR10623.2 PU10602.2 R1506.2 R1542.2 U4700.D6 U6203.6
SLP_S3#_3R_3: PR9507.2 PR9518.2
SLP_S3#_3R_5: PR9504.1 PR9520.2
SLP_S3#_3R_PCH: R1506.1 U400.DJ43
SLP_S3_5R: PQ8703.5 PQ8703.6 PR8720.1
SLP_S4#_3R: CON7602.39 CON7700.5 D3300.1 PD8700.2 PR8724.1 R1505.2 R1541.2 R3302.1 U4700.F11 U6202.4 U6203.7
SLP_S4#_3R_PCH: R1505.1 U400.DJ41
SLP_S5#_3R: CON7700.4 R5927.2 U400.DM43
SM_VREF: C2828.1 R2815.1 U400.AU49
SMB_ALERT#: R1226.2 R1227.2 R1229.1 U400.DN19
SMB_PCH_CLK: R816.2 U400.DB45
SMB_PCH_DAT: R815.2 U400.DB44
SMB_PCH_R_CLK: R1106.1 U400.DK17
SMB_PCH_R_DAT: R1107.1 U400.DJ17
SMB_SML0_CLK: C5940.2 CON7602.36 R1128.1 R5916.2 U400.DK19
SMB_SML0_DAT: C5941.2 CON7602.37 R1129.1 R5918.2 U400.DM17
SMC: PC8410.2 PCN8400.6 PR8419.1
SMD: PC8409.2 PCN8400.7 PR8418.1
SMDDR_VREF_DQ1_M1: C2926.1 C2927.1 R2900.2 R2916.1 R2917.2 R2919.2
SMDDR_VREF_DQ1_M3: C2928.1 C2929.1 R2919.1 U400.AU52
SML0_ALERT#: R1234.2 R1235.1 U400.DN17
SN3V: PC8610.1 PR8605.1
SN5V: PC8629.1 PR8614.1
SN_CHG: PC8219.1 PR8218.1
SN_DDR: PC8720.2 PR8708.1
SN_GPU1: PC9910.1 PR9901.2
SN_GPU2: PC9921.1 PR9902.2
SN_VCCIN1: PC8919.1 PR8904.2
SN_VCCIN2: PC8938.1 PR8911.2
SNDW_RCOMP: R1504.1 U400.DF33
SPI_TPM_CS#: R5101.2 TP5101.1 U400.DF39 U5100.20
SRTC_RST#: C1402.1 Q7507.3 R1418.2 R1421.2 U400.DK37
STRAP0: R6905.1 R6914.2 U6600.D1
STRAP1: R6906.1 R6915.2 U6600.D2
STRAP2: R6907.1 R6916.2 U6600.E4
STRAP3: R6908.1 R6917.2 U6600.E3
STRAP4: R6909.1 R6918.2 U6600.D3
STRAP5: R6910.1 R6919.2 U6600.C1
SUSCLK32_KBC: R4131.1 U400.DW41 U4700.L5
SUSCLK32_KBC_WLAN: CON4100.50 R4131.2
SY127F_BST: PR8612.1 PU8601.13
SY127F_BST_S: PC8628.1 PR8612.2
SY127F_BYP: PC8635.2 PR8615.2 PR8620.2 PU8601.8
SY127F_EN: PC8636.1 PR8619.2 PR8621.1 PU8601.6
SY127F_FB: PR8618.1 PR8620.1 PR8622.2 PU8601.7
SY127F_FB_S: PC8635.1 PR8618.2
SY127F_LDOEN: PR8613.2 PR8616.1 PU8601.5
SY127F_LX: PC8628.2 PL8604.1 PR8614.2 PU8601.2 PU8601.12
SY127F_PG: PR8617.2 PU8601.4
SY8386_FB: PC9218.2 PR9212.1 PR9213.2 PU9200.10
SYS_RESET#: C7701.2 CON7700.13 CON7703.48 R1526.2 U400.DD10
TACH_FAN2_IN_R: C5404.1 C5405.2 CON5400.2 R5404.2
TACH_FAN_IN: C5403.1 R5403.2 R5404.1 U4700.E10
TBT_CYPRE_INT: CON7701.12 R5923.2 R6129.1
TBT_FORCE_PWR: CON7701.13 R1501.1 R5929.1 R5930.1 R6102.2 U5900.B10
TBT_FORCE_PWR_GPPA23: R1501.2 U400.DG41
TBT_LSX0_RXD: R1207.2 R1215.1 R5917.1 U400.DV8 U5900.L7
TBT_LSX0_TXD: R5915.1 U400.DU8 U5900.M7
TBT_LSX1_RXD: R1208.2 R1216.1 U400.DD6
TBT_LSX2_RXD: R1209.2 R1217.1 U400.DM23
TBT_LSX3_RXD: R1210.2 R1218.1 U400.DN21
TBT_MRESET: R4742.1 U4700.F5
TBT_PD_I2C_SCL: CON7701.10 R5919.2 R6108.1 U6100.29
TBT_PD_I2C_SDA: CON7701.11 R5921.2 R6107.1 U6100.28
TBTA_I2C_INT#_R: R5923.1 U5900.A10
TBTA_I2C_SCL_R: R5919.1 U5900.C9
TBTA_I2C_SDA_R: R5921.1 U5900.E7
TBTA_SSRX1_N: R5902.1 U5900.J11
TBTA_SSRX1_N_C: C6309.2 D5907.1 R5902.2 R5955.2
TBTA_SSRX1_P: R5900.1 U5900.J12
TBTA_SSRX1_P_C: C6308.2 D5906.1 R5900.2 R5953.2
TBTA_SSRX2_N: R5906.1 U5900.C11
TBTA_SSRX2_N_C: C6313.2 D5903.1 R5906.2 R5963.2
TBTA_SSRX2_P: R5905.1 U5900.C12
TBTA_SSRX2_P_C: C6312.2 D5902.1 R5905.2 R5961.2
TBTA_SSTX1_N: R5904.1 U5900.G11
TBTA_SSTX1_N_C: C6311.2 D5905.1 R5904.2 R5951.2
TBTA_SSTX1_P: R5903.1 U5900.G12
TBTA_SSTX1_P_C: C6310.2 D5904.1 R5903.2 R5949.2
TBTA_SSTX2_N: R5908.1 U5900.E11
TBTA_SSTX2_N_C: C6315.2 D5901.1 R5908.2 R5959.2
TBTA_SSTX2_P: R5907.1 U5900.E12
TBTA_SSTX2_P_C: C6314.2 D5900.1 R5907.2 R5957.2
TCP0_AUX_DN: C6111.2 R5912.2 U400.AP5
TCP0_AUX_DN_R: R5912.1 U5900.M8
TCP0_AUX_DP: C6110.2 R5911.2 U400.AP7
TCP0_AUX_DP_R: R5911.1 U5900.L8
TCP0_DIRECT_TX0_R_DN: R5950.1 R5951.1
TCP0_DIRECT_TX0_R_DP: R5947.1 R5949.1
TCP0_DIRECT_TX1_R_DN: R5958.1 R5959.1
TCP0_DIRECT_TX1_R_DP: R5956.1 R5957.1
TCP0_DIRECT_TXRX0_R_DN: R5954.1 R5955.1
TCP0_DIRECT_TXRX0_R_DP: R5952.1 R5953.1
TCP0_DIRECT_TXRX1_R_DN: R5962.1 R5963.1
TCP0_DIRECT_TXRX1_R_DP: R5960.1 R5961.1
TCP0_FLASH_CLK: TP5911.1 U5900.C7 U5901.6 U5902.6
TCP0_FLASH_CS#: R5942.1 TP5910.1 U5900.B6 U5901.1 U5902.1
TCP0_FLASH_DI: TP5908.1 U5900.C6 U5901.5 U5902.5
TCP0_FLASH_DO: R5944.1 TP5909.1 U5900.B4 U5901.2 U5902.2
TCP0_FLASH_HOLD#: R5940.1 TP5906.1 U5901.7 U5902.7
TCP0_FLASH_MSTR_SLV: R5933.1 U5900.A5
TCP0_FLASH_SHARE_EN: R5932.1 U5900.A4
TCP0_FLASH_WP#: R5945.1 TP5907.1 U5901.3(W\P\) U5902.3(W\P\(IO2))
TCP0_GPIO_5: R5924.1 U5900.B9
TCP0_GPIO_6: R5925.2 R5926.1 U5900.A8
TCP0_GPIO_12: R5934.1 R5935.1 U5900.A6
TCP0_JTAG_TCK: R5941.1 TP5902.1 U5900.B5
TCP0_JTAG_TDI: R5937.1 TP5900.1 U5900.A3
TCP0_JTAG_TDO: R5943.1 TP5903.1 U5900.C5
TCP0_JTAG_TMS: R5939.1 TP5901.1 U5900.C3
TCP0_RESET#: R5927.1 R5928.1 U5900.L11
TCP0_TEST_PWRGD: R5922.1 U5900.B3
TCP0_THERMDA: TP5904.1 U5900.M11
TCP0_TX_N0: C5901.2 R5950.2 U400.AT5
TCP0_TX_N0_C: C5901.1 U5900.J2
TCP0_TX_N1: C5909.2 R5958.2 U400.AM7
TCP0_TX_N1_C: C5909.1 U5900.C2
TCP0_TX_P0: C5900.2 R5947.2 U400.AT7
TCP0_TX_P0_C: C5900.1 U5900.J1
TCP0_TX_P1: C5908.2 R5956.2 U400.AM5
TCP0_TX_P1_C: C5908.1 U5900.C1
TCP0_TXRX_N0: C5905.2 R5954.2 U400.BB2
TCP0_TXRX_N0_C: C5905.1 U5900.G2
TCP0_TXRX_N1: C5913.2 R5962.2 U400.AY1
TCP0_TXRX_N1_C: C5913.1 U5900.E2
TCP0_TXRX_P0: C5904.2 R5952.2 U400.BB1
TCP0_TXRX_P0_C: C5904.1 U5900.G1
TCP0_TXRX_P1: C5912.2 R5960.2 U400.AY2
TCP0_TXRX_P1_C: C5912.1 U5900.E1
TCP1_AUX_CTRL: R6125.2 U6100.12
TCP1_AUX_CTRL_R: R6124.1 R6125.1 U6101.6
TCP1_AUX_DN_C: C6111.1 R6117.1 U6101.7
TCP1_AUX_DP_C: C6110.1 R6119.1 U6101.8
TCP01_FLASH_BUSY#: R5938.2 U5900.A9
TCP1_RESET#_R: CON7701.14 TP7705.1
TCP_RETIMER_PERST#: R1550.1 R1562.1 R1572.1 U1502.4 U5900.B8
TCRCOMP_DN: R400.2 U400.AN1
TCRCOMP_DP: R400.1 U400.AN2
TESTMODE: R6616.1 U6600.AD9(NVJTAG_SEL)
THERM+: TP6904.1 U6600.F12
THERM-: TP6903.1 U6600.E12
THERM_SCI#: R625.1 U400.DU5 U5400.6
THERM_SCL: Q5404.1(S) R5418.2 U5400.8 U5403.8
THERM_SDA: Q5404.4 R5417.2 U5400.7 U5403.7
THERMDA_1: C5411.1 Q5403.2 Q5403.3 U5400.2
THERMDC_1: C5411.2 Q5403.1(EMITTER) U5400.3
TILE_I2C_INT_EC: R4233.1 R4749.2 U4700.D5
TILE_TAG_I2C_SCL: CON7704.6 R4231.1 R4727.2 U4700.J8
TILE_TAG_I2C_SDA: CON7704.7 R4232.1 R4728.2 U4700.J9
TOUCH_INT#: CON3400.39 R3400.2 U400.DR21
TOUCH_PWR_EN: R1548.2 R3422.1 U400.DW24
TOUCH_RST#: CON3400.26 R3406.2 U400.DR18
TP_3: TP1028.1 U400.DW52
TP_4: TP1029.1 U400.DV53
TP_L34: TP1030.1 U400.DD13
TP_M34: TP1004.1 U400.DF53
TP_SCAN_DISABLE#: CON5200.8 CON5202.1 Q5202.3 R5218.1 U4700.D8
TPCLK-1: C5204.1 CON5202.3 R5203.2
TPDATA-1: C5205.1 CON5202.2 R5204.2
TPM_PIRQ#: R5100.2 U400.DR30 U5100.18
TPM_PLTRST#: Q5101.3 R5120.2 R5125.2 U5100.17
TPM_PP: R5123.2 R5124.1 R5126.2 R5128.1
TPS2546_EN: R6203.1 U6203.5
TS_VREF: U6600.AE2
TX0_HDMI+: CON3501.7 R3502.1 U3501.22
TX0_HDMI-: CON3501.9 R3502.2 U3501.21
TX1_HDMI+: CON3501.4 R3501.1 U3501.24
TX1_HDMI-: CON3501.6 R3501.2 U3501.23
TX2_HDMI+: CON3501.1 R3500.1 U3501.27
TX2_HDMI-: CON3501.3 R3500.2 U3501.26
TXC_HDMI+: CON3501.10 R3503.1 U3501.19
TXC_HDMI-: CON3501.12 R3503.2 U3501.18
TXLOUT0+: C3415.1 CON3400.13
TXLOUT0-: C3417.1 CON3400.14
TXLOUT1+: C3409.2 CON3400.16
TXLOUT1-: C3411.2 CON3400.17
TYPEC1_USB0: PC8004.1 PC8006.2 PQ8001.1 PQ8001.2 PQ8001.3(S_3) PQ8006.5 PR8028.1 PR8216.2
TYPEC3_RX1N_C: C6309.1 CON6300.A10 R6309.1
TYPEC3_RX1P_C: C6308.1 CON6300.A11 R6308.1
TYPEC3_RX2N_C: C6313.1 CON6300.B10 R6310.1
TYPEC3_RX2P_C: C6312.1 CON6300.B11 R6311.1
TYPEC3_TX1N_C: C6311.1 CON6300.B3 R6305.1
TYPEC3_TX1P_C: C6310.1 CON6300.B2 R6304.1
TYPEC3_TX2N_C: C6315.1 CON6300.A3 R6306.1
TYPEC3_TX2P_C: C6314.1 CON6300.A2 R6307.1
TYPEC_CC1: C6107.2 CON6300.B5 D6309.1 U6100.46
TYPEC_CC2: C6108.2 CON6300.A5 D6310.1 U6100.44
TYPEC_SBU1: CON6300.B8 D6306.1 R6314.2 U6100.42
TYPEC_SBU2: CON6300.A8 D6307.1 R6319.2 U6100.43
TYPEC_VBUS: C6306.1 CON6300.A4 CON6300.A9 CON6300.B4 CON6300.B9(VBUS_4) D6300.1 PC8003.2 PQ8001.5 U6100.1 U6100.2 U6100.3 U6100.48
UART2_RXD: CON7702.29 R7723.2 TP7707.1 U400.DG23
UART2_TXD: CON7702.28 R7722.2 TP7706.1 U400.DJ21
UIM_CLK: CON4202.32 D4205.2 R4217.1 R4218.1
UIM_CLK_400: CON4204.3 R4218.2
UIM_CLK_600: R4217.2
UIM_DATA: CON4202.34 D4203.2 R4219.1 R4220.1 R4221.1
UIM_DATA_400: CON4204.7 R4221.2
UIM_DATA_600: R4219.2
UIM_RESET: CON4202.30 D4204.2 R4226.1 R4227.1
UIM_RST_400: CON4204.2 R4227.2
UIM_RST_600: R4226.2
UIM_VPP_400: CON4204.6(VPP) TP4201.1
UIM_VPP_600: TP4203.1
USB2_COMP: R1303.1 U400.DE1
USB30_RX1+: CON6201.6 U400.CV2 U6201.2 U6201.9
USB30_RX1-: CON6201.5 U400.CV1 U6201.1 U6201.10
USB30_RX2+: CON6202.6 U400.CU3 U6200.2 U6200.9
USB30_RX2-: CON6202.5 U400.CT4 U6200.1 U6200.10
USB30_RX4+: CON7603.5 U400.CN5
USB30_RX4-: CON7603.6 U400.CN4
USB30_TX1+: C6207.1 U400.DA8
USB30_TX1+_C: C6207.2 CON6201.9 U6201.5 U6201.6(NC_4)
USB30_TX1-: C6206.1 U400.DA7
USB30_TX1-_C: C6206.2 CON6201.8 U6201.4 U6201.7
USB30_TX2+: C6209.1 U400.CW8
USB30_TX2+_C: C6209.2 CON6202.9 U6200.5 U6200.6(NC_4)
USB30_TX2-: C6208.1 U400.CW7
USB30_TX2-_C: C6208.2 CON6202.8 U6200.4 U6200.7
USB30_TX4+: CON7603.1 U400.CR8
USB30_TX4-: CON7603.2 U400.CR7
USB_CHARGER_STATUS#: R4820.2 U4700.G2 U6203.9(S\T\A\T\U\S\)
USB_CYPRESS_BOT_DN: CON6300.A7 D6314.2 U6100.21
USB_CYPRESS_BOT_DP: CON6300.A6 D6314.1 U6100.20
USB_CYPRESS_TOP_DN: CON6300.B7 D6313.2 U6100.19
USB_CYPRESS_TOP_DP: CON6300.B6 D6313.1 U6100.18
USB_ID: R1302.2 U400.DF1
USB_OC1#: R406.2 U400.DH52
USB_OC2#: R407.2 U400.DK45
USB_OC3#: R1306.2 U400.DJ45
USB_VBUSSENSE: R1301.2 U400.DC12
USBC_ALT_AUX_NBIAS: R6117.2 U400.DT6
USBC_ALT_AUX_PBIAS: R6119.2 U400.DN4
USBP1+: U400.DC11 U6203.3
USBP1+_C: C6210.1 CON6201.3 L6200.1
USBP1+_CHA: L6200.2 U6203.10
USBP1-: U400.DC9 U6203.2
USBP1-_C: C6210.2 CON6201.2 L6200.4
USBP1-_CHA: L6200.3 U6203.11
USBP2+: R3410.2 U400.DA5
USBP2+_C: CON3400.32 R3410.1
USBP2-: R3408.2 U400.DA4
USBP2-_C: CON3400.33 R3408.1
USBP4+: L6201.2 U400.DC8
USBP4+_C: C6211.1 CON6202.3 L6201.1
USBP4-: L6201.3 U400.DC7
USBP4-_C: C6211.2 CON6202.2 L6201.4
USBP5+: U400.DA12 U6100.23
USBP5-: U400.DA11 U6100.22
USBP6+: CON7602.13 U400.DA1
USBP6-: CON7602.12 U400.DA2
USBP7+: R5201.2 U400.DD1
USBP7+_C: C5203.2 CON5200.4 R5201.1
USBP7-: R5200.2 U400.DD2
USBP7-_C: C5203.1 CON5200.3 R5200.1
USBP8+: R4417.2 U400.DB4
USBP8+_C: CON4400.6 R4417.1
USBP8-: R4416.2 U400.DB3
USBP8-_C: CON4400.5 R4416.1
USBP9+: CON4402.13 U400.DD5
USBP9-: CON4402.4 U400.DD4
USBP10+: R4119.2 U400.CV4
USBP10+_C: CON4100.3 R4119.1
USBP10-: R4120.2 U400.CY3
USBP10-_C: CON4100.5 R4120.1
USIM_DETECT: CON4202.66 D4206.2
V_ADP_ADC4: PC8401.2 PR8401.1 PR8403.2 R4717.2
V_ADP_ADC4_R: C4711.2 R4717.1 U4700.C2
VADJ1: C3427.1 CON3400.6 R3434.1
VADPBL: C7217.1 C7218.1 PQ8000.5 PQ8007.5 PR8029.1 PR8214.2
VGA_OVT#: Q6902.1(S) R6952.1 U6600.A6
VMA_CLK0: R7014.1 U6600.D24 VRAM7000.J12
VMA_CLK0#: R7015.1 U6600.D25 VRAM7000.J11
VMA_CLK1: R7008.1 U6600.N22 VRAM7001.J12
VMA_CLK1#: R7010.1 U6600.M22 VRAM7001.J11
VMA_DQ0: U6600.E18 VRAM7000.A4
VMA_DQ1: U6600.F18 VRAM7000.A2
VMA_DQ2: U6600.E16 VRAM7000.B4
VMA_DQ3: U6600.F17 VRAM7000.B2
VMA_DQ4: U6600.D20 VRAM7000.E4
VMA_DQ5: U6600.D21 VRAM7000.E2
VMA_DQ6: U6600.F20 VRAM7000.F4
VMA_DQ7: U6600.E21 VRAM7000.F2
VMA_DQ8: U6600.E15 VRAM7000.A11
VMA_DQ9: U6600.D15 VRAM7000.A13
VMA_DQ10: U6600.F15 VRAM7000.B11
VMA_DQ11: U6600.F13 VRAM7000.B13
VMA_DQ12: U6600.C13 VRAM7000.E11
VMA_DQ13: U6600.B13 VRAM7000.E13
VMA_DQ14: U6600.E13 VRAM7000.F11
VMA_DQ15: U6600.D13 VRAM7000.F13
VMA_DQ16: U6600.B15 VRAM7000.U11
VMA_DQ17: U6600.C16 VRAM7000.U13
VMA_DQ18: U6600.A13 VRAM7000.T11
VMA_DQ19: U6600.A15 VRAM7000.T13
VMA_DQ20: U6600.B18 VRAM7000.N11
VMA_DQ21: U6600.A18 VRAM7000.N13
VMA_DQ22: U6600.A19 VRAM7000.M11
VMA_DQ23: U6600.C19 VRAM7000.M13
VMA_DQ24: U6600.B24 VRAM7000.U4
VMA_DQ25: U6600.C23 VRAM7000.U2
VMA_DQ26: U6600.A25 VRAM7000.T4
VMA_DQ27: U6600.A24 VRAM7000.T2
VMA_DQ28: U6600.A21 VRAM7000.N4
VMA_DQ29: U6600.B21 VRAM7000.N2
VMA_DQ30: U6600.C20 VRAM7000.M4
VMA_DQ31: U6600.C21 VRAM7000.M2
VMA_DQ32: U6600.R22 VRAM7001.A4
VMA_DQ33: U6600.R24 VRAM7001.A2
VMA_DQ34: U6600.T22 VRAM7001.B4
VMA_DQ35: U6600.R23 VRAM7001.B2
VMA_DQ36: U6600.N25 VRAM7001.E4
VMA_DQ37: U6600.N26 VRAM7001.E2
VMA_DQ38: U6600.N23 VRAM7001.F4
VMA_DQ39: U6600.N24 VRAM7001.F2
VMA_DQ40: U6600.V23 VRAM7001.A11
VMA_DQ41: U6600.V22 VRAM7001.A13
VMA_DQ42: U6600.T23 VRAM7001.B11
VMA_DQ43: U6600.U22 VRAM7001.B13
VMA_DQ44: U6600.Y24 VRAM7001.E11
VMA_DQ45: U6600.AA24 VRAM7001.E13
VMA_DQ46: U6600.Y22 VRAM7001.F11
VMA_DQ47: U6600.AA23 VRAM7001.F13
VMA_DQ48: U6600.AD27 VRAM7001.U11
VMA_DQ49: U6600.AB25 VRAM7001.U13
VMA_DQ50: U6600.AD26 VRAM7001.T11
VMA_DQ51: U6600.AC25 VRAM7001.T13
VMA_DQ52: U6600.AA27 VRAM7001.N11
VMA_DQ53: U6600.AA26 VRAM7001.N13
VMA_DQ54: U6600.W26 VRAM7001.M11
VMA_DQ55: U6600.Y25 VRAM7001.M13
VMA_DQ56: U6600.R26 VRAM7001.U4
VMA_DQ57: U6600.T25 VRAM7001.U2
VMA_DQ58: U6600.N27 VRAM7001.T4
VMA_DQ59: U6600.R27 VRAM7001.T2
VMA_DQ60: U6600.V26 VRAM7001.N4
VMA_DQ61: U6600.V27 VRAM7001.N2
VMA_DQ62: U6600.W27 VRAM7001.M4
VMA_DQ63: U6600.W25 VRAM7001.M2
VMA_WCK01: U6600.D18 VRAM7000.D4
VMA_WCK01#: U6600.C18 VRAM7000.D5
VMA_WCK23: U6600.D17 VRAM7000.P4
VMA_WCK23#: U6600.D16 VRAM7000.P5
VMA_WCK45: U6600.T24 VRAM7001.D4
VMA_WCK45#: U6600.U24 VRAM7001.D5
VMA_WCK67: U6600.V24 VRAM7001.P4
VMA_WCK67#: U6600.V25 VRAM7001.P5
VR_SVID_ALERT#: PR8801.2 PR8833.1 R703.1 R705.2
VR_SVID_CLK: PR8802.2 PR8835.1 R706.2
VR_SVID_DATA: PR8800.2 PR8831.1 R704.1 R707.2
VRALERT#: D1600.1(CATHODE) R1613.1 R1614.1 U400.DB39
VRAVDDQ_FB: PR8713.2 PR8714.1 PR8715.1 PU8700.6
VRAVR_ON: PR8827.1 R3309.2
VREF_VMA1_MOS: Q7000.3 R7001.2
VREF_VMA2_MOS: Q7001.3 R7012.2
VREFC_VMA1: C7058.1 R7000.2 R7001.1 R7002.2 R7017.2 VRAM7000.J14
VREFC_VMA2: C7061.1 R7011.2 R7012.1 R7016.2 R7018.2 VRAM7001.J14
VRPVDDQ_PG: PR8105.2 PR8700.2
VSYS: R6103.1 U6100.8
WIFI_PCIE_REST#: C4113.2 CON4100.52 R4137.2 R4151.1 U4102.4
WIRELESS_ON: CON4100.6 CON4100.16 R4121.2
WLAN_ALERT#: CON4100.62 TP4101.1
WLAN_DISABLE: R4155.1 R4814.2 U4700.E4
WLAN_I2CCLK: CON4100.60 TP4102.1
WLAN_I2DATA: CON4100.58 TP4100.1
WLAN_TRANSMIT_OFF#: R4134.2 R4136.2 U400.DW27
WLAN_WAKE#: CON4100.55 Q4112.1 R4139.1 R4140.1
WP#_3: R6839.2 TP6807.1 U6801.3
WR_CLK_DN: CON4100.21 U400.DW44
WR_CLK_DP: CON4100.23 U400.DV44
WR_LANE0_DN: CON4100.15 U400.DT43
WR_LANE0_DP: CON4100.17 U400.DR44
WR_LANE1_DN: CON4100.9 U400.DV43
WR_LANE1_DP: CON4100.11 U400.DU43
WT_CLK_DN: CON4100.71 U400.DN47
WT_CLK_DP: CON4100.73 U400.DN45
WT_LANE0_DN: CON4100.65 U400.DR49
WT_LANE0_DP: CON4100.67 U400.DN49
WT_LANE1_DN: CON4100.59 U400.DM47
WT_LANE1_DP: CON4100.61 U400.DK47
WW_LED#: R4205.1 TP4200.1
WW_LED#_C: CON4202.10 R4205.2
WWAN_ASPM_EXIT: R817.1 R4208.2 U400.DC53 U4200.6
WWAN_CONFIG_0: CON4202.21 R1573.2
WWAN_CONFIG_0_R: R1514.2 R1573.1 U400.DW38
WWAN_CONFIG_2: CON4202.75 R1512.2 U400.DV38
WWAN_CONFIG_3: D4200.2 Q4200.2 R1511.2 U400.DT38
WWAN_CONFIG_3_C: CON4202.1 D4200.1 R4203.2
WWAN_DET#: R4212.2 R4800.1 U4700.E6
WWAN_FWUPD#: Q4200.1(S) R1520.1 R4214.2 U400.DL52
WWAN_OFF#: CON4202.6 R4202.2 R4810.2 U4700.K2
WWAN_TRANSMIT_OFF#: D4201.1(CATHODE) R811.1 R4204.1 U400.DC49
WWAN_TRANSMIT_OFF#_R: CON4202.8(W_DISABLE#1_3.3V) D4201.2 R4201.2 R4204.2
WWAN_WAKE#: R1132.2 R4211.1 U400.DN5
WWAN_WAKE#_R: CON4202.54 R4211.2
XDP_BPM0: CON7703.22 R1032.2 U400.Y2
XDP_BPM1: CON7703.24 R1033.2 U400.AB4
XDP_PCH_SPI0_SI: R1236.2 R1238.2 R1239.1 TP1200.1
XDP_TCK: CON7703.57 R609.2 R617.1 TP604.1 U400.B6
XDP_TDI_CPU: CON7703.56 R613.2 TP603.1 U400.A12
XDP_TDO_CPU: CON7703.52 R612.2 R616.1 TP602.1 U400.D12
XDP_TMS_CPU: CON7703.58 R611.2 TP601.1 U400.B9
XDP_TRST#: CON7703.54 R615.2 TP600.1 U400.K4
XTAL_38P4M_IN: R1424.2 U400.DL1
XTAL_38P4M_IN_R: C1404.2 R1424.1 R1426.1 Y1401.1
XTAL_38P4M_OUT: R1429.2 U400.DM1
XTAL_38P4M_OUT_R: C1406.2 R1426.2 R1429.1 Y1401.3
XTAL_SSIN: R6805.1 U6600.A10
XTAL_TCP0_25MHZ_IN: R5964.1 U5900.L9
XTAL_TCP0_25MHZ_IN_R: C5916.2 R5964.2 Y5900.1
XTAL_TCP0_25MHZ_OUT: R5965.1 U5900.M9
XTAL_TCP0_25MHZ_OUT_R: C5917.2 R5965.2 Y5900.3
N16923117: C3300.2 R3300.2 R3301.1
N17285542: R5111.1 U5100.2
N17285546: R5112.1 U5100.9
N17285548: R5121.1 U5100.32
N17285713: R5122.1 U5100.6
N17777419: L4700.1 R4740.2
N18345378: R5408.1 U5401.1
N18490206: D3500.2 R3514.1
N18697895: C4722.2 R4747.2
N18861075: C5108.2 R5110.2
N20937188: Q5401.3 R5401.2 R5402.1
N20937236: Q5401.4 Q5401.6
N21479772: Q6800.1(EMITTER) Q6802.3 R6812.2
N23161371: Q5101.6 R5127.2 R5130.1
N23161400: C5112.2 Q5101.5 R5130.2
N25318825: PQ8004.3 PR8006.1
N25319146: PQ8002.2 PR8001.2 PR8006.2
N25319276: PC8002.2 PQ8000.4 PQ8002.3 PR8000.2 PR8009.1
N26788301: D3500.1 R3509.1
N27239944: PR8710.1 PU8700.3
N27265640: PC9517.1 PR9507.1 PU9501.5
N27265648: PC9515.1 PU9501.12
N27265649: PC9516.1 PU9501.10
N27265691: PC9521.1 PR9505.1 PU9500.5
N27265699: PC9519.1 PU9500.12
N27265700: PC9520.1 PU9500.10
N27265702: PC9518.1 PR9504.2 PU9500.3
N27303349: PC9543.1 PR9514.2 PU9502.5
N27303375: PC9536.1 PR9513.1 PU9502.3
N27367629: PC10513.1 PD10500.2 PR10516.1 PU10501.5
N27367663: PC10508.1 PC10509.1 PR10514.1 PU10501.14
N27367762: PC10515.1 PU10501.10
N27367840: PC10506.1 PC10507.1 PR10512.1 PU10501.1 PU10501.6
N27367864: PC10510.1 PC10511.1 PR10515.2 PU10501.9
N27367912: PC10514.1 PU10501.12
N27367918: PC10516.1 PR10517.2 PU10501.3
N27368301: PQ10500.5 PQ10500.6 PR10507.2 PR10509.1
N27368325: PQ10500.3 PR10504.2
N27673930: PQ8702.3 PR8713.1
N30709649: R7005.2 VRAM7001.J13(ZQ)
N30709654: R7003.2 VRAM7000.J13(ZQ)
N30882249: C7060.1 R7014.2 R7015.2
N30885322: C7059.1 R7008.2 R7010.2
N31840009: CON5000.5 R5002.2
N31840087: CON5000.8 R5007.2
N31840108: CON5000.9 R5009.2
N31840152: CON5000.11 R5004.2
N31840183: CON5000.12 R5011.2
N32484985: PQ8008.2 PR8014.2 PR8015.1
N32484987: PR8015.2 PR8019.2 PR8020.1
N32485009: PQ8008.3 PQ8011.2 PR8021.1
N32890326: CON4300.12 R4301.1
N34650123: Q4111.2 R4136.1
N34650132: Q4108.2 Q4111.3 R4133.2 R4135.1
N36049795: CON4100.38 R4128.2
N36049798: CON4100.40 R4129.2
N36049801: CON4100.42 R4130.2
N36756780: PQ8703.3 PR8718.2
N37096665: PQ8012.3 PR8016.1
N37096667: PQ8006.4 PQ8012.6 PR8023.2
N37096688: PQ8012.2 PQ8012.5 PR8025.1
N37096692: PD8001.2 PQ8009.2 PQ8010.2 PR8018.2
N37096694: PQ8013.3 PR8017.1
N37096728: PQ8013.2 PQ8013.5 PR8026.1
N37096732: PQ8007.4 PQ8013.6 PR8024.2
N37096738: PQ8010.1(S) PQ8013.4(E2)
N37096862: PQ8009.1(S) PQ8012.4(E2)
N37277040: C4707.2 U4700.A6
N37543651: R3515.1 U3501.16
N37586765: C3525.1 U3501.17
N38095593: CON4300.75 R4311.2
N38480242: CON4100.64 TP4104.1
N38512591: C2828.2 R2821.2
N38515705: C2928.2 C2929.2 R2920.1
N38936226: PQ8200.4 PQ8202.6 PR8207.1
N38936233: PD8201.2 PQ8201.2 PR8204.1
N38936236: PC8203.2 PC8204.1 PR8201.1 PR8205.1
N38936237: PC8204.2 PC8205.1 PR8202.1 PR8206.1
N38936238: PQ8201.1(S) PQ8202.4(E2)
N38936239: PQ8202.3 PR8203.2
N38936251: PQ8202.2 PQ8202.5 PR8208.1
N38936280: PD8202.1(CATHODE) PD8204.1(CATHODE) PR8211.1
N38936318: PC8212.1 PR8212.1
N38936322: PD8205.3(COMMON ANODE) PR8213.1
N38936486: PR8238.1 PU8201.3
N38936522: PR8243.2 PR8244.1
N39054084: PD8205.2 PR8214.1
N39054087: PD8205.1 PR8216.1
N39054316: PD8207.2 PR8219.2 PR8220.2
N39166693: PC9537.1 PU9502.12
N39166694: PC9538.1 PU9502.10
N39250128: R3616.1 U3600.2
N39252871: C3603.1 U3600.22(VREF)
N39252874: C3604.2 R3603.2 U3600.21
N39253153: C3600.2 U3600.27
N39253381: C3601.2 U3600.28
N39253577: C3601.1 U3600.30
N39254866: R3608.2 R3609.1 R3610.2 U3600.12
N39255557: C3622.2 U3600.6
N39257337: C3605.1 U3600.32
N39257899: C3611.2 C3612.1 C3614.2 C3615.1 L3601.1 U3600.34 U3600.39
N39300434: Q3600.1(EMITTER) R3620.1
N39300462: Q3600.2 R3622.1
N39344253: R3605.2 U3600.16
N39344256: C3613.2 U3600.15
N39344262: TP3602.1 U3600.24
N39518726: PC9120.1 PR9110.2
N41131693: Q500.2 Q501.3 R506.2
N41131697: Q501.2 R512.2 R513.2
N43333369: Q3404.2 R3409.1 R3411.1
N45522143: R5128.2 U5100.4
N45522294: R5123.1 U5100.7
N45522388: R5129.2 U5100.16
N45761120: C4712.1 R4730.2 R4731.1
N46297116: PD8700.1(CATHODE) PR8722.2
N46753812: PC9109.1 PR9107.2
N46753832: PC9119.1 PR9112.2
N46795838: PC9209.2 PU9200.8
N46796009: PC9215.2 PR9207.1
N46796205: PC9218.1 PR9208.1 PR9212.2
N46797162: PC8400.2 PQ8400.1(EMITTER) PR8404.1 PR8405.2 PR8406.1
N46797220: PR8402.2 PR8406.2 PR8407.2
N46797224: PQ8401.2 PR8402.1
N46797226: PC8402.2 PR8400.2 PR8401.2
N46797272: PQ8401.1(EMITTER) PQ8402.3 PR8407.1
N46797433: PQ8403.3 PR8410.2 PR8411.2
N46797587: PC8408.2 PQ8404.2 PR8413.1 PR8415.2
N46797700: PQ8404.3 PQ8405.2 PR8416.2
N46872073: PC8909.1 PR8901.1
N46874040: PC8927.1 PR8908.1
N46891481: PR8810.2 PR8817.2
N46891574: PC8806.2 PR8818.2
N46891676: PC8807.2 PR8823.1
N46891831: PC8812.2 PR8828.2
N46891887: PC8813.1 PR8830.1
N46891889: PC8813.2 PC8814.2 PC8815.2 PR8832.2 PR8834.1 PR8843.2
N46892152: PR8839.2 PR8841.1 PR8842.1
N47579539: R7614.1 U7600.32(WAKE#)
N47579836: R7607.2 U7600.9
N47664126: CON4402.12 F4401.1
N47664563: CON4400.1 CON4400.2 F4400.2
N47925309: CON7703.41 R7702.1
N47925473: CON7703.39 R7705.2
N47925767: CON7702.4 R7711.2
N48061147: PQ9100.5 PQ9100.6 PR9119.2 PR9122.1
N48061149: PQ9100.3 PR9120.2
N48061323: PQ9100.2 PR9121.2
N48112598: PC8617.1 PU8602.9
N48112603: PC8617.2 PR8609.2 PU8602.10
N48117434: PR9204.2 PU9200.9
N48125412: PC8005.1 PR8027.2
N48131045: PQ8010.3 PR8029.2
N48131048: PQ8009.3 PR8028.2
N48234350: R7507.1 U7500.8
N48973706: C3422.2 R3422.2 U3404.3
N49036359: CON4202.69 R4212.1
N49042977: CON4202.25 R4207.2
N49052226: TP1802.1 U1802.A3
N49052232: TP1803.1 U1803.A3
N49053509: TP1801.1 U1800.A3
N49054377: TP1804.1 U1805.A3
N49055211: TP1800.1 U1801.A3
N49093093: TP1902.1 U1900.A3
N49093758: TP1901.1 U1902.A3
N49096987: TP1903.1 U1903.A3
N49098515: TP1904.1 U1904.A3
N49099212: TP1905.1 U1905.A3
N49100645: TP1907.1 U1907.A3
N49101512: TP1908.1 U1908.A3
N49102198: TP1909.1 U1909.A3
N49103385: TP1906.1 U1906.A3
N49104740: TP2008.1 U2008.A3
N49179710: CON5000.1 R5000.2
N49254400: C5000.1 Q5000.5 Q5000.6 R5005.2 R5010.1
N49470898: R4405.1 R4406.1 U4400.6
N49472283: C4403.2 C4404.1 R4411.2 R4412.1
N49472680: Q4400.5 Q4400.6 R4407.2 R4410.1
N50419052: PC10625.1 PC10626.1 PR10611.1 PU10601.1
N50419064: PC10627.1 PC10628.1 PR10615.1 PU10601.6
N50419270: PC10635.1 PR10613.2 PR10614.2 PU10601.3
N50419274: PC10634.1 PR10612.1 PR10623.1 PU10601.5
N50419307: PC10636.2 PU10601.12
N50419309: PC10637.1 PU10601.10
N50522912: PR9822.1 PR9823.1 PU9800.13
N50522939: PR9802.1 TP9801.1
N50522940: PC9804.1 PR9820.2 PR9821.2 PU9800.8
N50522975: PQ9800.5 PQ9800.6 PR9826.1 PR9827.2
N50522977: PQ9800.3 PR9825.2
N50522997: PR9801.1 TP9800.1
N50635931: C4105.1 C4114.1 R4112.1 U4100.2
N50636280: R4102.1 R4112.2 R4155.2
N50901509: Q1501.1(S) R1560.2
N50901512: Q1501.3 Q1502.1(S)
N51022503: Q5001.2 R5016.2 R5017.2
N51022542: Q5004.2 R5018.2 R5019.2
N51034199: PC8106.2 PR8119.2 PR8120.2 PU8101.4
N51034211: PC8107.2 PR8121.2 PR8122.2 PU8101.3
N51034475: PR8123.1 PU8101.6
N51038375: PR8623.2 PU8602.12
N51044000: PC8003.1 PC8006.1 PD8002.2 PQ8001.4 PR8002.1 PR8008.1
N51044064: PQ8003.3 PR8008.2
N51258459: TP1805.1 U1804.A3
N51259075: TP1806.1 U1806.A3
N51259634: TP1809.1 U1807.A3
N51260827: TP1808.1 U1809.A3
N51263568: TP2010.1 U2010.A3
N51264929: TP2007.1 U2007.A3
N51454542: PC10211.2 PC10212.1 PC10213.1 PC10214.1 PC10215.1 PC10219.2 PC10220.1 PL10201.2 PR10202.1 PR10209.1 PR10215.1
N51471480: PC8100.1 PR8106.2 PR8108.2 PU8100.2 PU8100.6
N51471485: PC8102.2 PD8100.3(COMMON ANODE) PR8100.1 PR8101.1 PR8103.1 PR8105.1 PR8111.1 PR8113.1
N51471494: PR8111.2 PR8115.1 PU8100.3
N51471496: PC8101.2 PR8102.2 PR8104.2 PR8107.1 PR8112.2 PR8114.1
N51471497: PR8112.1 PR8116.1 PU8100.5
N51471552: PD8100.2 PR8109.1
N51471553: PD8100.1 PR8110.1
N51531858: Q4703.2 Q4703.3 R4825.2
N51533071: Q5201.3 Q5202.2 R5217.2
N51588253: CON7703.23 TP7701.1
N51999762: C800.2 Q800.2 R818.2
N51999829: Q800.3 Q801.2 R819.2
N52065607: PQ10603.5 PQ10603.6 PR10617.1
N52065643: PQ10603.2 PR10619.1 PR10621.2 PR10622.2
N52288680: Q4106.2 R4156.2
N52420915: C5413.1 U5403.2
N52420918: C5413.2 U5403.3
N52477829: CON3400.10 L3403.1
N52652005: TP6101.1 U6100.36
N52656375: C6105.1 U6100.9
N52664021: TP6102.1 U6100.35
N52907910: PQ8201.3 PR8245.1
N52915346: PC10210.1 PR10203.1
N52915353: PC10216.2 PR10206.1
N53077021: PQ10200.5 PQ10200.6 PR10212.2 PR10214.1
N53077023: PQ10200.3 PR10213.2
N53629073: R6109.1 R6129.2 U6100.37
N53814485: CON5000.3 R5028.2
N54003618: Q5005.2 Q5006.3 R5026.1
N54131141: R6708.2 U6600.F22
N54131145: R6709.2 U6600.J22
N54154109: C6619.2 C6623.2 C6635.2 C6800.2 C6802.2 C6803.2 L6600.2 U6600.F11 U6600.L6 U6600.M6 U6600.N6
N54169728: C6642.1 C6645.1 C6650.1 C6653.1 R7727.2 U6600.G8 U6600.G9
N54177392: C6719.2 R6713.2 U6600.D23
N54187750: C6902.1 R6965.1 U6600.F10
N54190117: Q6901.5 Q6901.6 R6947.1
N54237676: PQ9801.3 PR9831.1
N54237726: PQ9801.2 PQ9802.3 PR9829.2
N54361820: LED7600.2 R7615.1
N54361826: LED7600.1 R7616.1
N54441486: PC9805.2 PD9801.1(CATHODE) PQ9802.2 PR9833.2
N54490415: PQ10501.5 PQ10501.6 PR10518.2 PR10520.1
N54490417: PQ10501.3 PR10519.2
N55084151: CON4300.68(SUSCLK) TP4300.1
N55555920: R5419.2 U5403.4
N57313521: L3402.1 Q3406.1(S) R3435.1
N58653005: Q1000.2 R1004.1 R1007.2 R1008.2
N64506943: R1427.2 Y1400.2

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MSATA_DET#_R: length 45.6
  TOP w0.109: v1(18.12,54.97) 18.12,54.62 18.04,54.54 R4309.2 18.04,53.77 17.55,53.29 R4308.1 17.24,51.84 17.41,51.67 Q4300.2
  IN3 w0.089: v1(12.16,19.73) 12.16,20.05 11,21.21 11,34.19 12.46,35.65 12.46,37.77 13.28,38.59 13.28,41.01 14.39,42.13 14.39,43.68 16.71,46 17.85,46 18.12,46.28 v1(18.12,54.97)
  BOTTOM w0.109: v1(12.16,19.73) 12.65,19.25 CON4300.69
MSR_ENABLE_N: length 175.3
  TOP w0.109: R5637.2 164.13,71.42 163.9,71.19 v1(163.65,71.19) ; CON7703.60 v1(38.99,53.98) 38.87,53.98 38.58,53.7 v1(38.58,53.37)
  BOTTOM w0.109: v1(38.58,53.37) 38.58,54.36 39.66,55.43 43.72,55.43 47.86,51.3 47.86,40.7 51.32,37.24 99.98,37.24 103.02,40.28 117.43,40.28 118.39,41.23 152.17,41.23 156.37,45.44 156.79,45.44 157.22,45.87 157.22,48.31 158.14,49.22 159.18,49.22 159.61,49.65 160.8,49.65 161.97,50.82 161.97,52.45 163.32,53.8 163.89,53.8 165.12,55.03 165.12,56.06 164.77,56.41 163.86,56.41 163.62,56.65 163.62,59.54 165.77,61.69 165.77,66.47 165.07,67.17 164.52,67.17 163.74,67.94 163.74,71.1 v1(163.65,71.19)
N12E_SCL: length 11.9
  TOP w0.109: R6928.1 75.61,95.09 75.61,94.84 76.38,94.08 76.38,93.47 76.55,93.29 v1(76.55,93.04) 76.55,92.72 v1(76.06,92.22)
  BOTTOM w0.109: U6600.C9 71.96,86.64 72.42,87.1 72.42,87.43 72.66,87.67 72.66,88.69 72.98,89.02 73.89,89.02 75.59,90.73 75.59,91.75 v1(76.06,92.22)
N12E_SDA: length 10.5
  TOP w0.109: R6929.1 75.56,94.41 75.72,94.41 76.03,94.1 76.03,92.97 75.46,92.41 75.46,91.97 v1(75.48,91.96) 75.53,91.96 v1(76.01,91.48)
  BOTTOM w0.109: U6600.C8 73.24,86.84 73.24,88.11 73.94,88.81 73.97,88.81 75.92,90.75 75.92,91.38 v1(76.01,91.48)
NB680A_VOUT: length 4.8
  TOP w0.254: v1(145.72,17.54) 145.74,17.52 PR8607.1
  BOTTOM w0.203: PU8602.5 142.7,18.02 143.05,18.37 145.17,18.37 145.72,17.83 v1(145.72,17.54)
NB680ABST:
  vias: v1(144.4,13.92)
NB680ABSW:
  vias: v1(144.78,15.42) v3(144.69,16.1)
NB680AEN: length 4.8
  BOTTOM w0.109: PR8606.2 139.72,12.32 140.03,12.63 PC8616.1 PR8608.2 141.15,12.63 141.47,12.63 141.55,12.71 141.55,13.05 141.72,13.22 142.29,13.46 142.37,13.54 142.44,13.71 142.44,14.02 142.2,14.26 PU8602.11
NB680APG: length 0.8
  BOTTOM w0.109: PR8600.2 141.32,17.54 141.37,17.58 PU8602.3
NB691_BST:
  vias: v1(125.52,11.99)
NB691_EN: length 6.2
  BOTTOM w0.109: PR10625.2 119.79,13.27 119.87,13.27 119.99,13.38 119.99,14.12 v1(120.11,14.25)
  BOTTOM w0.203: PR9209.2 120.78,12.51 120.6,12.7 120.29,12.7 119.88,13.11 PR10625.2
  BOTTOM w0.254: PR9209.2 120.79,12.3 PC9217.1 121.34,12.59 120.94,12.99 PR9210.1 120.94,13.65 121.39,14.1 PU9200.11
NB691_LX:
  vias: v1(125.83,14.48) v3(127.23,13.59)
NB691_PG: length 2.9
  TOP w0.109: PR9214.1 124.11,16.76 v1(123.8,17.08)
  BOTTOM w0.109: v1(123.8,17.08) 123.69,17.08 123.16,17.6 PR9206.1 122.91,17.1 122.89,17.08 PU9200.5
NFC_3S_SMCLK: length 277.8
  TOP w0.109: v2(44.11,5.95) 44.11,5.93 43.44,5.26 42.48,5.26 41.84,5.89 41.84,6.39 42.19,6.74 42.19,7.49 C4406.1 41.45,7.91 R5208.2
  IN1 w0.079: v1(162.93,39.69) 163.27,39.35 163.84,39.35 164.39,38.81 165.59,38.81 167.14,40.35 169.35,40.35 169.66,40.04 170.7,40.04 175.78,34.95 177.54,34.95 180.98,31.52 182.06,31.52 182.58,31 182.58,30.11 184.99,27.7 184.99,27.32 185.46,26.2 186.9,24.75 186.9,23.74 187.12,23.52 187.68,23.52 187.91,23.29 187.91,21.58 187.83,21.4 187.83,21.18 188.62,20.39 188.62,17.6 189.21,17.01 189.21,16.82 189.65,16.37 189.65,13.79 187.84,11.98 186.74,11.98 185.61,10.85 185.61,10.53 184.68,9.6 180.65,9.6 180.31,9.27 180.31,8.84 179.52,8.05 176.92,8.05 176.59,7.72 171.17,7.72 169.15,9.74 160.71,9.74 160.45,9.48 148.96,9.48 v1(148.79,9.66) 148.63,9.66 148.26,10.03 147.95,10.03 147.94,10.02 145.98,10.02 145.25,9.28 141.25,9.28 140.96,8.99 136.29,8.99 135.41,9.87 134.89,9.87 134.77,9.75 133.78,9.75 133.3,10.23 131.87,10.23 131.13,9.49 126.03,9.49 125.86,9.32 114.93,9.32 114.22,8.61 113.86,8.61 113.1,7.85 105.05,7.85 104.23,8.67 99.86,8.67 98.44,10.09 94.48,10.09 93.97,10.61 92.38,10.61 91.91,11.08 89,11.08 88.83,11.25 86.2,11.25 84.84,9.89 80.99,9.89 80.95,9.93 59.45,9.93 58.99,9.47 58.71,9.47 58.05,8.81 56.13,8.81 53.92,6.6 52.08,6.6 51.43,7.25 50.62,7.25 49.52,6.16 44.31,6.16 44.11,5.96 v2(44.11,5.95)
  IN2 w0.089: v2(146.42,77.55) 146.42,77.79 146.64,78.01 147.76,78.01 150.11,75.66 150.11,74.78 149.74,74.4 149.74,72.59 148.28,71.14 148.28,68.73 148.77,68.24 148.77,67.72 148.44,67.39 148.44,66.65 148.58,66.51 148.58,65.6 148.79,65.09 148.79,63.52 147.79,62.52 147.79,61.81 v1(147.42,61.44)
  IN3 w0.089: v1(162.93,39.69) 162.88,39.74 161.38,39.74 160.85,40.27 160.17,40.27 158.71,41.73 158.71,43.35 157.94,44.12 157.36,44.12 156.92,43.69 156.21,43.69 155.02,44.88 155.02,45.77 152.9,47.89 148.14,47.89 140.33,55.69 140.33,58.32 140.76,58.74 141.51,58.74 143.41,60.64 143.88,61.11 147.09,61.11 v1(147.42,61.44)
  BOTTOM w0.109: v1(148.79,9.66) 148.79,9.6 148.49,9.31 CON4402.8 ; U400.DV18 144.68,78.2 145.48,78.2 145.78,77.91 146.06,77.91 146.42,77.55 v2(146.42,77.55) 146.43,77.54 146.43,77.54 146.73,77.24 147.06,77.24 147.27,77.44 147.28,77.48 147.67,77.86 149.34,77.86 R806.1
NFC_3S_SMDATA: length 279.1
  TOP w0.109: v2(43.56,5.95) 43.56,5.91 43.23,5.58 42.46,5.58 42.1,5.94 42.1,6.34 42.41,6.65 42.41,7.6 42.24,7.77 42.24,8.11 41.82,8.53 41.1,8.53 C4405.1 40.08,7.51 40.08,7.16 39.83,6.91 R5211.2
  IN1 w0.079: v2(43.56,5.95) 43.93,5.59 44.42,5.59 44.83,6 49.59,6 50.68,7.09 51.36,7.09 52.02,6.44 53.99,6.44 56.2,8.65 58.11,8.65 58.77,9.31 59.06,9.31 59.52,9.78 80.88,9.78 80.92,9.74 84.91,9.74 86.25,11.08 88.78,11.08 88.94,10.92 91.85,10.92 92.32,10.45 93.9,10.45 94.42,9.93 98.38,9.93 99.79,8.52 102.31,8.52 102.92,7.91 104.77,7.91 104.98,7.69 113.17,7.69 113.93,8.45 114.29,8.45 115,9.16 125.92,9.16 126.08,9.33 131.42,9.33 132.1,10.01 133.27,10.01 133.7,9.57 134.82,9.57 134.96,9.72 135.34,9.72 136.22,8.83 141.1,8.83 141.4,8.53 142.94,8.53 143.29,8.88 145.49,8.88 145.66,9.06 147.51,9.06 v1(148.11,9.66) 148.88,8.88 151.25,8.88 151.56,8.57 153.58,8.57 154.33,9.32 155.73,9.32 155.95,9.09 155.95,8.91 156.26,8.61 157.99,8.61 158.7,9.32 160.51,9.32 160.77,9.58 169.08,9.58 171.12,7.54 176.64,7.54 176.98,7.89 179.62,7.89 180.52,8.79 180.52,9.22 180.74,9.44 184.74,9.44 185.77,10.47 185.77,10.77 186.82,11.82 187.9,11.82 189.81,13.73 189.81,16.44 189.38,16.86 189.38,17.14 188.8,17.73 188.8,20.44 188.01,21.22 188.01,21.43 188.06,21.55 188.06,21.74 188.16,21.84 188.16,24.01 187.93,24.24 187.64,24.24 185.59,26.3 185.15,27.35 185.15,27.76 182.74,30.18 182.74,31.06 182.12,31.68 181.04,31.68 177.59,35.13 175.83,35.13 170.74,40.22 169.71,40.22 169.41,40.51 167.07,40.51 165.53,38.97 164.51,38.97 163.76,39.72 v1(163.6,39.72)
  IN2 w0.089: v2(146.96,77.65) 147.73,77.65 149.25,76.13 149.25,74.69 149.53,74.4 149.53,72.64 148.11,71.21 148.11,68.66 148.59,68.17 148.59,67.79 148.26,67.46 148.26,66.58 148.41,66.44 148.41,65.57 148.62,65.06 148.62,63.59 147.41,62.38 v1(147.41,62.08)
  IN3 w0.089: v1(147.41,62.08) 146.62,61.29 143.77,61.29 143.27,60.79 141.43,58.95 140.71,58.95 140.16,58.39 140.16,55.58 148.05,47.68 151.67,47.68 153.43,45.92 154.02,45.92 154.84,45.1 154.84,44.8 156.14,43.51 156.99,43.51 157.43,43.95 157.87,43.95 158.49,43.33 158.49,41.71 159.99,40.2 159.99,39.65 160.5,39.14 163.01,39.14 v1(163.6,39.72)
  BOTTOM w0.109: U400.DW18 145.05,78.58 145.18,78.46 145.5,78.46 145.86,78.11 146.5,78.11 146.96,77.65 v2(146.96,77.65) 146.96,77.66 147.4,78.09 148.5,78.09 R805.1 ; v1(148.11,9.66) 148.11,9.62 147.99,9.5 CON4402.9
NFC_DETECT#: length 187.1
  TOP w0.109: v2(162.59,12.22) 163.65,12.22 v1(163.88,11.99) 164.15,11.99 164.57,11.57 165.24,11.57 165.72,11.09 165.72,10.98 166.35,10.35 166.35,10.15 167.16,9.34 170.46,9.34 170.61,9.19 173.07,9.19 174.32,7.95 175.74,7.95 176.02,7.67 177.65,7.67 178.76,6.55 179.97,6.55 v1(180.06,6.47) 181.19,5.33 183.74,5.33 184.68,4.39 184.68,3.45 184.4,2.78 184.4,1.79 184.83,1.36 204.64,1.36 R4406.2
  IN2 w0.089: v2(146.82,83.32) 146.93,83.43 149.18,83.43 150.23,82.38 150.23,81.95 150.56,81.62 151.73,81.62 151.94,81.84 151.94,82.35 152.22,82.62 155.77,82.62 156.67,81.72 156.67,80.74 158.27,79.14 158.27,76.68 157.77,76.18 157.77,74.86 158.49,74.13 158.49,72.81 157.79,72.11 157.79,71.49 155.93,69.63 155.93,67.95 156.31,67.57 156.31,66.8 156.38,66.61 157.06,65.94 157.06,64.49 158.06,63.5 158.06,62.43 158.93,61.55 158.93,58.12 158.7,57.89 158.7,56.82 159.32,56.2 159.32,55.64 158.8,55.12 158.8,54.42 159.72,53.5 160.54,53.5 161.74,52.3 161.74,48.48 162.69,47.52 162.69,46.72 163.57,45.84 163.57,44.39 163.94,44.02 167.69,44.02 169.93,41.79 170.96,41.79 171.54,41.2 172.63,41.2 173.75,40.07 173.75,38.35 174.06,38.05 174.13,38.05 180.4,31.78 180.4,30.48 182.46,28.43 182.46,26.31 182.14,25.98 182.14,24.25 184.12,22.27 184.12,20.48 185.81,18.79 185.81,18.3 186.08,18.03 186.6,18.03 187.12,18.54 187.12,18.74 187.48,19.1 187.89,19.1 188.63,18.36 189,18.36 189.63,17.73 190.09,17.73 190.2,17.62 190.2,13.35 191.29,12.27 191.29,11.74 190.89,11.34 190.89,10.18 190.42,9.71 184.38,9.71 183.94,9.27 182.75,9.27 182.23,8.76 181.58,8.76 181.23,8.42 181.23,7.11 180.58,6.47 v1(180.06,6.47)
  BOTTOM w0.109: v2(146.82,83.32) 146.81,83.32 146.48,83 145.85,83 145.54,82.69 145.12,82.69 U400.DW9 ; CON4402.1 151.99,9.11 152.28,9.4 152.51,9.4 R1120.1 153.26,9.76 153.52,9.5 155.42,9.5 156.36,10.44 156.36,11.81 156.84,12.29 162.51,12.29 v2(162.59,12.22)
NFC_DWL_REQ: length 79.2
  TOP w0.109: v1(149.84,7.52) 149.84,6.67 150.86,5.65 162.01,5.65 v1(162.41,6.04) 162.68,6.04 164.21,7.58 168.11,7.58 169.49,6.96 171,5.45 171.71,3.39 172.72,2.38 176.54,2.38 178.05,3.89 178.05,4.57 178.81,5.33 179.17,5.33 179.98,4.52 179.98,3.91 180.67,3.22 180.67,2.92 181.27,2.32 v1(181.61,2.32) ; R4409.1 207.77,10.71 207.77,9.93 207.87,9.83 R4408.2 208.76,9.83 209.05,9.54 U4400.4 209.05,8.22 209.34,7.92 209.34,2.42 v1(209.21,2.29)
  IN2 w0.089: v1(209.21,2.29) 208.97,2.29 208.1,1.42 182.5,1.42 v1(181.61,2.32)
  BOTTOM w0.109: CON4402.5 149.99,7.67 v1(149.84,7.52)
NFC_DWL_REQ_PCH: length 138.2
  TOP w0.109: R4408.1 208.76,10.28 209.05,10.57 U4400.3 209.05,11.21 208.63,11.63 208.63,12.27 208.79,12.42 209.29,12.42 209.65,12.06 210.11,12.06 210.87,11.3 R4404.2 211.07,13.92 v1(212.28,15.13)
  IN1 w0.079: v1(143.22,55.35) 143.36,55.22 143.36,54.02 146.91,50.47 147.31,50.47 148.04,49.73 149.16,49.73 149.81,49.07 149.81,48.59 150.64,47.77 151.54,47.77 153.04,46.26 153.63,46.26 153.88,46.01 155.81,46.01 156.13,46.33 156.62,46.33 156.82,46.53 157.18,46.53 157.58,46.13 158.25,46.13 159.94,47.83 160.42,47.83 163.03,50.43 163.03,51.37 165.09,53.44 172.22,53.44 172.55,53.77 174.33,53.77 174.62,54.07 177.28,54.07 177.85,54.64 184.45,54.64 186.2,52.89 186.2,51.53 186.93,50.8 186.93,48.5 188.16,47.26 191.74,47.26 192.28,47.8 193.58,47.8 193.9,47.47 193.9,45.46 191.86,43.42 191.86,41.2 192.19,40.88 192.19,38.95 192.36,38.78 192.36,32.86 193.33,31.89 193.74,31.89 194.52,31.11 197,31.11 197.08,31.03 197.88,31.03 198.19,30.72 198.33,30.66 200.72,30.66 202.69,28.69 203.51,28.69 204.48,27.72 204.76,27.72 206.53,25.96 207.92,25.96 208.1,26.13 210.83,26.13 212.89,24.07 213.03,24.07 214.67,22.44 214.67,16.9 212.89,15.13 v1(212.28,15.13)
  BOTTOM w0.109: v1(143.22,55.35) 142.33,55.35 141.55,56.13 140.64,56.13 v1(139.29,57.48) 138.95,57.82 138.95,58.4 139.01,58.47 139.01,60.82 138.45,61.38 138.45,62.2 137.53,63.12 U400.DC52
NFC_IRQ: length 123.4
  TOP w0.109: v1(146.43,52.91) 146.15,52.63 145.87,52.63 145.62,52.38 R4413.2 145.51,52.14 Q4401.2 ; v1(162.17,18.03) 163.33,16.87 163.33,14.06 162.05,12.78 161.95,12.55 161.95,11.83 v1(162.35,11.43) 162.35,11.25 162.18,11.07 162.18,9.51 161.81,9.14 v1(161.81,8.64)
  IN1 w0.079: v2(147.07,7.74) 147.07,8.05 147.27,8.25 150.99,8.25 151.3,7.94 158.39,7.94 158.52,8.07 161.08,8.07 161.5,8.49 161.66,8.49 v1(161.81,8.64)
  IN3 w0.089: v1(162.17,18.03) 163.93,19.78 175.49,19.78 176.37,20.67 177.35,20.67 177.96,21.28 177.96,24.62 177.85,24.74 177.85,27.09 177.4,27.54 177.4,28.84 174.48,31.76 174.48,33.1 172.45,35.13 172.45,35.74 171.51,36.69 171.51,38.74 170.73,39.51 169.9,39.51 167.9,41.52 167.9,43.56 166.24,45.22 166.24,45.77 165.96,46.05 163.57,46.05 162.84,46.78 162.84,47.24 161.19,48.89 161.19,49.03 160.61,49.61 159.91,49.61 159.71,49.41 159.71,48.99 158.93,48.21 158.42,48.21 158.21,48.42 158.21,50.06 156.34,51.93 156.34,52.25 v1(157.11,53.01)
  BOTTOM w0.079: 136.75,60.22 136.75,60.22 136.75,61.94 136.31,62.38 U400.CY53
  BOTTOM w0.109: v2(147.07,7.74) 146.99,7.82 CON4402.11 ; v1(157.11,53.01) 156.77,52.68 152.91,52.68 152.7,52.88 147.52,52.88 147.11,53.29 146.82,53.29 v1(146.43,52.91) 146.05,52.53 139.53,52.53 135.99,56.07 135.99,59.41 136.29,59.71 R802.1 136.42,59.89 136.75,60.22
NFC_RST#: length 160.7
  TOP w0.109: v1(149.17,7.51) 149.17,6.71 150.46,5.42 162.38,5.42 164.31,7.35 168.06,7.35 169.35,6.77 170.8,5.32 171.51,3.27 172.63,2.15 176.68,2.15 178.28,3.76 178.28,4.2 v1(178.99,4.91)
  IN1 w0.079: v1(149.17,7.51) 149.08,7.51 148.75,7.19 146.9,7.19 146.56,7.53 146.56,7.91 146.35,8.11 145.83,8.11 145.81,8.09 143.62,8.09 143.16,7.63 142.05,7.63 v1(141.94,7.52)
  IN2 w0.089: v1(178.99,4.91) 179.48,4.91 181.41,6.84 181.41,8.34 181.65,8.58 182.31,8.58 182.81,9.09 184.02,9.09 184.47,9.54 190.49,9.54 191.06,10.11 191.06,11.27 191.46,11.67 191.46,12.34 190.38,13.43 190.38,18.15 190,18.54 188.7,18.54 187.96,19.28 187.41,19.28 186.94,18.81 186.94,18.61 186.53,18.2 186.16,18.2 185.98,18.38 185.98,18.87 184.3,20.55 184.3,22.34 182.31,24.33 182.31,25.91 182.64,26.24 182.64,28.49 180.58,30.56 180.58,31.85 174.21,38.22 174.13,38.22 173.93,38.43 173.93,40.15 172.7,41.38 171.62,41.38 171.03,41.96 170,41.96 167.76,44.2 164.02,44.2 163.75,44.47 163.75,45.92 162.87,46.8 162.87,47.6 161.92,48.55 161.92,52.38 160.48,53.82 v1(160.48,53.92)
  BOTTOM w0.079: 137.21,61.44 137.21,61.94 136.73,62.42 136.73,62.86 U400.CY52
  BOTTOM w0.109: CON4402.6 149.49,7.83 v1(149.17,7.51) ; 137.21,61.44 138.28,60.37 138.28,59.38 138.15,59.26 R801.1 137.84,59 137.71,58.86 137.71,57.41 137.72,57.4 137.72,55.23 139.47,53.48 144.67,53.48 145.11,53.92 147.34,53.92 147.79,53.48 152.95,53.48 153.15,53.27 156.06,53.27 156.71,53.92 158.82,53.92 159.27,54.36 160.03,54.36 v1(160.48,53.92) ; CON7704.2 140.12,8.04 140.64,7.52 v1(141.94,7.52)
NFC_TAG_INT#: length 85.6
  TOP w0.076: U4700.F10 v2(195.44,20.89)
  TOP w0.109: R4726.2 135.85,7.99 v1(135.6,7.99)
  IN3 w0.076: v2(195.44,20.89) 195.78,21.24 196.88,21.24 198.4,19.72 198.4,18.25 199.36,17.28 199.36,16.05 198.96,15.64 196.82,15.64 196.47,15.29 195.67,14.96 195.24,14.78 ; 193.36,15.09 193.37,15.09 193.69,14.78
  IN3 w0.089: v1(135.6,7.99) 136,7.99 136.55,8.53 140.03,8.53 140.22,8.34 142.81,8.34 143.24,8.77 143.86,8.77 144.01,8.92 145.05,8.92 145.18,9.04 146.83,9.04 147.03,8.84 147.96,8.84 148.04,8.92 151.44,8.92 151.79,8.57 154.14,8.57 154.74,9.17 155.73,9.17 155.98,8.92 155.98,8.73 156.21,8.5 158.84,8.5 159.28,8.94 160.25,8.94 160.56,9.25 160.98,9.43 161.68,9.57 162.51,9.57 162.7,9.38 165.19,9.38 165.66,8.9 170.01,8.9 171.17,7.74 171.7,7.74 172.44,8.48 178.21,8.48 181.4,11.67 181.4,12.31 181.8,12.7 182.45,12.7 183.79,14.04 185.98,14.04 186.56,14.62 188.49,14.62 188.98,14.14 189.49,14.14 190.1,14.74 190.1,15.25 190.41,15.56 190.72,15.69 191.69,15.69 192.28,15.09 193.36,15.09 ; 195.24,14.78 195.13,14.73 193.73,14.73 193.69,14.78
  BOTTOM w0.109: v1(135.6,7.99) 136.25,7.99 136.6,7.64 139.4,7.64 139.62,7.86 CON7704.3
NGFF_RESET#_R: length 20.1
  TOP w0.109: v1(197.41,7.59) 197.1,7.29 Q4200.3 ; R4214.1 187.84,7.38 187.26,6.8 186.69,6.8 186.49,7 R4213.2 186.13,7.16 186.08,7.11 C4204.1 185.73,7.35 186.21,7.83 v1(186.28,7.83)
  IN1 w0.079: v1(197.41,7.59) 197.41,6.47 196.26,5.33 195.93,5.33 194.51,6.75 193.83,6.75 193.7,6.62 189.49,6.62 189.03,7.07 187.05,7.07 v1(186.28,7.83)
  BOTTOM w0.109: CON4202.67 185.92,8.2 v1(186.28,7.83)
NMI_SMI_DBG#: length 135.1
  IN1 w0.079: v1(181.87,56.68) 181.57,56.68 181.14,57.11 173.38,57.11 172.98,56.71 172.48,56.71 171.06,55.29 163.73,55.29 161.88,53.44 160.29,53.44 159.01,52.16 159.01,51.98 v1(158.58,51.55)
  IN2 w0.089: v1(212.32,14.46) 211.89,14.89 211.89,16.56 211.15,17.31 211.15,22.01 210.07,23.09 209.47,23.09 209.04,23.52 209.04,24.1 208.03,25.12 206.1,25.12 204.61,26.6 203.99,26.6 203.19,27.4 202.36,27.4 201.22,28.53 199.01,28.53 197.95,29.59 197.83,29.64 197.59,29.87 193.87,29.87 193.26,30.48 192.95,30.48 191.04,32.39 191.04,33.96 188.9,36.1 188.9,37.76 187.16,39.5 187.16,43.35 185.64,44.87 185.64,46.71 185.43,46.92 185.43,47.53 185.6,47.7 185.6,49.67 185.6,49.67 185.6,49.99 182.88,52.72 182.88,53.43 182.06,54.25 182.06,56.49 v1(181.87,56.68)
  BOTTOM w0.079: 136.52,61.72 136.52,61.95 136.09,62.38 136.09,62.83 135.94,62.98 135.94,63.9 135.96,63.93 135.96,64.23 U400.CY49
  BOTTOM w0.109: v1(158.58,51.55) 158.08,51.55 157.64,51.99 156.79,51.99 156.6,51.79 153.74,51.79 152.22,50.27 151.51,50.27 150.86,49.63 150.23,49.63 149.59,50.27 140.94,50.27 135.15,56.06 135.15,59.59 135.27,59.71 R804.1 135.83,59.71 136.52,60.4 136.52,61.72 ; Q4800.1 204.59,12.04 206.09,12.04 206.21,11.92 207.48,11.92 207.98,12.42 209.29,12.42 209.57,12.14 210.2,12.14 210.28,12.22 CON7702.5 211.74,12.22 212.32,12.8 v1(212.32,14.46)
NPCE576H_AGND: length 7.3
  TOP w0.203: C4711.1 193.9,9.72 194.28,10.1 C4708.1 194.59,10.69 v1(194.51,10.77) 194.66,10.92 194.66,12.48 194.59,12.56
  TOP w0.254: U4700.E1 194.46,14.48 193.82,13.84 v2(193.82,13.32) 194.59,12.56
  BOTTOM w0.203: 195.88,12.88 196.42,13.41 C4710.1
NUM_LOCK_LED#: length 91.6
  TOP w0.076: v2(193.49,18.94) U4700.D7
  IN3 w0.076: 192.65,17.24 193.01,17.24 193.29,17.52 193.29,17.85 193.11,18.03 193.11,18.57 193.49,18.94 v2(193.49,18.94)
  IN3 w0.089: 192.65,17.24 192.43,17.24 192.1,17.57 190.83,17.57 190.02,16.77 189.73,16.77 189.39,17.11 187.14,17.11 187.02,16.99 183.6,16.99 182.12,15.51 181.6,15.51 180.31,14.22 180.31,12.09 178.39,10.16 172.78,10.16 172.19,9.58 171.87,9.58 171.48,9.97 167.09,9.97 166.29,10.77 165.38,10.77 165.2,10.59 164.47,10.59 163.97,11.09 160.04,11.09 158.6,10.5 149.67,10.5 149.23,10.94 148.9,11.08 148.76,11.22 146.56,11.22 146.46,11.13 144.1,11.13 143.95,11.28 143.41,11.28 141.55,10.51 139.32,10.51 138.99,10.18 138.52,10.18 v2(138.15,10.55)
  BOTTOM w0.076: 192.4,20.7 192.4,18.69 192.53,18.57 193.11,18.57 v2(193.49,18.94)
  BOTTOM w0.109: v2(138.15,10.55) 138.15,10.52 137.81,10.18 137.4,10.18 136.94,10.64 136.13,10.64 R5028.1 ; CON7702.15 210.37,17.22 209.9,17.7 208.91,17.7 208.86,17.74 206.64,17.74 202.66,21.71 v1(201.9,21.71) 201.7,21.51 200.79,21.51 R4805.1 199.38,21.28 192.73,21.28 192.4,20.95 192.4,20.7
NVVDD: length 37.6
  TOP w0.203: v1(59.08,99.03) 58.47,99.64 55.83,99.64 55.1,98.92 53.63,98.92 53.29,98.58 31.82,98.58 31.47,98.93 v1(31.47,99.13) 31.27,99.13 30.78,99.62 30.78,99.82 30.91,99.95 PR9815.2
  IN1 w0.254: v1(59.08,99.03) 59.36,99.03 61.87,101.55 64.67,101.55 65.16,101.05 v1(65.16,100.82)
  vias: v1(63.24,77.11) v1(63.57,72.79) v1(64.54,80.78) v1(65.3,72.74) v1(65.45,75.77) v1(65.53,79.8) v1(66.09,72.74) v1(67.17,77.8) v1(67.26,79.8) v1(67.37,73.65) v1(67.43,75.74) v1(67.49,72.74) v1(68.22,81.78) v1(68.23,80.76) v1(68.81,72.72) v1(69.19,73.76) v1(69.29,75.79) v1(69.34,79.8) v1(69.39,77.83) v1(70.38,74.66) v1(70.31,72.72) v1(71.28,79.74) v1(71.38,77.71) v1(71.4,75.77) v1(71.5,73.84) v1(71.63,72.74) v1(72.29,79.73) v1(72.26,72.72) v1(72.77,73.12) v1(72.92,79.7) v1(73.07,81.18) v1(73.07,80.39) v1(73.02,75.66) v1(73.18,77.84) v1(73.2,73.58) v1(73.73,74.65) v1(74.04,75.21) v1(74.12,77.72) v1(79.07,80.95) v3(62.1,100.83) v3(62.1,100.04) v3(62.86,100.83) v3(62.86,100.04) v3(63.62,100.83) v3(63.62,100.04) v3(64.39,100.83) v3(64.39,100.04) v3(65.91,100.83) v3(66.67,100.83) v3(67.43,100.83) v3(68.2,100.83) v3(68.96,100.83) v3(69.72,100.83) v3(70.48,100.83) v3(71.24,100.83) v3(72.01,100.83) v3(72.03,100.01) v3(72.77,100.83) v3(72.79,100.01) v3(73.53,100.83) v3(73.56,100.01) v3(74.29,100.83) v3(74.32,100.01) v3(75.05,100.83) v3(75.08,100.01) v3(75.82,100.83) v3(75.84,100.01) v3(76.58,100.83) v3(76.58,100.05) v3(77.34,100.83)
NVVDD_PG_LOOP_OVT: length 37.7
  IN2 w0.089: v1(87.22,80.28) 87.22,78.7 84.84,76.31 84.84,74.85 80.74,70.75 80.74,69.91 77.68,66.85 77.68,64.86 v1(78.03,64.51)
  BOTTOM w0.109: R6954.1 85.87,60.5 v1(86.51,61.14) 86.29,61.35 85.51,61.35 85.11,61.75 85.11,63.27 84.53,63.85 84.53,65.08 84.17,65.44 83.42,65.44 82.84,64.85 80.1,64.85 79.76,64.51 v1(78.03,64.51) ; Q6903.5 87.58,81.61 87.48,81.71 87.04,81.71 86.93,81.59 Q6903.6 86.74,81.1 86.74,79.92 87.06,79.61 Q6904.3 87.45,80.05 v1(87.22,80.28)
NVVDDPG: length 83.8
  TOP w0.178: PU9800.1 36.5,104.95 36.69,104.76 v1(37.2,104.76)
  TOP w0.203: PR9828.2 37.97,105.86 v1(37.44,105.33) 37.39,105.28 37.39,104.95 v1(37.2,104.76)
  IN2 w0.089: v1(37.67,99.77) 37.68,99.77 38.96,98.49 40.1,98.49 41.31,97.27 53.54,97.27 53.93,96.88 56.16,96.88 57.55,98.27 79.28,98.27 80.6,96.95 81.76,96.95 83.72,98.91 85.6,98.91 86.53,97.98 86.53,96.83 87.25,96.1 87.25,92.54 87.79,92.01 87.79,84.08 86.31,82.6 v1(86.31,81.91)
  BOTTOM w0.109: v1(37.2,104.76) 37.54,104.42 37.54,102.92 37.39,102.77 37.16,102.77 36.93,102.54 36.93,102.08 36.17,101.32 36.17,100.58 36.52,100.23 37.21,100.23 v1(37.67,99.77) ; Q6904.2 87.95,78.39 86.28,80.06 R6957.1 86.28,81.88 v1(86.31,81.91)
OCP_CHG#: length 201.5
  TOP w0.109: v1(160.83,47.24) 161.05,47.02 161.05,45.5 160.21,44.66 160.21,43.47 160.72,42.96 160.72,41.75 161.06,41.4 161.21,41.4 v1(161.88,40.73) ; v1(52.42,8.51) 53.19,7.74 PR8225.1
  IN2 w0.089: v1(161.88,40.73) 162.15,41 163.87,41 164.18,40.69 165.55,40.69 166.01,40.23 166.46,40.23 166.62,40.39 167.26,40.39 168.72,38.93 169.19,38.93 169.58,39.32 171.2,39.32 172.26,38.26 172.26,37.66 172.65,37.28 172.65,36.36 174.33,34.68 174.33,34.16 175.11,33.38 175.11,31.91 179.02,28 179.02,24.56 179.74,23.84 179.74,17.54 180.72,16.56 180.85,16.25 180.85,15.99 179.18,14.32 177.47,14.32 176.26,13.11 172.37,13.11 170.25,11 169.15,11 168.23,11.91 163.97,11.91 163.82,11.76 162.4,11.76 161.9,12.26 159.23,12.26 159.12,12.15 157.89,12.15 157.5,12.54 153.64,12.54 153.21,12.97 145.88,12.97 145.29,12.38 144.59,12.38 144.3,12.67 141.27,12.67 141.1,12.84 140.12,12.84 139.93,12.65 138.39,12.65 137.72,11.97 135.28,11.97 135.15,11.92 131,11.92 130.43,11.35 129.37,11.35 129.16,11.56 124.55,11.56 124,12.11 123.7,12.11 123.33,11.74 121.94,11.74 121.83,11.85 116.46,11.85 116.05,11.43 114.79,11.43 114.57,11.21 112.41,11.21 111.87,10.68 110.98,10.68 110.34,10.03 109.83,10.03 109.57,9.78 108.15,9.78 107.79,10.14 106.82,10.14 106.45,9.76 105.65,9.76 104.87,10.54 103.58,10.54 102.89,11.22 102.89,12.39 102.31,12.98 99.21,12.98 98.5,12.27 92.97,12.27 91.92,13.32 88.32,13.32 87.89,12.88 80.64,12.88 79.46,11.7 75.58,11.7 73.61,9.73 66.8,9.73 66.41,10.12 61.07,10.12 60.31,9.36 58.89,9.36 58.53,9 55.94,9 55.59,9.36 53.27,9.36 v1(52.42,8.51) ; v1(160.83,47.24) 160.83,47.38 159.59,48.62 159.59,49.02 159.51,49.1 159.51,51.66 159.02,52.15 159.02,52.67 157.73,53.96 157.73,54.91 157.64,55 157.64,57.21 157.22,57.63 157.22,58.87 157.39,59.05 157.39,59.81 v1(157.63,60.04)
  BOTTOM w0.109: PR8410.1 157.6,60.07 v1(157.63,60.04)
OCP_ID_ADC2: length 66.9
  IN2 w0.089: v2(194.78,13.33) 194.37,12.93 193.39,12.93 193.29,13.03 191.5,13.03 190.56,13.97 190.56,18.23 190.07,18.71 188.77,18.71 188.01,19.48 187.36,19.48 186.81,18.93 186.17,18.93 184.48,20.63 184.48,22.41 182.49,24.4 182.49,25.84 182.82,26.17 182.82,28.57 180.76,30.63 180.76,31.93 174.98,37.7 174.98,40.28 173.17,42.09 v1(173.17,42.11)
  BOTTOM w0.109: v2(194.78,13.33) 194.78,14.04 R4714.2 ; PR8405.1 189.53,53.67 189.49,53.62 PR8408.1 189.05,53.62 187.47,52.04 187.35,52.04 186.69,51.38 185.98,51.38 185.76,51.16 183.66,51.16 182.12,49.62 181.49,49.62 180.22,48.36 179.53,48.36 177.62,46.44 177.62,45.29 176.94,44.61 176.94,44.17 175.27,42.51 174.98,42.51 174.78,42.31 174.26,42.31 174.07,42.11 v1(173.17,42.11)
OCP_ID_SEL: length 51.9
  TOP w0.109: U4700.K9 198.04,20.24 198.04,22.27 198.3,22.53 198.3,23.59 v1(198.68,23.98) 198.75,24.04 198.75,25.37 199.05,25.68 R4741.1 199.71,25.68 v2(200.1,26.08)
  IN2 w0.089: v1(184.11,48.47) 183.94,48.3 183.94,46.93 184.2,46.67 184.2,45.54 186.26,43.47 186.26,40.36 185.52,39.62 185.52,38.19 189.8,33.91 189.8,32.38 192.58,29.6 192.88,29.6 193.55,28.93 197.22,28.93 197.45,28.83 198.8,27.48 198.8,27.25 199.32,26.74 199.77,26.74 200.1,26.41 v2(200.1,26.08)
  BOTTOM w0.109: v1(184.11,48.47) 183.47,49.11 183.3,49.11 182.98,49.43 182.98,49.83 183.85,50.7 185.96,50.7 186.05,50.8 186.05,50.8 186.17,50.92 186.89,50.92 187.46,51.5 188.27,51.5 PR8409.2 189.61,52.48 189.65,52.43 191.37,52.43 191.4,52.46 PQ8402.2
OCP_PWM_OUT: length 73.6
  TOP w0.076: U4700.G6 v2(195.44,17.64)
  IN1 w0.079: v2(195.44,17.64) 195.15,17.94 195.15,19.35 194.74,19.76 194.74,21.05 194.39,21.41 192.91,21.41 192.48,21.84 192.48,23.18 188.83,26.82 188.44,26.82 184.79,30.47 184.79,31.27 182.86,33.19 182.86,36.56 179.24,40.18 179.24,41.17 175.45,44.96 172.22,44.96 171.09,43.83 166.77,43.83 v1(166.34,43.4)
  IN2 w0.089: v1(166.34,43.4) 165.96,43.79 163.93,43.79 163.4,44.32 163.4,45.72 162.52,46.6 162.52,47.45 161.56,48.4 161.56,52.1 160.33,53.33 159.64,53.33 158.62,54.35 158.62,55.28 158.52,55.37 158.52,57.97 158.75,58.2 158.75,60.6 v1(158.24,61.11)
  BOTTOM w0.109: PQ8403.2 157.36,63.26 157.36,63.23 156.92,62.79 156.92,61.92 157.73,61.11 v1(158.24,61.11)
OLED_EN: length 46.9
  TOP w0.109: v1(32.54,12.95) 31.98,13.51 R3428.1
  IN1 w0.079: v1(20.62,39.69) 21.17,39.69 22.05,40.57 23.93,40.57 25.28,41.93 27.89,41.93 28.56,42.6 28.56,42.67 29.33,43.44 v1(29.75,43.44)
  IN2 w0.089: v1(20.62,39.69) 21.64,38.67 21.64,35.17 20.76,34.3 20.76,30.39 20.24,29.87 20.24,28.05 22.14,26.15 22.74,26.15 31.98,16.91 31.98,13.51 v1(32.54,12.95)
  BOTTOM w0.109: CON3400.36 29.08,43.25 29.27,43.44 v1(29.75,43.44)
OLED_EN_R: length 0.9
  TOP w0.109: R3428.2 30.48,13.51 30.17,13.82 v1(30.17,13.92)
ON_OFF#: length 195.5
  TOP w0.109: VC5001.1 13.6,40.41 13.79,40.22 13.79,40.08 14.35,39.52 v1(14.49,39.52) 14.52,39.52 15.12,38.91 16.23,38.91 16.36,39.04 C5031.1 16.92,38.76 18.16,38.76 18.62,38.3 19.58,38.3 20.09,37.79 20.52,37.79 21.79,36.52 Q7500.3 22.15,36.93 22.43,37.21 v1(22.58,37.21) 22.78,37.21 23.06,37.48 23.06,38.62 R7501.1 23.43,39.68 v1(23.54,39.8) R7500.2 23.54,41.33 R7502.1
  IN2 w0.089: v1(26.61,26.85) 24.71,28.75 24.71,29.18 23.98,29.92 23.98,31.77 26.44,34.24 26.44,34.92 24.15,37.21 v1(22.58,37.21)
  IN3 w0.089: v1(14.49,39.52) 14.28,39.3 14.28,38.28 13.56,37.56 13.56,35.63 11.78,33.86 11.78,21.64 13.47,19.95 13.47,17.77 13.81,17.43 13.81,10.67 14.5,9.98 15.44,9.98 17.03,8.39 19.98,8.39 20.44,7.92 21.36,7.92 21.99,7.29 23.59,7.29 24.11,6.77 24.11,6.31 24.28,6.14 24.84,6.14 25.04,6.34 25.04,6.69 25.32,6.97 26.19,6.97 26.34,6.91 27.23,6.02 29.9,6.02 30.24,5.68 33.61,5.68 34.69,6.76 39.73,6.76 40.09,7.13 42.49,7.13 42.94,6.67 47.22,6.67 48,7.44 49.86,7.44 50.38,7.96 51.57,7.96 51.79,7.87 53.77,7.87 54.53,7.1 59.61,7.1 60.71,8.21 60.71,8.96 61.45,9.7 74.47,9.7 74.68,9.91 85.85,9.91 86.5,10.56 93.59,10.56 94.24,9.91 98.54,9.91 99.49,8.96 103.19,8.96 104.03,8.13 105.53,8.13 105.79,7.87 108.61,7.87 109.87,9.14 111.63,9.14 112.06,9.57 112.06,10.24 112.7,10.87 113.47,10.87 113.6,10.82 113.73,10.69 114.05,10.69 114.12,10.66 114.27,10.51 114.41,10.18 114.92,9.67 124.76,9.67 125.29,10.19 127.99,10.19 v1(128.6,10.8)
  BOTTOM w0.109: CON5000.7 128.64,10.75 v1(128.6,10.8) ; R5027.2 29,24.71 28.47,24.18 26.74,24.18 26.39,24.53 26.39,26.67 26.56,26.85 v1(26.61,26.85)
ON_OFF#1_Q: length 180.7
  TOP w0.109: v1(167.01,39) 167.01,37.46 R4818.2 ; v1(50.77,48.23) 51.2,48.66 51.2,49.48 50.78,49.91 R7702.2 ; v1(18.19,40) 18.41,40 18.84,39.57 19.35,39.57 19.56,39.37 19.56,39.17 20.31,38.42 20.84,38.42 21.36,37.9 Q7500.1 21.65,38.54 v1(21.84,38.73) 22.39,38.73 R7501.2 22.65,39.37 22.46,39.56 R7504.1
  IN1 w0.079: v1(167.01,39) 165.97,37.95 164.86,37.95 163.66,39.16 162.88,39.16 161.8,40.24 161.38,40.24 161.21,40.41 160.28,40.41 160.04,40.66 156.82,40.66 150.84,46.64 150.84,46.79 150.37,47.26 150.22,47.26 149.05,48.42 v1(149.05,48.77) ; v1(58.77,50.67) 58.77,50.13 58.09,49.45 57.38,49.45 55.73,47.8 51.2,47.8 v1(50.77,48.23) 50.39,47.85 50.39,46.96 49.73,46.3 45.67,46.3 45.03,45.67 45.03,44.8 44.7,44.47 39.42,44.47 38.88,43.94 38.03,43.94 37.17,43.08 35.77,43.08 35.17,43.68 30.94,43.68 30.3,44.32 29.32,44.32 27.93,42.93 27.93,42.87 27.62,42.56 25.02,42.56 23.66,41.2 19.66,41.2 19.43,40.97 18.97,40.97 18.19,40.19 v1(18.19,40)
  BOTTOM w0.109: v1(149.05,48.77) 148.8,49.02 119.09,49.02 115.04,44.96 109.13,44.96 102.01,52.08 77.69,52.08 77.46,52.31 75.95,52.31 74.02,50.38 60.18,50.38 59.82,50.75 58.85,50.75 v1(58.77,50.67) ; CON7700.11 17.88,39.69 v1(18.19,40)
OVP_DET: length 18.5
  TOP w0.109: v1(51.8,4.42) 51.88,4.5 PR8242.2 ; v1(43.93,8.68) 43.64,8.97 PQ8405.3 42.63,7.66 PR8417.2
  BOTTOM w0.109: PQ8205.2 52.03,5.44 52.03,4.65 v1(51.8,4.42) 51.44,4.78 44.82,4.78 44.47,5.13 44.47,8.14 v1(43.93,8.68)
PCH_DISP_ON: length 269.6
  IN2 w0.089: v1(34.41,32.15) 31.65,29.39 31.65,21.18 33.65,19.17 35.51,19.17 37.08,17.6 38.43,17.6 40.03,16 v1(40.56,16) ; v2(142.08,82.4) 142.3,82.18 143.16,82.18 143.59,82.61 148.65,82.61 150.17,81.09 152.14,81.09 152.5,80.73 154.91,80.73 156.46,79.19 156.46,78.23 156.84,77.85 156.84,75.82 156.93,75.73 156.93,74.65 157.78,73.8 157.78,73.11 157.08,72.41 157.08,71.96 155.94,70.81 152.94,70.81 152.43,70.3 151.86,70.3 151.56,70.01 151.56,68.41 152.07,67.9 152.07,65.84 152.68,65.24 152.68,64.33 149.87,61.53 149.87,59.01 150.29,58.6 150.29,58.35 151.49,57.15 153.1,57.15 155.01,55.23 156.78,55.23 157.48,54.53 157.48,53.95 158.84,52.59 158.84,52.08 159.34,51.58 159.34,49.02 159.41,48.95 159.41,48.54 160.42,47.54 160.42,47.11 161.98,45.54 161.98,45.48 163.43,44.03 163.43,43.95 164.01,43.38 v1(164.69,43.38)
  IN3 w0.089: v1(40.56,16) 47.19,16 48.55,14.64 53.7,14.64 53.83,14.51 57.95,14.51 58.8,13.65 62.1,13.65 62.97,14.53 67.35,14.53 67.64,14.24 69.89,14.24 71.6,15.95 74.63,15.95 75.82,14.76 79.08,14.76 79.99,15.67 85.67,15.67 85.85,15.85 88.16,15.85 88.21,15.8 88.75,15.8 88.82,15.87 93.34,15.87 93.7,16.23 100.29,16.23 101.73,17.67 101.73,17.98 102.74,19 104.47,19 105.53,17.93 106.87,17.93 107.62,18.68 110.95,18.68 112.2,19.93 119.74,19.93 120.3,19.37 142.12,19.37 142.14,19.35 156.77,19.35 157.71,18.41 157.71,17.85 157.94,17.62 160.44,17.62 163.14,20.32 175.24,20.32 176.12,21.2 177.13,21.2 177.43,21.5 177.43,24.39 177.31,24.51 177.31,26.87 176.87,27.32 176.87,28.62 170.94,34.55 170.94,36.23 169.51,37.67 169.51,38.08 166.34,41.25 166.34,41.73 v1(164.69,43.38)
  BOTTOM w0.109: v1(34.41,32.15) 34.01,31.75 30.98,31.75 30.84,31.9 R3414.2 30.67,32.3 30.67,32.88 30.37,33.17 U3400.3 ; v2(142.08,82.4) 141.87,82.61 141.63,82.85 U400.DM8
PCH_DPST_PWM: length 344.8
  TOP w0.109: v2(139.86,81.44) 139.86,81.44 139.9,81.44 140.38,81.91 142.38,81.91 143.05,81.25 144.03,81.25 144.79,82.01 146.43,82.01 146.73,81.72 146.73,81.09 145.6,79.97 v2(145.44,79.67) ; R3433.2 33.74,39.84 v1(33.96,40.05) 33.96,40.56 v1(34.34,40.94)
  IN1 w0.076: v2(189.74,20.58) 189.74,19.93 190.09,19.58 190.09,18.46 190.42,18.13
  IN1 w0.079: v2(145.44,79.67) 145.86,80.09 149.57,80.09 150.53,79.13 152.45,79.13 152.97,78.61 154.42,78.61 155.3,79.5 156.59,79.5 156.85,79.23 159.38,79.23 160.11,78.51 164.08,78.51 165.43,77.16 166.3,77.16 167.8,78.66 168.17,78.66 168.73,78.1 168.73,77.32 169.14,76.91 170.59,76.91 171.42,76.08 172.26,76.08 172.67,76.49 175.7,76.49 176.15,76.93 177.73,76.93 178.03,76.63 178.26,76.63 v1(178.46,76.43) ; 190.42,18.13 190.67,17.76 190.87,17.28 190.87,14.92 v2(191.36,14.43)
  IN3 w0.089: v1(161.08,14.65) 163.06,14.65 163.57,15.16 164.29,15.16 164.71,15.58 164.71,15.93 165.01,16.23 165.46,16.23 166.09,16.86 168.2,16.86 168.35,17.02 169.57,17.02 170.81,15.78 178.35,15.78 180.28,17.71 180.28,18.58 180.89,19.2 181.79,19.2 184.07,21.48 184.07,22.1 184.63,22.65 184.78,22.65 184.88,22.76 185.32,22.76 186.13,21.94 186.13,20.88 186.57,20.43 188.6,20.43 188.75,20.58 v2(189.74,20.58) 189.74,20.83 190.29,21.38 190.29,22.57 189.9,22.96 189.6,23.09 189.14,23.09 188.06,24.17 187.82,24.27 186.94,24.27 184.88,26.33 184.5,27.25 183.09,29.36 183.09,31.19 181.67,32.61 180.42,32.61 179.32,33.72 179.32,36 178.85,36.47 177.87,36.47 176.12,38.21 176.12,41.52 175.32,42.32 175.19,42.32 173.91,43.6 v1(173.91,43.85) ; v1(178.46,76.43) 178.46,76.22 180.17,74.5 180.17,73.75 183.59,70.33 183.59,68.35 184.76,67.18 184.76,66.48 189.67,61.57 190.16,60.38 190.83,59.71 v1(190.83,59.57) ; v1(34.34,40.94) 34.01,40.61 34.01,37.3 33.86,37.16 33.86,35 31.63,32.78 31.63,21.52 35.42,17.73 47.46,17.73 49.25,15.95 54.28,15.95 54.57,15.66 58.58,15.66 59.38,14.86 60.25,14.86 61.36,15.97 62.81,15.97 63.1,15.69 67.83,15.69 68.1,15.42 69.18,15.42 71.45,17.69 78.57,17.69 79.43,16.83 80.79,16.83 82.74,18.77 83.2,18.77 83.87,19.44 87.14,19.44 89.55,17.03 92.19,17.03 92.46,17.3 92.46,19.1 93.61,20.25 97.17,20.25 97.27,20.15 104.68,20.15 104.81,20.28 107.71,20.28 107.92,20.49 109.52,20.49 111.5,22.48 116.04,22.48 117.31,21.21 120.09,21.21 120.77,20.54 142.66,20.54 142.69,20.51 157.74,20.51 v1(160.25,18.01)
  BOTTOM w0.109: v2(139.86,81.44) 139.57,81.73 U400.DG10 ; v1(161.08,14.65) 161.69,14.65 162.06,15.02 162.06,17.55 161.88,17.73 160.53,17.73 v1(160.25,18.01) ; v1(190.83,59.57) 190.83,58.14 190.27,57.58 190.27,56.61 188.87,55.22 181,55.22 179.65,53.87 178.26,53.87 176.18,51.79 176.18,50.56 176.15,50.53 175.68,50.06 175.68,48.48 174.92,47.72 174.92,45.56 173.91,44.55 v1(173.91,43.85) ; R4730.1 190.96,15.65 190.96,14.83 v2(191.36,14.43) 191.97,13.81 R3420.2
PCH_DPST_PWM_R: length 3.7
  TOP w0.109: R3434.2 26.61,41.07 27.94,41.07 v1(28.06,40.94) 28.7,40.31 U3405.4
PCH_DSWROK: length 26.5
  TOP w0.109: v1(162.79,68.33) 162.79,68.64 R1527.1 162.51,68.84 R1529.1
  IN1 w0.079: v2(141.27,71.38) 141.28,71.38 141.64,71.74 141.99,71.74 142.19,71.55 142.19,71.15 142.29,71.04 143.23,71.04 143.34,70.93 144.2,70.93 145.07,70.07 147.86,70.07 148.82,69.1 149.79,69.1 150.09,68.8 150.7,68.8 151.24,68.26 154.33,68.26 154.57,68.5 155.18,68.5 155.35,68.33 156.02,68.33 156.89,67.46 160.27,67.46 161.14,68.33 v1(162.79,68.33)
  BOTTOM w0.109: U400.DK35 140.87,71.03 141.21,71.37 141.27,71.37 v2(141.27,71.38)
PCH_IST_TP_0: length 5.8
  BOTTOM w0.109: TP1000.1 148.82,62.3 148.49,62.63 148.07,62.63 147.76,62.94 146.03,62.94 145.41,62.32 144.2,62.32 U400.DU53
PCH_IST_TP_1: length 8.6
  BOTTOM w0.109: U400.DT52 143.55,63.16 143.55,62.54 143.96,62.13 145.53,62.13 146.12,62.72 147.67,62.72 147.98,62.41 148.33,62.41 149.04,61.69 149.83,61.69 TP1002.1
PCH_JTAGX: length 14
  IN2 w0.089: v2(102.65,82.96) 102.68,82.99 102.68,83.04 102.97,83.34 103.35,83.34 103.6,83.59 103.6,84.71 103.3,85.01 101.57,85.01 101.27,84.72 v1(98.65,84.72)
  BOTTOM w0.109: v1(98.65,84.72) 98.38,84.99 97.13,84.99 96.48,84.34 95.97,84.34 95.64,84.01 94.03,84.01 R609.1 ; U400.D8 102.37,83.27 102.65,82.99 v2(102.65,82.96)
PCH_KBC_CLK: length 399.7
  TOP w0.109: U4700.K8 198.03,18.95 199.23,18.95 199.35,18.83 200.4,18.83 200.83,18.41 v2(201.09,18.41) ; v1(116.67,6.66) 116.25,7.08 115.84,7.08 115.13,6.37 104.81,6.37 103.5,7.69 98.49,7.69 97.08,9.09 92.29,9.09 90.56,10.82 89.18,10.82 88.68,11.31 88.68,13.38 89.16,13.85 89.16,15.19 90.8,16.83 v1(90.8,17.5)
  IN1 w0.079: v1(116.67,6.66) 117.51,5.82 132.21,5.82 132.59,6.2 136.73,6.2 137.28,6.75 139.62,6.75 140.18,6.2 145.36,6.2 145.77,6.62 146.11,6.62 146.52,6.2 150.82,6.2 151.44,6.82 157.48,6.82 158.1,6.2 160.52,6.2 160.84,6.53 161.97,6.53 162.85,7.4 164.78,7.4 165.3,7.92 168.34,7.92 172.43,3.83 177.26,3.83 177.97,4.54 179.15,4.54 179.73,5.13 181.03,5.13 182.92,7.03 186,7.03 186.53,6.5 187.23,6.5 187.77,5.96 192.38,5.96 192.4,5.94 194.6,5.94 195.59,4.95 196.23,4.95 196.53,5.08 197.24,5.79 198.3,5.79 198.8,5.28 199.36,5.28 200.78,6.7 200.96,7.13 201.09,7.26 201.09,9.04 200.38,9.75 200.38,13 200.02,13.37 200.02,14.31 200.89,16.42 200.89,18.21 v2(201.09,18.41)
  IN3 w0.089: v1(77.75,95.76) 78.08,95.42 78.08,93.13 78.63,92.59 78.63,91.3 77.85,90.53 77.85,87.77 80.4,85.21 80.4,84.35 80.9,83.86 80.9,81.21 80.78,81.1 80.78,78.94 80.28,78.45 80.28,75.51 78.03,73.25 75.54,73.25 73.81,71.52 72.04,71.52 71.1,70.58 68.91,70.58 68.63,70.3 68.63,68.72 69.23,67.28 69.23,64.64 67.05,62.46 67.05,57.76 62.93,53.64 61.52,53.64 60.88,54.27 58.95,54.27 v1(58.72,54.05) 58.72,53.5 56.68,51.46 51.43,51.46 50.26,50.29 46.94,50.29 45.45,48.8 43.19,48.8 42.12,47.73 42.12,41.96 40.89,40.73 40.89,35.87 39.17,34.14 35.16,34.14 34.01,32.99 34.01,31.94 33.13,31.06 33.13,26.06 34.85,24.34 36.62,24.34 41.27,19.69 49.58,19.69 50.89,21 63.9,21 65.22,19.69 78.15,19.69 79.33,18.51 79.33,18.25 v1(79.55,18.03) 79.7,18.18 79.7,19.17 80.29,19.76 82.95,19.76 83.44,20.25 87.48,20.25 89.7,18.03 90.26,18.03 v1(90.8,17.5)
  BOTTOM w0.076: v2(201.09,18.41) 201.04,18.36 R4724.2
  BOTTOM w0.109: Q5404.6 89.48,71.3 88.97,70.79 88.14,70.79 87.9,71.03 87.45,71.03 87.25,70.83 87.25,70.18 86.66,69.59 86.18,69.59 85.63,69.04 85.63,68.45 86.66,67.42 86.66,65.88 87.26,65.28 87.26,63.76 86.93,63.43 86.93,60.33 85.8,59.21 84.16,59.21 81.79,56.83 75.73,56.83 73.41,54.51 63.9,54.51 63.16,55.26 62.44,55.26 62.1,54.91 61.75,54.91 61.53,54.7 59.37,54.7 v1(58.72,54.05) ; v1(79.55,18.03) 79.41,17.89 79.41,13.09 76.04,9.72 76.04,7.74 75.8,7.5 75.8,2.8 74.94,1.94 65.52,1.94 65.1,2.37 62.27,2.37 61.83,2.81 PU8201.1 ; Q6900.3 76.48,95.16 77.31,95.16 77.75,95.6 v1(77.75,95.76)
PCH_KBC_DATA: length 395.9
  TOP w0.109: v2(201.88,16.96) 201.67,16.96 200.29,18.34 199.18,18.34 199.13,18.29 198.05,18.29 U4700.K7 ; v1(90.16,17.5) 90.16,16.72 88.75,15.31 88.75,13.97 88.31,13.53 88.31,11.15 89.01,10.45 90.41,10.45 92.13,8.72 96.93,8.72 98.34,7.32 103.35,7.32 104.66,6 115.4,6 v1(116.05,6.65)
  IN1 w0.079: v2(201.88,16.96) 201.21,16.29 200.37,14.26 200.37,13.51 200.73,13.14 200.73,9.93 201.45,9.22 201.45,7.12 201.25,6.93 201.06,6.47 199.46,4.87 198.63,4.87 198.22,5.28 197.23,5.28 197.03,5.08 197.03,4.6 196.73,4.3 195.89,4.3 195.57,4.62 195.45,4.62 194.54,5.53 192.34,5.53 192.25,5.62 187.63,5.62 187.09,6.16 186.39,6.16 185.86,6.69 183.06,6.69 181.16,4.8 179.87,4.8 179.28,4.21 178.11,4.21 177.39,3.5 172.29,3.5 168.2,7.59 165.44,7.59 164.92,7.07 163.63,7.07 162.32,5.75 161.45,5.75 161.36,5.84 138.58,5.84 138.25,6.17 137.28,6.17 136.98,5.87 132.79,5.87 132.41,5.49 117.22,5.49 v1(116.05,6.65) ; v1(75.54,8.1) 75.19,7.75 75.19,2.89 74.38,2.08 66.24,2.08 64.81,3.52 v1(63.82,3.52)
  IN3 w0.089: v1(77.59,94.06) 77.59,93.12 78.09,92.62 78.09,91.39 76.96,90.25 76.96,88.14 80.03,85.06 80.03,84.2 80.49,83.74 80.49,81.33 80.41,81.25 80.41,79.1 79.91,78.6 79.91,75.63 77.92,73.63 75.38,73.63 73.65,71.91 71.93,71.91 70.97,70.94 68.76,70.94 68.24,70.42 68.24,68.78 68.88,67.21 68.88,64.84 66.68,62.63 66.68,57.93 62.74,53.99 61.66,53.99 61.01,54.64 58.61,54.64 58.27,54.3 58.27,53.65 v1(58.22,53.6) 56.44,51.83 51.23,51.83 50.04,50.63 46.76,50.63 45.3,49.17 42.93,49.17 41.76,48 41.76,42.11 40.53,40.88 40.53,35.98 39.03,34.49 35,34.49 33.67,33.16 33.67,32.2 32.79,31.32 32.79,25.91 34.71,24 36.16,24 40.84,19.32 49.74,19.32 51.08,20.66 63.76,20.66 65.1,19.32 77.88,19.32 78.92,18.29 v1(78.92,18.03) 79.37,17.58 79.81,17.58 80.06,17.83 80.06,19.01 80.46,19.42 83.09,19.42 83.59,19.91 87.33,19.91 89.75,17.5 v1(90.16,17.5)
  BOTTOM w0.109: Q6900.6 77.77,93.89 v1(77.59,94.06) ; v1(63.82,3.52) 63.42,3.12 PU8201.5 ; Q5404.3 91.26,70 90.43,69.17 87.81,69.17 87.35,68.7 87.35,68.43 87.76,68.02 87.76,66.34 88.35,65.75 88.35,63.31 88.02,62.98 88.02,59.05 86.33,57.36 84.68,57.36 82.8,55.49 75.95,55.49 73.87,53.41 61.95,53.41 61.03,54.33 59.64,54.33 58.91,53.6 v1(58.22,53.6) ; v1(78.92,18.03) 79.05,17.9 79.05,13.24 75.54,9.74 v1(75.54,8.1) ; v2(201.88,16.96) 202.03,17.11 R4723.2
PCH_LVDS_BLON: length 218.6
  TOP w0.109: v2(142.88,82.99) 142.88,82.99 143.1,83.21 143.1,83.46 143.62,83.98 144.78,83.98 147.09,86.28 148.13,86.28 150.4,84.02 150.61,84.02 150.9,83.73 153.61,83.73 v1(153.77,83.58) ; R3425.2 24.71,49.58 R3402.2 R3405.2 23.44,49.57 v1(22.83,50.19)
  IN2 w0.089: v1(153.77,83.58) 154.01,83.34 156.11,83.34 158.8,80.64 158.8,76.46 158.3,75.96 158.3,75.08 159.03,74.36 159.03,72.59 158.33,71.89 158.33,70.53 158.39,70.47 158.39,69.09 157.99,68.69 157.99,68.22 157.62,67.85 157.62,67.05 158,66.67 158.88,66.67 159.52,66.04 159.52,64.25 159.25,63.99 159.25,62.83 160.11,61.97 160.11,60.68 161.24,59.56 161.24,58.82 160.63,58.21 160.63,56.65 161.7,55.58 161.7,54.98 162.87,53.81 162.87,48.94 164.14,47.68 v1(164.14,47.65)
  BOTTOM w0.109: v1(22.83,50.19) 25.6,50.19 26.44,49.35 27,49.35 27.59,48.76 27.85,48.76 28.21,48.4 28.21,48.14 29.03,47.32 34.24,47.32 38.57,42.99 39.24,42.99 42.59,39.63 42.59,38.6 43.5,37.69 44.1,37.69 48.13,33.66 103.16,33.66 104.29,32.53 118.78,32.53 123.91,37.66 155.2,37.66 157.03,39.49 157.41,39.49 159.89,41.98 159.89,42.01 160.47,42.59 160.47,43.23 160.28,43.43 160.28,43.96 162.2,45.89 162.2,46.71 163.14,47.65 v1(164.14,47.65) ; v2(142.88,82.99) 142.75,82.99 142.62,82.85 U400.DN8
PCH_OPI_RCOMP: length 1.8
  TOP w0.109: v2(127.99,82.66) 127.76,82.43 R608.2
  BOTTOM w0.109: v2(127.99,82.66) 128.26,82.39 U400.CB9
PCH_PWROK: length 22.5
  TOP w0.109: R1513.1 161.44,68.12 161.44,68.12 R1574.1 161.39,68.43 160.78,68.43 v1(160.73,68.37) 160.38,68.02 v1(160.2,68.02)
  IN1 w0.079: v1(160.2,68.02) 159.79,67.62 157,67.62 156.13,68.49 155.41,68.49 155.24,68.66 154.51,68.66 154.27,68.42 151.3,68.42 150.76,68.96 150.15,68.96 148.77,70.34 145.07,70.34 143.69,71.73 142.87,71.73 v2(142.53,71.39)
  BOTTOM w0.109: U400.DN35 142.17,71.03 v2(142.53,71.39)
PCH_SLP_S0IX#: length 113.9
  TOP w0.076: U4700.J3 197.39,15.69 197.39,14.43 v2(197.56,14.26)
  TOP w0.109: v2(150.78,74.04) 150.9,74.16 150.9,74.7 R813.1 ; R818.1 155.67,52.55 155.7,52.52 v1(155.7,52.22)
  IN1 w0.079: v1(163.12,41.48) 163.65,41.48 164.53,42.36 165.93,42.36 166.56,42.98 171.57,42.98 171.86,43.27 171.86,44.01 172.42,44.58 174.59,44.58 175.96,43.21 175.96,39.06 176.52,38.49 180.26,38.49 182.39,36.36 182.39,33 184.32,31.07 184.32,30.35 187.94,26.73 187.94,26.16 190.83,23.27 190.83,21.74 192.28,20.29 192.28,18.74 192.29,18.73 192.29,16.17 193.34,15.11 196.71,15.11 v2(197.56,14.26)
  IN2 w0.089: v2(145.32,77.57) 145.86,78.12 146.42,78.12 146.49,78.19 147.89,78.19 147.97,78.12 148.32,78.12 150.78,75.67 v2(150.78,74.04) 150.23,74.04 149.94,73.74 149.94,72.5 148.99,71.55 148.99,71.12 149.35,70.76 149.35,69.23 149.21,69.09 148.92,69.09 148.73,68.89 148.73,68.54 148.95,68.32 148.95,67.35 149.26,67.04 149.26,66.72 148.76,66.22 148.76,65.64 148.97,65.13 148.97,63.44 148.44,62.91 148.44,58.44 148.87,58.01 148.87,57.74 150.88,55.73 151.87,55.73 154.69,52.9 154.69,52.07 154.93,51.83 155.31,51.83 v1(155.7,52.22)
  IN3 w0.089: v1(155.7,52.22) 155.69,52.21 155.69,52.08 157.86,49.91 157.86,48.33 159.03,47.16 159.03,45.3 160.41,43.92 161.46,43.92 161.62,43.76 161.62,43.28 162.88,42.02 162.88,41.72 v1(163.12,41.48)
  BOTTOM w0.109: v2(145.32,77.57) 145.26,77.63 144.28,77.63 U400.DU19
PCH_SLP_SUS#: length 97.6
  TOP w0.076: U4700.J6 v2(197.39,17.64)
  IN1 w0.079: v1(159.82,42.86) 160.57,42.86 160.75,43.04 163.6,43.04 164.7,44.14 167.99,44.14 170.06,46.21 170.6,46.21 171.46,47.07 173.56,47.07 174.07,47.58 174.43,47.58 174.86,48.01 175.52,48.01 176.47,47.06 176.79,47.06 181.01,42.84 181.01,42.53 182.5,41.03 182.5,39.22 184.49,37.23 184.49,35 186.5,33 186.5,31.21 188.95,28.76 190.07,28.76 190.45,28.38 190.45,27.35 191.51,26.28 192.54,26.28 195.83,22.98 197.3,22.98 198.78,21.51 198.78,18.9 197.53,17.64 v2(197.39,17.64)
  IN2 w0.089: v2(147.18,64.22) 146.43,64.22 145.24,63.04 145.24,61.38 146.31,60.3 146.31,57.55 149.54,54.33 149.96,54.33 150.9,53.39 152.56,53.39 152.83,53.11 152.83,51.91 153.13,51.61 153.13,50.72 152.74,50.33 152.74,48.76 153.2,48.3 153.76,48.3 154.03,48.03 156.2,48.03 157.39,46.83 157.39,46.71 158.55,45.54 158.55,44.49 159.82,43.22 v1(159.82,42.86)
  BOTTOM w0.109: U400.DV49 144.52,64.77 145.13,64.77 145.68,64.22 v2(147.18,64.22) 148.35,64.22 R1544.2
PCH_SMB_CLK: length 16.9
  IN1 w0.079: v2(140.66,77.82) 141.76,76.73 142.81,76.73 143.32,76.22 144.44,76.22 144.48,76.18 146.52,76.18 146.78,76.44 147.78,76.44 148.11,76.76 150.27,76.76 151.37,75.66 v2(151.94,75.66)
  BOTTOM w0.109: v2(151.94,75.66) 151.94,75.56 152.22,75.28 152.55,75.28 152.7,75.13 R1140.1 152.72,74.88 R1125.1 153.39,75.24 153.69,75.54 v1(153.69,75.64) 153.69,75.75 Q1100.6 ; U400.DK21 140.87,77.61 v2(140.66,77.82)
PCH_SMB_DATA: length 18.3
  IN1 w0.079: v2(152.5,75.66) 152.14,76.02 151.51,76.02 150.41,77.11 147.96,77.11 147.64,76.79 146.67,76.79 146.59,76.87 143.82,76.87 143.59,77.1 141.91,77.1 v2(141.21,77.8)
  BOTTOM w0.109: v2(141.21,77.8) 141.52,78.11 U400.DM19 ; v2(152.5,75.66) 152.47,75.69 152.47,78.31 152.58,78.41 R1133.1 152.45,78.81 152.25,78.61 R1126.1 151.76,78.61 151.57,78.42 Q1100.3
PCH_SMBCLK: length 309.3
  TOP w0.109: v1(172.11,58.68) 171.6,58.16 168.63,58.16 165.78,55.32 164.69,55.32 161.25,51.88 161.25,49.1 160.76,48.61 160.13,48.61 158.73,47.21 158.73,44.81 158.92,44.63 158.92,41.29 158.42,40.79 158.42,39.57 v1(158.15,39.31) ; v1(48.9,52.48) CON7703.53
  IN1 w0.079: v1(158.15,39.31) 158.15,38.64 163.8,32.99 171.37,32.99 172.34,32.03 173.29,32.03 174.95,30.36 176.56,30.36 179.69,27.24 179.76,27.24 180.17,26.82 180.17,24.37 180.37,24.18 180.37,23.65 181.66,22.36 v1(181.66,22.27) 180.51,21.12 154.89,21.12 153.68,19.91 152.97,19.91 152.41,19.35 147.56,19.35 146.56,20.35 117.21,20.35 115.71,21.85 114.03,21.85 113.21,21.03 112.16,21.03 111.67,21.53 111.67,24.22 110.17,25.72 105.19,25.72 v1(105.09,25.61) 104.59,25.12 104.59,24.66 104.16,24.23 102.77,24.23 102.44,23.9 102.44,21.99 101.52,21.07 95.68,21.07 95.49,20.89 93.34,20.89 92.77,20.31 59.48,20.31 59.2,20.6 48.61,20.6 v1(44.52,16.51)
  IN3 w0.089: v1(48.9,52.48) 46.25,52.48 43.31,49.54 42.81,49.54 41.39,48.12 41.39,42.26 40.16,41.03 40.16,36.1 38.89,34.83 34.85,34.83 32.84,32.82 32.84,31.87 32.45,31.48 32.45,24.78 33.61,23.62 36.02,23.62 37.39,22.25 v1(37.39,20.44) ; v2(153.16,74.19) 153.74,74.78 154.66,74.78 154.78,74.65 156.46,74.65 158.17,72.94 158.17,71.46 158.51,71.12 160.72,71.12 162.47,69.38 162.84,69.38 163.54,68.68 163.54,68.04 163.23,67.74 163.23,66.84 163.78,66.29 165.54,66.29 165.85,65.97 166.14,65.97 167.72,64.39 168.21,64.39 171.29,61.32 171.29,59.64 171.89,59.04 171.89,58.89 v1(172.11,58.68)
  BOTTOM w0.109: v2(153.16,74.19) 152.86,74.5 152.47,74.5 152.25,74.72 R1140.2 R1114.1 151.51,74.95 151.51,76.21 Q1100.1 ; v1(105.09,25.61) 104.56,25.61 104.47,25.71 JDIM2900.253 ; JDIM2800.253 181.43,22.51 v1(181.66,22.27) ; v1(44.52,16.51) 44.52,17.64 43.78,18.39 39.55,18.39 38.05,19.89 37.87,19.89 37.39,20.37 v1(37.39,20.44)
PCH_SMBDATA: length 310.8
  TOP w0.109: v1(172.12,58.03) 171.88,57.8 168.78,57.8 165.94,54.95 164.84,54.95 161.62,51.73 161.62,48.94 160.92,48.24 160.28,48.24 159.28,47.24 159.28,39.76 v1(159.26,39.73) ; v1(49.53,52.48) 49.03,51.98 CON7703.51
  IN1 w0.079: v1(43.86,16.51) 44.24,16.13 44.7,16.13 48.84,20.26 59.06,20.26 59.35,19.98 92.91,19.98 93.48,20.55 95.63,20.55 95.82,20.74 101.66,20.74 102.77,21.85 102.77,23.76 102.9,23.9 104.3,23.9 105.09,24.68 v1(105.09,24.95) 105.5,25.36 110.03,25.36 111.34,24.05 111.34,21.35 112.01,20.67 113.32,20.67 114.17,21.52 115.57,21.52 117.08,20.02 146.42,20.02 147.42,19.02 152.55,19.02 153.11,19.58 153.84,19.58 155.06,20.79 180.85,20.79 181.68,21.63 v1(181.68,21.65) 182.15,22.12 182.15,22.33 180.72,23.77 180.72,24.3 180.51,24.51 180.51,26.96 179.9,27.57 179.83,27.57 176.68,30.71 175.1,30.71 173.44,32.37 172.48,32.37 171.52,33.33 164.02,33.33 159.59,37.75 159.59,38.6 159.26,38.93 v1(159.26,39.73)
  IN3 w0.089: v1(36.95,20.9) 36.95,22.16 35.84,23.27 33.47,23.27 32.1,24.64 32.1,31.62 32.48,32 32.48,32.95 34.71,35.17 38.74,35.17 39.79,36.22 39.79,41.19 41.02,42.42 41.02,48.23 42.69,49.91 43.15,49.91 46.18,52.93 49.08,52.93 v1(49.53,52.48) ; v2(154.43,74.39) 154.51,74.31 156.32,74.31 157.83,72.8 157.83,71.31 158.36,70.78 160.58,70.78 162.32,69.03 162.7,69.03 163.19,68.54 163.19,68.18 162.89,67.88 162.89,66.7 163.64,65.95 165.39,65.95 165.71,65.63 166,65.63 167.58,64.05 168.07,64.05 170.94,61.18 170.94,59.5 171.55,58.89 171.55,58.31 171.83,58.03 v1(172.12,58.03)
  BOTTOM w0.109: JDIM2800.254 181.68,21.64 v1(181.68,21.65) ; Q1100.4 153.24,77.64 153.24,78.28 153.03,78.49 R1133.2 R1116.1 153.57,78.43 153.65,78.35 153.65,78.12 154.96,76.81 154.96,75.89 154.43,75.36 v2(154.43,74.39) ; JDIM2900.254 104.72,21.16 104.63,21.25 104.63,23.02 104.96,23.35 104.96,24.83 v1(105.09,24.95) ; v1(43.86,16.51) 43.86,17.78 43.63,18.02 39.38,18.02 37.89,19.5 37.72,19.5 36.95,20.27 v1(36.95,20.9)
PCH_SPI1_CLK: length 48.5
  TOP w0.109: R5601.2 R5602.1 163.12,73.53 162.73,73.91 162.67,73.98 161.73,73.98 v1(161.67,73.91) ; U5100.19 164.89,65.19 164.81,65.27 164.81,65.71 164.94,65.84 164.94,65.96 R5110.1 165.24,65.83 v1(165.24,65.56)
  BOTTOM w0.109: v1(165.24,65.56) 164.7,65.02 163.42,65.02 162.75,65.69 162.75,67.77 162.37,68.15 162.37,69.41 162.72,69.77 162.72,70.32 162.63,70.41 162.63,70.98 162.2,71.41 162.2,72.58 161.88,72.9 161.88,72.95 161.88,72.96 161.88,73.7 v1(161.67,73.91) 161.87,74.12 161.87,76.64 162.5,77.27 162.5,78.41 161.52,79.4 161.52,81.45 160.2,82.77 160.2,84.2 160.24,84.25 TP5601.1 160.24,85.44 159.93,85.75 159.93,88.88 159.73,89.09 157.34,89.09 157.21,89.22 155.93,89.22 155.81,89.33 155.81,89.6 155.93,89.72 156.93,89.72 157.05,89.83 157.05,90.1 156.93,90.21 155.67,90.21 155.56,90.32 155.56,90.59 155.67,90.71 156.93,90.71 157.05,90.82 157.05,91.09 156.93,91.2 155.67,91.2 155.56,91.32 155.56,91.58 155.67,91.7 156.8,91.7 157.32,92.22 U5602.6 158.08,92.19 U5604.6
PCH_SPI1_CLK_E1: length 78.3
  TOP w0.109: v2(191.85,27.15) 191.85,26.72 v1(191.7,26.58) 191.32,26.58 191.21,26.69 R4708.2 ; v1(164.89,72.7) 164.51,73.08 R5601.1
  BOTTOM w0.109: v1(164.89,72.7) 164.6,72.4 164.6,70.49 164.87,70.22 165.75,70.22 165.92,70.05 165.92,69.69 167.35,68.26 167.35,66.16 168.34,65.18 168.34,62.23 168.8,61.77 168.8,61.42 167.95,60.57 167.82,60.25 167.82,58.76 168.24,58.33 168.24,53.84 167.52,53.12 167.52,51.91 168.13,51.31 168.13,50.13 168.46,49.8 168.46,48.49 168.3,48.33 168.3,47.15 167.61,46.46 167.61,45.62 165.89,43.89 165.89,41.19 165.51,40.82 165.51,33.49 167.39,31.6 170.21,31.6 170.97,30.84 176.84,30.84 178.35,32.35 180.83,32.35 181.2,31.98 183.31,31.98 184.44,30.84 188.48,30.84 188.9,30.43 188.9,27.51 189.13,27.28 191.72,27.28 v2(191.85,27.15)

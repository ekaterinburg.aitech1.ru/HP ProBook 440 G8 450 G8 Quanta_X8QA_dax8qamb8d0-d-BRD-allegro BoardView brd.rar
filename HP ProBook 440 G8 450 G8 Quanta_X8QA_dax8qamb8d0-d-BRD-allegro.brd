# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BB_TCP0_RESET#: length 51.2
  TOP w0.109: v1(185.01,81.1) 184.81,80.9 183.57,80.9 182,82.47 180.39,82.47 180.26,82.6 179.05,82.6 v1(178.79,82.34) 178.39,81.94 172.6,81.94 170.04,84.5 168.75,84.5 167.91,85.35 167.73,85.35 167.56,85.52 v1(167.56,85.76) ; v2(188.38,93.49) 188.46,93.49 188.72,93.75 188.95,93.75 189.24,94.04 R5920.1 189.3,94.33 R5928.2
  IN1 w0.079: v1(185.01,81.1) 185.67,80.44 190.58,80.44 v2(190.94,80.8)
  IN2 w0.089: v2(188.38,93.49) 188.63,93.75 189.15,93.75 189.3,93.6 189.3,92.78 187.84,91.32 187.84,90.31 187.86,90.29 187.86,88.45 187.15,87.73 186.97,87.73 186.69,87.45 186.69,86.79 184.45,84.56 184.45,81.66 v1(185.01,81.1)
  BOTTOM w0.109: v1(167.56,85.76) 167.56,85.67 168.31,84.91 168.31,84.01 167.38,83.08 CON7701.15 ; v2(190.94,80.8) 191.31,81.17 191.31,81.56 191.41,81.66 U6100.30
BIOS_WP#: length 7.6
  TOP w0.109: R5633.2 200.13,27.46 199.79,27.12 199.29,27.12 199.13,27.28 199.13,27.69 198.85,27.97 R5632.1 198.6,27.73 198.42,27.56 197.48,27.56 197.43,27.61 v2(197.41,27.61)
  BOTTOM w0.109: v2(197.41,27.61) 197.41,27.24 198.02,26.64 U5603.3 U5605.3 198.93,26.64 199.21,26.92 200.02,26.92 TP5618.1
BIT_CLK: length 8.9
  BOTTOM w0.079: U400.DR38 143.31,69.72 143.56,69.72 143.68,69.85 145.15,69.85 145.39,69.6 146.76,69.6 147.24,69.13
  BOTTOM w0.109: R1575.1 150.39,69.09 148.71,69.09 148.54,69.26 148.26,69.26 147.96,68.96 R1500.1 147.48,68.88 147.24,69.13
BIT_CLK_AUDIO: length 89.8
  TOP w0.109: R3617.1 187.25,39.3 186.53,39.3 C1504.2 185.29,38.39 185.29,39.83 183.05,42.06 183.05,43.28 182.93,43.4 v1(182.93,43.93)
  IN3 w0.089: v1(182.93,43.93) 182.93,46.56 181.99,47.5 181.99,50.68 181.87,50.79 181.37,50.79 181.23,50.66 181.23,47.32 181.1,47.18 178.95,47.18 175.77,50.37 175.2,50.37 173.66,51.9 173.31,51.9 172.41,52.81 172.41,53.13 172.93,53.66 172.93,53.88 172.61,54.2 172.44,54.2 171.76,53.51 171.64,53.51 171.25,53.9 171.25,54.03 171.68,54.46 171.68,54.58 171.3,54.97 171.17,54.97 170.82,54.62 170.53,54.62 169.45,55.7 169.45,57.02 167.28,59.19 167.28,59.38 165.91,60.75 165.54,60.75 165.38,60.58 165.38,59.69 165.29,59.6 164.74,59.6 164.65,59.69 164.65,60.62 164.53,60.74 164.02,60.74 163.93,60.65 163.93,59.69 163.84,59.6 163.29,59.6 163.2,59.69 163.2,60.68 163.11,60.78 162.68,60.78 162.21,60.31 161.83,60.31 161.59,60.56 161.59,60.75 161.95,61.11 161.95,61.31 161.6,61.66 161.42,61.66 160.76,61 160.42,61 160.16,61.26 160.16,61.49 161.62,62.95 161.62,63.23 161.35,63.5 161.15,63.5 159.65,62 159.42,62 159.13,62.29 159.13,62.52 160.63,64.02 160.63,64.25 160.25,64.63 160,64.63 159.09,63.71 158.88,63.71 158.6,63.99 158.6,64.25 159.18,64.83 159.18,65.7 158.9,65.98 158.23,65.98 158.07,65.83 158.07,65.47 157.88,65.28 157.5,65.28 157.31,65.47 157.31,66.16 157.21,66.26 156.66,66.26 156.57,66.17 156.57,65.42 156.49,65.34 155.9,65.34 155.81,65.44 155.81,66.17 155.72,66.25 155.18,66.25 155.08,66.15 155.08,65.44 154.99,65.35 154.39,65.35 154.3,65.44 154.3,67.73 154.25,67.78 153.69,67.78 153.57,67.66 153.57,67.34 153.36,67.13 152.97,67.13 152.81,67.28 152.81,67.69 152.73,67.78 150.4,67.78 149.89,68.29 149.54,68.29 149.12,68.7 v2(149.12,68.7)
  BOTTOM w0.109: v2(149.12,68.7) 148.94,68.88 R1500.2
BIT_CLK_AUDIO_L: length 4.8
  TOP w0.109: U3600.5 191.9,38.12 191.88,38.14 191.23,38.14 C3623.2 190.13,38.38 188.78,38.38 188.53,38.63 R3617.2
BK_DIGITAL_CLK: length 6.3
  TOP w0.109: v1(141.96,61.08) 140.89,60.02 R1546.2
  IN1 w0.079: v1(141.96,61.08) 141.96,63.34 141.07,64.23 v2(141.06,64.23)
  BOTTOM w0.109: U400.DL49 141.06,64.3 v2(141.06,64.23)
BK_DIGITAL_D1: length 7.9
  BOTTOM w0.079: U400.DG50 139.74,64.02 139.74,63.32 139.83,63.23 139.83,62.4 139.96,62.27 139.96,60.85 140.07,60.74
  BOTTOM w0.109: 140.07,60.74 142.6,58.21 TP1500.1
BLON_CON: length 37.1
  TOP w0.109: v1(27.68,48.18) 25.55,48.18 25.52,48.21 v1(25.12,48.21) 25.12,47.92 Q3403.3 24.64,49.05 R3402.1
  IN3 w0.089: v1(27.68,48.18) 27.91,47.96 27.91,42.82 26.71,41.61 24.83,41.61 23.89,40.68 23.89,35.41 23.67,35.18 23.67,31.27 25.3,29.63 25.3,28.74 v1(26.56,27.49)
  BOTTOM w0.109: v1(27.68,48.18) 27.99,47.88 27.99,46.13 27.37,45.51 27.37,44.55 27.67,44.25 CON3400.38 ; v1(26.56,27.49) 26.83,27.75 CON3400.5
BOARD_ID1: length 11
  TOP w0.109: v2(141.87,73.2) 142.25,73.58 142.72,73.58 142.72,73.57 143.27,73.02 144.81,73.02 145.44,72.39 146.07,72.39 146.28,72.59 147.74,72.59 147.96,72.81 R1201.2 148.47,72.81 148.56,72.72 149.4,72.72 149.48,72.8 R1202.1
  BOTTOM w0.109: v2(141.87,73.2) 141.83,73.16 141.83,72.54 142.03,72.34 142.52,72.34 142.82,72.04 U400.DR32
BOARD_ID2: length 8.6
  TOP w0.109: v2(142.86,72.84) 142.86,72.84 142.86,72.84 143.03,72.67 144.31,72.67 145.49,71.49 147.2,71.49 147.62,71.91 148.94,71.91 149.22,72.18 R1203.2 149.58,72.36 R1204.1
  BOTTOM w0.109: v2(142.86,72.84) 142.86,72.84 142.86,72.84 143,72.69 U400.DT31
BOARD_ID3: length 9.4
  TOP w0.109: R1206.1 148.5,73.35 R1205.2 147.66,72.9 146.56,72.9 146.2,73.25 143.36,73.25 142.81,73.8 141.12,73.8 v2(140.74,74.18)
  BOTTOM w0.109: U400.DK29 140.87,74.05 v2(140.74,74.18)
BOARD_ID4: length 9
  TOP w0.109: v2(142.38,74.23) 142.38,74.23 142.44,74.17 142.77,74.17 143.46,73.48 146.56,73.48 147.15,74.08 148.51,74.08 148.71,74.28 149.07,74.28 149.22,74.13 R1211.2 149.5,73.81 149.58,73.89 R1212.1
  BOTTOM w0.109: U400.DN29 142.17,74.03 v2(142.38,74.23)
BQACDET: length 6.7
  TOP w0.178: PU8200.6 56.68,8.98
  TOP w0.203: 56.68,8.98 56.49,9.16 PR8232.2 56.44,9.5 v1(56.44,10.01) 56.59,10.16 PR8217.1 56.59,10.95 56.34,11.2 PR8213.2
  BOTTOM w0.254: PD8207.1 55.18,9.3 PC8213.1 56.77,9.65 56.44,9.98 v1(56.44,10.01)
BQACDRV: length 1.7
  TOP w0.178: 57.48,8.86 PU8200.4
  TOP w0.203: 57.48,8.86 57.48,8.86 58.09,9.47 TP8200.1
BQACN: length 2.8
  TOP w0.178: PU8200.1 58.68,8.72
  TOP w0.203: PR8206.2 59.68,9.63 PR8209.1 59.1,9.14 58.68,8.72
BQACP: length 2.2
  TOP w0.178: 58.28,8.77 PU8200.2
  TOP w0.203: PR8205.2 59.23,9.72 58.28,8.77
BQBATDRV: length 1.6
  TOP w0.178: 57.48,3.73 PU8200.18
  TOP w0.203: TP8202.1 57.48,2.87 57.48,3.73
BQBATPRES: length 3.8
  TOP w0.178: 56.28,3.78 PU8200.15
  TOP w0.203: 56.28,3.78 56.28,3.57 55.47,2.76 PR8228.2 55.47,2.23 v1(55.14,1.9) 54.79,1.9 PR8226.2
BQBATSRC: length 15.9
  TOP w0.178: 57.08,3.76 PU8200.17
  TOP w0.203: 57.08,3.76 57.08,2.48 57.44,2.12 67.76,2.12 68.91,3.27 PR8227.1
BQBTST: length 3.7
  TOP w0.178: PU8200.25 59.92,6.3 59.97,6.25 60.14,6.25
  TOP w0.254: PR8212.2 61.9,4.89 61.34,5.46 61.34,5.84 v1(61.16,6.02) 60.93,6.25 60.14,6.25
BQCMPIN: length 6.2
  TOP w0.109: v1(50.67,8.2) 50.67,7.77 PR8243.1
  TOP w0.178: PU8200.13 54.94,5.5
  TOP w0.203: 54.94,5.5 54.31,5.5 54.3,5.51 PR8241.1 54,5.51 53.41,6.09 PC8227.2 52.86,6.09 52.38,6.58 52.2,6.58 PR8240.2 51.53,7.06 51.08,7.51 PR8243.1
BQCMPOUT: length 3.9
  TOP w0.109: PR8242.1 51.72,4.95 v1(51.64,5.03)
  TOP w0.178: PU8200.14 54.96,5.1
  TOP w0.203: 54.96,5.1 54.6,5.1 54.56,5.06 PR8241.2 53.95,5.06 53.84,4.95 PR8239.1 PR8242.1
BQCMSRC: length 4.3
  TOP w0.178: 57.88,8.81 PU8200.3
  TOP w0.203: PR8210.1 58.17,11.86 58.17,11.15 58.04,11.03 58.04,10.44 58.57,9.91 58.57,9.51 57.88,8.81 57.88,8.81
BQHIDRV: length 0.9
  TOP w0.178: v1(60.32,6.75) 60.27,6.7 PU8200.26
  vias: v1(60.32,8.84)
BQIADP: length 4.7
  TOP w0.178: 56.28,8.78 PU8200.7
  TOP w0.203: 56.28,8.78 PC8223.1 54.73,10.33 54.73,11.53 55.12,11.91 PR8233.2
BQIDCHG: length 6.3
  TOP w0.178: PU8200.8 55.11,7.5 54.96,7.64
  TOP w0.203: 54.96,7.64 54.96,7.95 55.29,8.28 55.29,8.68 54.28,9.69 PC8224.1 53.74,10.17 53.74,11 v1(53.52,11.22) 53.52,11.25 54.18,11.91 PR8234.2
BQILIM: length 6.8
  TOP w0.178: v1(58.77,3.4) 58.75,3.42 58.75,3.43 58.68,3.5 PU8200.21
  BOTTOM w0.203: v1(58.77,3.4) 58.75,3.42 58.75,3.43 58.44,3.74 PR8235.1 56.89,3.33 56.51,3.33 v1(56.31,3.12) 54.98,3.12 PQ8205.3
BQLODRV: length 6.2
  TOP w0.178: PU8200.23 60.23,5.5 v1(60.3,5.43)
  IN1 w0.635: v1(60.3,5.43) 59.61,6.12 59.61,7.03 61.29,8.71 v3(62.38,8.71)
BQPHASE: length 9
  TOP w0.178: v1(61.01,6.75) 60.53,7.24 60.12,7.24 59.98,7.1 PU8200.27
  IN1 w0.635: v1(66.52,5.75) 64.96,5.75 64.21,5 61.67,5 61.01,5.66 v1(61.01,6.75)
  vias: v1(66.55,6.73)
BQPMON: length 3
  TOP w0.178: v1(54.42,7.72) 54.42,7.69 55.02,7.1 PU8200.9
  TOP w0.203: v1(54.42,7.72) 54.42,7.88 53.95,8.36 PR8237.1 PR8236.1
BQPROCHOT: length 2.2
  TOP w0.178: 54.96,6.7 PU8200.10
  TOP w0.203: PR8225.2 53.77,7.72 54.28,7.2 54.45,7.2 54.95,6.7 54.96,6.7 54.96,6.7
BQSCL: length 3.5
  TOP w0.178: 54.92,5.9 PU8200.12
  TOP w0.203: 54.92,5.9 54.06,5.9 53.38,6.58 52.94,6.58 PR8224.1
BQSDA: length 1.2
  TOP w0.178: PR8223.1 54.76,6.33 54.79,6.3 PU8200.11
BQSRN: length 16.5
  TOP w0.178: 57.88,3.76 PU8200.19
  TOP w0.203: 57.88,3.76 57.88,3.18 58.62,2.44 67.44,2.44 69.85,4.86 69.85,6 PR8231.1
BQSRP: length 15.4
  TOP w0.178: 58.28,3.81 PU8200.20
  TOP w0.203: PR8229.1 69.53,6.21 69.53,4.99 67.31,2.76 58.75,2.76 58.28,3.23 58.28,3.81
BQTB_STAT: length 1.6
  TOP w0.178: 56.68,3.78 PU8200.16
  TOP w0.203: 56.68,3.78 56.68,3.26 TP8201.1
BQVCC: length 5
  TOP w0.178: PU8200.28 59.85,7.5 59.99,7.64
  TOP w0.254: PR8211.2 61.68,10.42 61.78,10.32 PC8211.1 61.78,9.43 59.99,7.64
BT_OFF: length 84.5
  TOP w0.109: v1(183.92,82.67) 183.84,82.76 R4156.1 183.84,83.51 184.05,83.72 184.2,83.72 184.4,83.92 R4152.1
  IN1 w0.079: v1(187.2,68.16) 187.17,68.18 186.76,68.18 186.43,67.85 185.81,67.85 179.3,61.34 179.3,60.4 177.49,58.59 176.13,58.59 175.88,58.34 174.75,58.34 174.19,57.78 173.38,57.78 172.78,57.18 172.29,57.18 172.08,56.97 171.46,56.97 171.04,57.4 170.47,57.4 169.04,55.96 165.66,55.96 165.01,56.61 162.42,56.61 v1(162.15,56.33)
  IN2 w0.089: v1(187.2,68.16) 188.06,69.02 188.06,71.81 187.08,72.78 187.08,75.45 186.51,76.02 186.51,77.16 183.49,80.19 183.49,82.24 v1(183.92,82.67)
  IN3 w0.089: v2(139.34,65.07) 139.34,64.22 140.73,62.83 147.75,62.83 148.63,61.95 148.63,58.56 151.19,56 154.44,56 156.05,57.61 158.35,57.61 158.62,57.89 160.44,57.89 161.09,58.54 161.39,58.54 161.75,58.19 161.75,57.86 160.91,57.02 160.91,56.64 161.42,56.13 161.94,56.13 v1(162.15,56.33)
  BOTTOM w0.109: U400.DH49 140.1,64.59 139.61,65.07 v2(139.34,65.07)
BXTALOUT: length 10.4
  TOP w0.109: R6804.1 70.46,92.97 R6806.1 70.46,91.87 70.7,91.63 71.88,91.63 73.15,90.36 73.42,90.36 v1(73.72,90.07)
  BOTTOM w0.109: v1(73.72,90.07) 73.38,89.74 72.69,89.74 71.82,88.87 71.82,88.47 71.57,88.21 71.57,86.81 U6600.C10
C_TX0_HDMI+: length 5.5
  TOP w0.109: C3521.1 196.16,53.66 196.34,53.66 196.52,53.83 196.52,55.04 197.03,55.55 197.03,56.37 197.55,56.88 198.13,56.88 198.22,56.97 U3501.6
C_TX0_HDMI-: length 5.5
  TOP w0.109: U3501.7 198.21,56.57 198.12,56.66 197.64,56.66 197.25,56.27 197.25,55.46 196.74,54.95 196.74,53.74 196.43,53.43 196.16,53.43 C3522.1
C_TX1_HDMI+: length 4.4
  TOP w0.109: U3501.4 198.21,57.77 198.12,57.68 197.26,57.68 196.4,56.82 196.4,55.8 196.25,55.66 196.16,55.66 C3507.1
C_TX1_HDMI-: length 4.4
  TOP w0.109: C3508.1 196.16,55.43 196.35,55.43 196.62,55.71 196.62,56.72 197.36,57.46 198.14,57.46 198.23,57.37 U3501.5
C_TX2_HDMI+: length 3.5
  TOP w0.109: C3505.1 196.13,57.67 196.34,57.67 197.56,58.88 198.13,58.88 198.21,58.97 U3501.1
C_TX2_HDMI-: length 3.5
  TOP w0.109: C3506.1 196.14,57.44 196.43,57.44 197.65,58.66 198.13,58.66 198.22,58.57 U3501.2
C_TXC_HDMI+: length 6.1
  TOP w0.109: U3501.9 198.23,55.77 198.14,55.68 197.95,55.68 197.33,55.06 197.33,53.32 196.45,52.44 196.45,51.75 196.32,51.62 196.16,51.62 C3523.1
C_TXC_HDMI-: length 6.1
  TOP w0.109: C3524.1 196.16,51.4 196.41,51.4 196.67,51.66 196.67,52.35 197.55,53.23 197.55,54.97 198.04,55.46 198.13,55.46 198.22,55.37 U3501.10
CABLE_SIZE_DET: length 205.3
  TOP w0.109: v2(147.84,79.52) 147.84,79.34 148.16,79.02 149.1,79.02 149.27,79.19 R1139.1 R1138.2
  IN2 w0.089: v2(147.84,79.52) 147.84,79.38 151.17,76.05 153.32,76.05 153.94,75.43 153.94,74.13 154.14,73.93 154.14,73.5 153.9,73.25 153.8,73.25 152.75,72.2 152.75,71.63 152.14,71.02 151.57,71.02 150.85,70.3 150.85,68.12 151.36,67.61 151.36,65.54 151.96,64.94 151.96,64.63 149.16,61.83 149.16,58.72 149.58,58.3 149.58,58.03 151.18,56.44 152.16,56.44 155.48,53.12 155.95,53.12 158.2,50.87 158.2,48.5 159.25,47.45 159.25,47.06 159.5,46.82 160.2,46.82 161.63,45.39 161.63,44.44 161.94,44.12 162.76,44.12 v1(162.83,44.05)
  BOTTOM w0.109: CON3400.11 29.85,30.75 30.08,30.97 30.41,30.97 30.74,31.3 34.07,31.3 34.39,30.97 35.58,30.97 36.94,29.61 37.4,29.61 39.23,31.44 102.59,31.44 103.47,30.56 119.72,30.56 124.26,35.1 159.18,35.1 161.39,37.31 161.39,39.56 161.89,40.07 162.31,40.07 163.6,41.36 163.6,43.29 v1(162.83,44.05) ; U400.DN13 142.94,80.26 146.15,80.26 147.06,79.35 147.52,79.35 147.7,79.52 v2(147.84,79.52)
CAMERA_ON: length 231.6
  TOP w0.109: U3402.3 22.87,56.45 23.25,56.07 v1(23.92,56.07)
  IN2 w0.089: v1(155.6,54.13) 155.6,53.72 158.38,50.94 158.38,49.48 159.06,48.8 159.06,47.9 159.43,47.52 159.43,47.14 159.57,46.99 160.28,46.99 161.8,45.46 161.8,45.04 v1(162.33,44.51) ; v1(32.09,45.77) 30.79,44.47 v1(25.22,44.47) 25.22,43.63 25.4,43.46 27.58,43.46 28.62,42.42 28.62,30.26 v1(29.4,29.48)
  IN3 w0.089: v1(23.92,56.07) 24.57,55.42 24.57,48.57 25.82,47.32 25.82,46.32 25.22,45.72 v1(25.22,44.47)
  BOTTOM w0.079: 137.95,61.67 137.95,61.86 137.3,62.51 137.3,63.59 136.89,64 U400.DA50
  BOTTOM w0.109: v1(155.6,54.13) 155.34,53.87 154.15,53.87 153.22,54.81 149.99,54.81 149.55,55.24 147.9,55.24 147.46,54.81 143.93,54.81 143.49,54.36 141.44,54.36 138.48,57.33 138.48,58.52 138.33,58.67 R810.1 138.49,59.06 138.49,60.46 137.95,61.01 137.95,61.67 ; CON3400.9 29.13,29.75 v1(29.4,29.48) ; v1(32.09,45.77) 32.57,46.25 34.31,46.25 35.2,45.35 35.2,41.88 35.56,41.52 35.56,37.49 36.86,36.2 36.86,34.18 38.68,32.36 102.91,32.36 103.84,31.43 119.3,31.43 124.39,36.52 158.28,36.52 159.83,38.06 159.83,39.1 159.97,39.24 159.97,40.15 160.36,40.54 160.77,40.54 162.25,42.02 162.25,42.64 161.83,43.06 161.83,44.01 v1(162.33,44.51)
CAMERA_WP#: length 202.7
  TOP w0.076: U4700.E8 v2(194.14,18.94)
  TOP w0.109: v1(35.39,32.6) 35.15,32.83 35.15,34.41 35.01,34.56 34.37,34.56 34.15,34.77 34.15,35.16 34.73,35.74 34.73,36.41 33.39,37.76 32.46,37.76 32.24,37.54 v1(32,37.54) 31.75,37.54 31.53,37.76 30.54,37.76 30.11,37.33 29.35,37.33 28.39,38.28 R3413.2 ; v1(170.87,45.21) 171.09,44.99 R4743.2
  IN1 w0.079: v1(170.87,45.21) 170.38,44.73 169.72,44.73 168.98,43.98 164.77,43.98 163.45,42.67 v1(163.02,42.67)
  IN2 w0.089: v2(194.14,18.94) 194.49,19.29 194.49,20.82 193.85,21.46 193.34,21.46 193.19,21.61 192.3,21.61 192.05,21.36 190.74,21.36 190.58,21.52 190.58,22.16 188.88,23.86 188.88,24.31 188.2,24.99 187.84,25.14 187.6,25.37 187,25.37 185.9,26.47 184.56,29.71 184.56,30.94 181.89,33.61 181.89,34.27 181.13,35.02 180.53,35.02 180.17,35.39 180.17,36.07 180.26,36.16 180.26,37.07 178.91,38.42 176.7,38.42 176.51,38.6 176.51,43.77 174.9,45.38 172.28,45.38 171.38,46.27 170.91,46.27 170.66,46.02 170.66,45.42 v1(170.87,45.21)
  BOTTOM w0.109: v1(163.02,42.67) 163.02,42.14 162.33,41.45 162.33,40.57 162.05,40.3 161.8,40.3 161.16,39.66 161.16,37.4 159.36,35.6 124.44,35.6 119.62,30.78 103.56,30.78 102.67,31.67 36.79,31.67 35.86,32.6 v1(35.39,32.6)
CAMERA_WP#_LCD: length 2.2
  TOP w0.109: v1(27.13,38.25) 27.16,38.28 R3413.1
  BOTTOM w0.109: v1(27.13,38.25) 27.13,38.07 27.45,37.75 CON3400.25
CAPS_LED#: length 151.2
  TOP w0.109: R4745.2 180.03,58.54 v1(180.13,58.65) 179.73,59.05 R4738.1 179.57,59.26 179.35,59.48 178.33,59.48 178.23,59.38 U4701.4 ; v1(126.71,7.86) 126.71,8.07 125.53,9.24 C5029.2 125.52,9.38 R5011.1
  IN2 w0.089: v1(182.33,50.99) 181.37,51.95 181.37,53.17 180.03,54.51 180.03,58.54 v1(180.13,58.65)
  IN3 w0.089: v1(175.18,43.03) 175.43,42.77 175.53,42.77 176.63,41.67 176.63,38.37 177.41,37.59 178.61,37.59 179.28,36.92 179.28,36.71 179.79,36.2 179.79,33.91 180.62,33.08 181.86,33.08 183.85,31.09 183.85,29.06 184.95,27.42 185.3,26.58 187.12,24.75 187.92,24.75 188.32,24.59 189.35,23.56 189.69,23.56 190.17,23.36 190.82,22.71 191.23,22.71 191.39,22.86 193.22,22.86 193.37,22.7 193.37,22.2 194.01,21.57 196.99,21.57 198.73,19.83 198.73,18.39 199.69,17.42 199.69,15.9 199.11,15.31 197,15.31 196.66,14.97 196.19,14.78 195.22,14.38 193.58,14.38 193.23,14.74 192.14,14.74 191.54,15.33 190.79,15.33 190.61,15.26 190.45,15.1 190.45,14.59 189.64,13.78 188.83,13.78 188.34,14.27 186.76,14.27 186.18,13.69 184.02,13.69 183.14,12.81 183.14,11.51 182.55,10.92 181.73,10.92 180.32,9.5 180.32,8.87 179.91,8.46 179.35,8.46 178.23,7.34 172.26,7.34 172.11,7.19 171.22,7.19 169.86,8.55 165.52,8.55 165.04,9.03 162.55,9.03 162.36,9.21 161.71,9.21 161.08,9.08 160.79,8.96 160.28,8.45 159.53,8.45 159.22,8.14 151.71,8.14 151.3,8.56 148.19,8.56 148.11,8.48 146.89,8.48 146.68,8.69 145.32,8.69 145.2,8.56 144.15,8.56 144.01,8.41 143.39,8.41 142.95,7.98 140.01,7.98 139.86,8.12 136.78,8.12 135.97,7.31 133.42,7.31 132.73,8 130.46,8 130,7.54 127.03,7.54 v1(126.71,7.86)
  BOTTOM w0.109: v1(182.33,50.99) 182.33,50.78 180.13,48.59 179.44,48.59 177.39,46.54 177.39,45.38 175.18,43.17 v1(175.18,43.03)
CCG5_HOTPLUG_DET_P1_C: length 28.8
  IN3 w0.089: v1(195.48,70.04) 195.79,70.36 198.45,70.36 200.68,72.59 200.68,75.37 201.27,75.96 201.27,76.78 201.06,77 199.92,77 199.65,77.27 195.71,77.27 195.19,77.79 194.1,77.79 192.23,79.66 192.23,80.8 v2(192.77,81.34)
  BOTTOM w0.102: R6101.1 192.77,80.93 v2(192.77,81.34) 192.61,81.5 U6100.27
  BOTTOM w0.109: R6115.2 193.03,69.12 v1(193.22,69.12) 194.23,69.12 195.15,70.04 v1(195.48,70.04) 195.48,69.63 Q6100.3
CCG5_SWD_CLK: length 99.7
  IN1 w0.079: v1(213.1,22.98) 213.1,23.42 210.7,25.82 208.24,25.82 208.02,25.6 206.43,25.6 204.64,27.39 204.36,27.39 203.38,28.38 202.56,28.38 200.59,30.34 198.27,30.34 197.38,30.72 196.95,30.72 196.87,30.8 194.39,30.8 193.61,31.58 193.2,31.58 192.05,32.73 192.05,34.87 190.99,35.93 190.99,40.9 191.55,41.46 191.55,43.67 191.79,43.91 191.79,44.4 v1(191.41,44.78) ; v1(204.14,59.46) 203.38,60.22 203.38,61.21 203.17,61.41 203.17,62.44 201.47,64.15 201.47,68.8 201.08,69.19 201.08,70.66 201.6,71.17 201.6,73.35 v1(201.39,73.56)
  IN2 w0.089: v1(204.14,59.46) 204.14,58.32 203.26,57.44 203.26,53.35 202.23,52.32 201.06,52.32 200.28,51.54 200.28,48.97 196.53,45.22 192.16,45.22 191.72,44.78 v1(191.41,44.78)
  IN3 w0.089: v1(201.39,73.56) 201.03,73.92 201.03,74.34 200.88,74.49 200.88,75.21 201.45,75.78 201.45,76.86 201.13,77.18 199.99,77.18 199.72,77.45 198.6,77.45 196.54,79.5 196.54,82.22 194.77,84 194.77,86.36 195.06,86.65 v2(195.16,86.65)
  BOTTOM w0.109: R6100.2 R6105.1 195.25,86.56 v2(195.16,86.65) 195.12,86.69 U6100.15 ; v1(213.1,22.98) 212.84,22.72 CON7702.26
CCG5_SWD_IO: length 103.8
  IN1 w0.079: v1(213.1,22.22) 212.72,22.6 212.72,23.55 210.61,25.66 208.31,25.66 208.07,25.42 206.38,25.42 204.56,27.23 204.3,27.23 203.31,28.22 202.49,28.22 200.52,30.19 198.24,30.19 197.34,30.56 196.89,30.56 196.8,30.64 194.32,30.64 193.54,31.42 193.13,31.42 191.89,32.66 191.89,34.8 190.84,35.86 190.84,40.98 191.39,41.53 191.39,44.12 191.41,44.14 v1(191.41,44.14) ; v1(204.26,60.12) 203.89,60.5 203.89,60.94 203.35,61.47 203.35,62.49 201.63,64.21 201.63,68.87 201.24,69.26 201.24,70.58 201.8,71.14 201.8,73.89 v1(201.47,74.22)
  IN2 w0.089: v1(204.26,60.12) 204.65,59.74 204.65,58.57 203.44,57.37 203.44,53.28 202.31,52.14 201.14,52.14 200.46,51.46 200.46,48.89 196.6,45.04 192.31,45.04 v1(191.41,44.14)
  IN3 w0.089: v2(195.16,87.2) 195.17,87.2 195.63,86.74 195.63,83.94 196.72,82.85 196.72,79.57 198.67,77.62 199.8,77.62 200.06,77.35 201.21,77.35 201.63,76.93 201.63,75.71 201.06,75.14 201.06,74.63 v1(201.47,74.22)
  BOTTOM w0.109: U6100.14 195.05,87.09 v2(195.16,87.2) 195.48,87.52 195.53,87.63 195.53,87.93 195.27,88.19 194.43,88.19 194.26,88.36 194.26,89.63 194.71,90.09 R6102.1 ; v1(213.1,22.22) CON7702.25
CCG5_VBUS_C_CTRL_P1: length 20.6
  IN3 w0.089: v1(195.08,76.83) 194.8,76.83 192.88,78.76 192.48,78.76 191.41,79.83 188.77,79.83 187.78,80.82 187.78,81.96 188.03,82.22 188.03,86.36 v2(187.07,87.32)
  BOTTOM w0.109: v2(187.07,87.32) 187.25,87.32 187.48,87.09 U6100.47 ; PR8002.2 196.64,77.54 v1(196.44,77.34) 196.26,77.16 PD8002.1 195.77,76.15 v1(195.08,76.83)
CCG5_XRES: length 101.5
  TOP w0.109: v2(189.66,81.34) 189.81,81.5 C6106.2
  IN1 w0.079: v1(204.26,60.86) 204.65,60.48 204.65,59.44 203.07,57.87 203.07,54.33 202.44,53.69 202.26,53.69 200.58,52.02 200.58,51 201.37,50.21 201.37,46.58 201.12,46.34 200.78,46.34 200.5,46.61 195.33,46.61 192.02,43.3 192.02,41.43 192.35,41.1 192.35,39.01 192.52,38.84 192.52,32.92 193.4,32.05 193.8,32.05 194.58,31.27 197.07,31.27 197.15,31.19 198.02,31.19 198.24,31.41 198.55,31.41 199.14,30.82 200.79,30.82 202.75,28.85 203.57,28.85 204.55,27.88 204.84,27.88 206.58,26.13 207.87,26.13 208.03,26.29 210.9,26.29 212.5,24.69 v1(212.99,24.69)
  IN2 w0.089: v2(189.66,81.34) 190.03,81.71 193.47,81.71 194.64,80.54 194.64,79.88 194.23,79.47 194.23,78.53 195.76,77.01 195.76,75.92 196.31,75.36 196.31,74.88 197.51,73.68 197.51,70.94 198.16,70.29 198.16,66.43 199.21,65.38 199.21,63.35 199.82,62.74 201.15,62.74 201.62,62.26 202.86,62.26 v1(204.26,60.86)
  BOTTOM w0.102: 189.81,81.72 189.81,81.47 189.68,81.34 v2(189.66,81.34) 189.28,80.96 189.28,80.59 189.43,80.44 191.16,80.44 191.61,80.89 R6106.2
  BOTTOM w0.109: v1(212.99,24.69) 212.99,24.6 211.62,23.22 CON7702.27 ; U6100.34 189.81,81.72
CCG6_BB_RT_A_EN: length 52.2
  TOP w0.109: R5948.1 172.85,105.48 v1(173,105.33) 173.12,105.21 U5904.B2
  IN1 w0.079: v2(190.94,81.34) 191.56,80.72 194.77,80.72 195.5,81.45 195.5,85.21 195.66,85.38 195.66,87.28 196.42,88.03 197.42,88.03 v2(198.53,89.14)
  IN3 w0.089: v2(198.53,89.14) 198.5,89.16 198.5,92.6 196.48,94.62 195.09,94.62 194.89,94.83 194.89,96.11 193.69,97.31 190.75,97.31 188.9,99.16 186.76,99.16 185.59,100.33 181.31,100.33 178.06,103.58 176.71,103.58 176.63,103.66 175.31,103.66 173.86,105.1 173.23,105.1 v1(173,105.33)
  BOTTOM w0.102: v2(190.94,81.34) 191.01,81.41 U6100.31
CCG6_SBU1_A: length 46.6
  IN1 w0.079: v2(187.07,84.4) 187.42,84.05 187.42,83.71 186.96,83.26 186.25,83.26 184.62,84.89 184.62,87.74 183.8,88.55 183.8,89.27 184.15,89.62 184.97,89.62 185.17,89.83 186.36,89.83 186.76,90.23 191.16,90.23 191.43,90.5 192.28,90.5 193.09,91.31 193.37,91.31 193.56,91.51 193.56,91.58 v2(193.35,91.8) 193.6,92.04 193.6,92.25 193.6,92.31 194.39,93.11 194.39,93.84 195,94.45 195.42,94.45 196.02,95.05 197.84,95.05 198.01,95.13 198.65,95.76 198.65,97.26 199.16,97.77 199.16,99.79 195.6,103.35 192.32,103.35 191.77,103.9 191.77,104.07 v1(191.47,104.37)
  BOTTOM w0.102: U6100.41 187.61,84.69 187.32,84.4 v2(187.07,84.4)
  BOTTOM w0.109: v1(191.47,104.37) 191.73,104.1 191.73,103.9 191.58,103.75 R5909.1 ; v2(193.35,91.8) 193.63,91.52 193.63,91.42 193.89,91.16 194.27,91.16 194.81,91.7 195.22,91.7 R6122.1
CCG6_SBU1_A_M: length 2.7
  BOTTOM w0.109: U6101.1 197.55,93.03 197.41,92.89 197.41,92.5 197.01,92.1 196.49,92.1 R6122.2
CCG6_SBU1_R_A: length 8.1
  BOTTOM w0.109: R5909.2 191.48,102.97 arc(191.57,102.96) 191.65,102.94 191.65,102.94 arc(191.79,102.85) 191.87,102.71 191.89,102.63 arc(191.89,102.62) 191.89,102.6 arc(191.89,102.59) 191.89,102.58 arc(191.87,102.47) 191.8,102.38 R5914.1 191.76,101.81 arc(191.79,101.76) 191.8,101.71 191.8,101.67 arc(191.79,101.63) 191.77,101.6 191.75,101.58 arc(191.71,101.56) 191.67,101.55 191.5,101.55 arc(191.31,101.51) 191.16,101.4 190.56,100.81 arc(190.02,100.45) 189.39,100.32 189.34,100.32 arc(189.02,100.26) 188.75,100.08 188.44,99.77 arc(188.4,99.73) 188.35,99.7 arc(188.29,99.68) 188.23,99.65 arc(188.18,99.64) 188.12,99.64 188.06,99.64 arc(187.59,99.55) 187.19,99.29 arc(187.18,99.28) 187.17,99.27 186.99,99.09 arc(186.91,98.96) 186.88,98.8 U5900.M10
CCG6_SBU2_A: length 45
  IN1 w0.079: v1(192.23,104.37) 191.94,104.08 191.94,103.97 192.39,103.52 195.67,103.52 199.33,99.86 199.33,97.7 198.82,97.19 198.82,95.69 198.11,94.98 197.87,94.89 196.09,94.89 195.49,94.28 195.07,94.28 194.56,93.77 194.56,93.04 193.76,92.24 193.76,92.18 193.76,92.18 193.76,92.04 v2(194.01,91.79) 193.73,91.51 193.73,91.44 193.44,91.14 193.16,91.14 192.35,90.33 191.5,90.33 191.23,90.06 186.83,90.06 186.43,89.66 185.24,89.66 185.04,89.46 184.22,89.46 183.97,89.2 183.97,88.62 184.78,87.81 184.78,84.96 186.32,83.42 186.9,83.42 187.07,83.6 v2(187.07,83.85)
  BOTTOM w0.102: U6100.40 187.51,84.29 v2(187.07,83.85)
  BOTTOM w0.109: R6123.1 195.15,91.92 194.72,91.92 194.18,91.38 193.98,91.38 193.85,91.51 193.85,91.63 v2(194.01,91.79) ; R5910.1 192.08,103.74 191.96,103.86 191.96,104.1 v1(192.23,104.37)
CCG6_SBU2_A_M: length 2.2
  BOTTOM w0.109: R6123.2 196.27,92.2 196.4,92.33 196.91,92.33 197.18,92.6 197.18,92.88 197.05,93.01 U6101.2
CCG6_SBU2_R_A: length 8.1
  BOTTOM w0.109: U5900.L10 187,98.28 arc(187.07,98.39) 187.1,98.53 187.1,98.72 arc(187.13,98.87) 187.22,99 187.35,99.13 arc(187.45,99.21) 187.56,99.29 arc(187.8,99.38) 188.06,99.41 188.12,99.41 arc(188.21,99.42) 188.3,99.44 arc(188.38,99.47) 188.45,99.5 arc(188.53,99.55) 188.6,99.61 188.91,99.92 arc(189.11,100.05) 189.34,100.1 189.39,100.1 arc(190.11,100.24) 190.72,100.65 191.31,101.25 arc(191.4,101.3) 191.5,101.32 191.67,101.32 arc(191.8,101.35) 191.91,101.42 191.92,101.44 arc(192,101.55) 192.02,101.67 192.02,101.85 arc(192.05,101.97) R5913.1 192.12,102.58 arc(192.12,102.6) 192.11,102.61 192.12,102.61 arc(192.14,102.73) 192.2,102.82 R5910.2
CFG0: length 88.3
  TOP w0.109: v1(57.54,49.96) 57.16,49.58 v1(57.02,49.58) 55.8,49.58 55.6,49.39 55.6,44.15 52.42,40.97 50.14,40.97 49.89,41.22 R7703.2 CON7703.9
  IN2 w0.089: v1(57.54,49.96) 57.59,49.96 58.43,49.12 66.64,49.12 70.88,53.36 71.71,53.36 76.06,57.71 77,57.71 81.86,62.58 81.86,63.08 84.02,65.24 84.02,66.02 86.2,68.2 86.71,68.2 87.04,68.52 87.04,69 87.41,69.37 88.81,69.37 91.13,71.69 91.13,76 92.6,77.47 v1(92.94,77.47) 93.53,77.47 96.26,80.2 96.26,81.02 96.97,81.73 96.97,82.6 97.56,83.19 97.56,84.24 98.53,85.21 98.93,85.21 99.2,84.95 101.01,84.95 101.28,85.21 103.38,85.21 103.81,84.79 103.81,83.5 103.26,82.96 v2(103.21,82.96)
  BOTTOM w0.109: R1028.1 92.5,76.78 92.94,77.21 v1(92.94,77.47) ; v2(103.21,82.96) 102.72,83.45 U400.E7
CFG0_R: length 2.7
  BOTTOM w0.109: R1028.2 92.5,75.7 TP1031.1 92.12,75.31 R1030.1 92.12,74.27 92.03,74.17 R1012.2
CFG1: length 84.7
  TOP w0.109: CON7703.11 48.51,41.98 48.79,41.71 49.41,41.71 49.88,41.9 v1(50.54,42.56) 51.88,42.56 54.3,44.98 54.3,49.99 v1(54.46,50.15)
  IN2 w0.089: v1(99.13,83.08) 99.13,81.16 97.87,79.9 97.11,79.9 93.34,76.14 93.34,75 v1(92.91,74.57) 92.73,74.39 92.73,72.29 88.24,67.8 87.75,67.8 87.37,67.42 86.52,67.42 84.74,65.64 84.74,63.77 80.93,59.97 80.93,59.24 78.63,56.93 76.48,56.93 71.95,52.41 70.95,52.41 66.85,48.31 55.32,48.31 54.4,49.23 54.4,50.09 v1(54.46,50.15)
  BOTTOM w0.079: U400.D9 101.73,82.72 101.33,82.72 101.17,82.88 100.34,82.88 100.19,82.73 99.62,82.73
  BOTTOM w0.109: v1(92.91,74.57) 93.09,74.75 93.7,74.75 93.87,74.92 R1013.2 ; R1039.1 98.73,82.67 v1(99.13,83.08) 99.26,83.08 99.62,82.73
CFG2: length 83.5
  TOP w0.109: CON7703.15 51.9,42.98 53.76,44.84 v1(53.76,48.36) v1(53.76,49.32)
  IN2 w0.089: v1(53.76,49.32) 54.06,49.02 54.29,49.02 55.21,48.1 66.92,48.1 70.97,52.16 72.07,52.16 76.55,56.64 78.59,56.64 81.13,59.18 81.13,59.91 84.91,63.7 84.91,65.56 86.57,67.21 87.45,67.21 87.85,67.62 88.32,67.62 92.91,72.21 92.91,73.75 93.53,74.37 93.53,75.65 94.28,76.4 v1(94.45,76.4) 94.69,76.63 94.69,77.15 97.26,79.72 98.6,79.72 99.34,80.46 99.34,81.63 99.77,82.07 v1(99.77,83.13)
  BOTTOM w0.079: v1(99.77,83.13) 99.86,83.04 101.24,83.04 101.4,82.88 102.22,82.88 U400.E9
  BOTTOM w0.109: v1(99.77,83.13) 99.39,83.51 98.75,83.51 98.63,83.39 R1031.1 ; v1(94.45,76.4) 94.1,76.4 R1014.2
CFG3: length 85.4
  TOP w0.109: CON7703.17 48.62,43.48 48.89,43.21 49.89,43.21 50.36,43.68 50.36,44 50.97,44.61 52.64,44.61 52.98,44.96 v1(52.98,47.14) 52.98,49.32 v1(52.96,49.35) ; R1040.1 94.08,76.02 v1(94.54,75.56)
  IN2 w0.089: v2(103.21,84.56) 103.21,84.53 102.59,83.92 102.59,83.77 101.33,82.51 101.33,80.18 100.29,79.14 99.57,79.14 98.87,78.44 97.58,78.44 97.25,78.11 96.33,78.11 95.8,77.58 95.8,76.42 95.35,75.97 95.06,75.97 94.65,75.56 v1(94.54,75.56) 94.54,75.44 93.91,74.81 93.91,74.14 93.27,73.5 93.27,72.07 88.46,67.26 88.03,67.26 87.61,66.84 86.7,66.84 85.27,65.41 85.27,63.51 81.53,59.78 81.53,59.08 78.68,56.23 76.87,56.23 72.11,51.47 70.86,51.47 67.1,47.7 55.04,47.7 54.13,48.61 53.26,48.61 52.96,48.92 v1(52.96,49.35)
  BOTTOM w0.109: R1015.2 93.9,74.59 94.54,75.23 v1(94.54,75.56) ; U400.H5 103.43,84.34 v2(103.21,84.56)
CFG4: length 82
  TOP w0.109: v1(95.09,76.38) 95.27,76.38 95.77,75.88 R1034.1 ; CON7703.27 48.52,45.98 49.08,46.54 51.37,46.54 52.53,47.7 52.53,49.15 v1(52.3,49.38)
  IN2 w0.089: v1(52.3,49.38) 52.75,49.83 53.13,49.83 53.36,49.6 53.36,49.15 53.69,48.82 54.21,48.82 55.12,47.9 67.01,47.9 70.96,51.85 72.13,51.85 76.69,56.41 78.61,56.41 81.33,59.13 81.33,59.82 85.09,63.59 85.09,65.49 86.64,67.04 87.52,67.04 87.92,67.44 88.39,67.44 93.09,72.14 93.09,73.58 93.73,74.22 93.73,75.49 94.19,75.95 94.67,75.95 v1(95.09,76.38) 95.09,76.42 95.1,76.43 95.1,77.27 97.34,79.52 98.65,79.52 101.01,81.88 101.01,83.59 101.98,84.55 v2(102.48,84.55)
  BOTTOM w0.109: U400.E6 102.72,84.31 v2(102.48,84.55) ; v1(95.09,76.38) 94.7,75.98 94.27,75.98 94.18,75.89 R1016.2
CFG5: length 77.4
  TOP w0.109: v1(52.07,48.26) 52.07,47.9 50.94,46.77 48.99,46.77 48.7,46.48 CON7703.29 ; v1(94.35,73.46) 94.34,73.47 94.34,73.51 94.31,73.54 R1041.1
  IN2 w0.089: v1(52.07,48.26) 52.55,47.78 54.31,47.78 54.8,47.29 67.74,47.29 68.8,48.35 69.79,48.35 77.14,55.7 78.9,55.7 80.2,57 81.06,57 82.34,58.28 82.34,60.04 85.7,63.4 85.7,64.43 86.88,65.61 87.75,65.61 88.64,66.51 88.64,66.94 93.7,72 93.7,72.52 94.35,73.17 v1(94.35,73.46) 94.34,73.47 94.34,74.62 94.62,74.9 94.88,74.9 95.16,75.18 95.36,75.18 95.74,75.55 95.74,75.79 96.95,77 98.01,77 99.74,78.73 100.46,78.73 102.59,80.86 102.59,81.77 v2(103.21,82.39)
  BOTTOM w0.109: R1017.2 94.34,73.31 94.34,73.44 v1(94.35,73.46) ; U400.H9 v2(103.21,82.39)
CFG6: length 81
  TOP w0.109: v1(50.8,47.37) 50.04,47.37 49.58,47.83 48.97,47.83 48.63,47.48 CON7703.33 ; v1(95.4,74.47) 95.8,74.88 R1042.1
  IN2 w0.089: v1(50.8,47.37) 54.14,47.37 54.63,46.89 67.84,46.89 68.95,48 70.01,48 77.36,55.34 79.05,55.34 80.35,56.64 81.21,56.64 82.78,58.21 82.78,59.95 89.08,66.25 89.08,66.87 94.06,71.85 94.06,72.3 94.97,73.21 94.97,74.04 v1(95.4,74.47) 96.09,75.16 96.09,75.64 97.05,76.6 98.17,76.6 99.91,78.33 100.63,78.33 103.86,81.55 103.86,82.13 v2(105.08,83.35)
  BOTTOM w0.109: v1(95.4,74.47) 95.06,74.13 95.06,72.94 94.41,72.29 94.41,71.88 R1018.2 ; v2(105.08,83.35) 104.77,83.04 U400.K8
CFG7: length 82
  TOP w0.109: v1(49.78,48.92) 49.45,48.59 v1(49.45,48.26) 49.38,48.18 48.99,48.18 48.79,47.98 CON7703.35 ; R1038.1 94.7,74.92 95.2,75.42 v1(95.2,75.56)
  IN2 w0.089: v2(103.21,84) 103.13,84 101.54,82.41 101.54,80.1 100.38,78.94 99.65,78.94 98.95,78.24 97.66,78.24 97.33,77.91 96.41,77.91 96,77.5 96,76.31 95.61,75.92 95.55,75.92 v1(95.2,75.56) 94.74,75.11 94.56,75.11 94.09,74.64 94.09,74.03 93.52,73.46 93.52,72.07 88.54,67.09 88.1,67.09 87.68,66.67 86.77,66.67 85.45,65.34 85.45,63.43 82.17,60.15 82.17,58.35 80.99,57.18 80.13,57.18 78.83,55.88 77.06,55.88 69.72,48.53 68.18,48.53 67.14,47.5 54.96,47.5 54.07,48.38 53.12,48.38 52.78,48.71 51.69,48.71 51.36,49.05 49.91,49.05 v1(49.78,48.92)
  BOTTOM w0.109: v2(103.21,84) 103.52,83.69 U400.H7 ; v1(95.2,75.56) 95.2,75.56 94.23,74.59 94.23,74.14 93.87,73.78 R1019.2
CFG8: length 96.8
  TOP w0.109: CON7703.10 40.48,41.48 39.55,42.42 TP7700.1 39.55,43.01 v1(40.05,43.52) ; v1(94.77,74.47) 94.79,74.47 94.85,74.41 R1043.1
  IN2 w0.089: v1(40.05,43.52) 41.73,45.19 41.73,47.77 43.54,49.58 45.36,49.58 47.17,47.78 51.1,47.78 51.31,47.57 54.23,47.57 54.74,47.06 67.76,47.06 68.88,48.18 69.9,48.18 77.25,55.52 78.98,55.52 80.28,56.82 81.14,56.82 82.55,58.23 82.55,59.99 85.88,63.32 85.88,64.36 86.92,65.41 87.83,65.41 88.85,66.42 88.85,66.89 93.88,71.92 93.88,72.41 94.77,73.3 v1(94.77,74.47) 94.77,74.5 95.2,74.93 95.4,74.93 95.91,75.44 95.91,75.72 97,76.8 98.09,76.8 99.82,78.53 100.55,78.53 103.66,81.64 103.66,82.21 104.71,83.27 104.71,83.68 105.04,84.01 105.06,84.01 v2(105.06,84)
  BOTTOM w0.109: R1020.2 94.83,73.04 94.83,74.43 94.79,74.47 v1(94.77,74.47) ; v2(105.06,84) 105.06,84 104.75,83.69 U400.K7
CFG9: length 91.1
  TOP w0.109: R1021.2 95.19,71.02 95.19,71.49 95.3,71.6 v2(95.31,71.6) ; CON7703.12 42.74,41.98 v1(43.2,41.51) ; R1006.1 107.28,78.76 106.9,79.14 v2(106.89,79.14)
  IN2 w0.089: v2(106.89,79.14) 106.89,79.14 106.51,78.76 103.14,78.76 99.96,75.58 99.96,75.07 99.09,74.2 99.09,72.67 98.64,72.22 98.28,72.22 98.21,72.15 96.8,72.15 96.65,72.01 95.71,72.01 v2(95.31,71.6) 95.31,71.59 90.3,66.58 90.3,65.8 84,59.5 84,57.92 79.67,53.59 77.35,53.59 69.18,45.42 65.66,45.42 65.37,45.71 53.6,45.71 53.24,45.34 47.5,45.34 45.72,47.12 44.21,47.12 43.76,46.67 43.76,46.16 44.55,45.36 44.55,44.11 45.01,43.66 45.01,43.32 v1(43.2,41.51)
  BOTTOM w0.109: v2(106.89,79.14) 107.17,78.86 U400.T17
CFG10: length 94.7
  TOP w0.109: R1009.1 96.07,73.82 v1(95.5,73.24) 95.5,73.22 95.13,72.84 v1(95.02,72.84) 94.9,72.73 94.58,72.73 94.25,72.4 R1023.2 ; CON7703.16 43.34,42.98 43.84,43.49 v1(43.84,43.52)
  IN2 w0.089: v1(43.84,43.52) 43.84,43.49 43.41,43.05 42.97,43.05 41.97,44.06 41.97,47.72 43.3,49.05 45.46,49.05 47.55,46.96 53.36,46.96 53.62,46.71 67.91,46.71 69.02,47.82 70.12,47.82 77.47,55.16 79.13,55.16 80.43,56.46 81.29,56.46 82.98,58.16 82.98,59.89 89.28,66.19 89.28,66.82 94.23,71.78 94.23,72.19 95.1,73.05 95.31,73.05 v1(95.5,73.24) 95.93,73.67 95.93,74.65 96.27,74.99 96.27,75.57 97.09,76.39 98.26,76.39 99.99,78.12 100.72,78.12 103.64,81.05 104.34,81.05 104.65,81.36 104.65,82.42 104.92,82.7 v2(105.05,82.7)
  BOTTOM w0.109: v2(105.05,82.7) 104.96,82.7 U400.K9
CFG11: length 92.7
  TOP w0.109: CON7703.18 43.18,43.48 v1(43.21,43.52) ; R1022.1 96.97,73.66 96.91,73.73 96.68,73.73 96.47,73.52 96.41,73.52 v1(96.13,73.24) 96.13,73.12 95.8,72.79 95.58,72.79 94.85,72.06 94.35,72.06 R1024.2
  IN2 w0.089: v2(105.12,81.54) 104.42,80.84 103.72,80.84 100.8,77.92 100.07,77.92 98.34,76.19 97.14,76.19 96.45,75.5 96.45,74.89 96.13,74.57 v1(96.13,73.24) 96.13,73.12 95.83,72.82 95.15,72.82 94.41,72.08 94.41,71.7 89.49,66.78 89.49,66.14 83.18,59.83 83.18,58.11 81.3,56.23 80.44,56.23 79.2,54.99 77.58,54.99 70.23,47.64 69.1,47.64 67.9,46.45 53.32,46.45 52.98,46.78 47.45,46.78 45.39,48.84 43.38,48.84 42.37,47.83 42.37,44.32 43.17,43.52 v1(43.21,43.52)
  BOTTOM w0.109: U400.K12 105.1,81.54 v2(105.12,81.54)
CFG12: length 90.9
  TOP w0.109: v1(96.79,73.24) 96.36,72.81 R1010.1 96.13,72.67 95.94,72.48 95.6,72.48 v1(94.7,71.59) 94.57,71.46 R1025.2 ; CON7703.28 42.97,45.98 43.07,45.89 44.47,45.89 44.87,46.29 44.87,47.84 v1(44.32,48.38)
  IN2 w0.089: v2(105.12,82.09) 105.48,81.72 105.48,81.23 104.9,80.64 103.81,80.64 100.89,77.72 100.16,77.72 98.43,75.99 97.19,75.99 96.65,75.45 96.65,74.8 96.34,74.48 96.34,73.7 v1(96.79,73.24) 96.79,73.12 96.29,72.61 95.23,72.61 94.59,71.97 94.59,71.63 89.69,66.73 89.69,66.05 83.39,59.75 83.39,58.06 81.37,56.05 80.51,56.05 79.27,54.81 77.69,54.81 70.34,47.47 69.17,47.47 67.98,46.27 52.73,46.27 52.4,46.61 47.29,46.61 46.12,47.78 44.93,47.78 v1(44.32,48.38)
  BOTTOM w0.109: U400.K11 105,82.09 v2(105.12,82.09)
CFG13: length 88.4
  TOP w0.109: CON7703.30 43.12,46.48 v1(43.21,46.4) ; R1026.2 97.07,71.05 97.07,71.7 97.24,71.86 97.32,71.92 97.69,71.92 98.47,72.7 v2(98.47,72.72) ; v2(107.68,80.22) 107.28,80.62 R1011.1
  IN2 w0.089: v2(107.68,80.22) 107.29,79.83 107.11,79.83 106.88,79.6 103.65,79.6 101.16,77.11 100.41,77.11 98.58,75.27 98.58,73.47 98.47,73.36 98.47,72.75 98.47,72.75 v2(98.47,72.72) 98.1,72.35 96.71,72.35 96.57,72.21 95.4,72.21 94.95,71.75 94.95,71.48 90.1,66.63 90.1,65.88 83.79,59.58 83.79,57.97 81.52,55.69 80.66,55.69 79.42,54.45 77.92,54.45 69.1,45.63 65.69,45.63 65.42,45.91 52.33,45.91 52.04,46.2 46.94,46.2 45.82,47.32 44.13,47.32 v1(43.21,46.4)
  BOTTOM w0.109: U400.U15 107.68,80.09 v2(107.68,80.22)
CFG14: length 88
  TOP w0.109: v2(98.04,71.55) 98.04,71.29 R1027.2 ; v1(44.37,46.4) 43.28,47.48 CON7703.34 ; v2(108.16,79.32) 108.4,79.08 R1003.1
  IN2 w0.089: v2(108.16,79.32) 107.96,79.12 107.96,79.08 106.63,77.75 102.82,77.75 100.45,75.38 100.45,73.45 98.99,71.98 98.99,71.34 98.79,71.14 98.47,71.14 98.07,71.55 v2(98.04,71.55) ; v1(44.37,46.4) 45.69,46.4 47.11,44.98 53.8,44.98 54.13,45.31 65.26,45.31 65.51,45.06 69.4,45.06 77.32,52.98 v1(78.38,52.98)
  IN3 w0.089: v1(78.38,52.98) 78.38,53.54 80.55,55.71 81.51,55.71 86.49,60.69 86.92,60.69 91.56,65.33 91.56,66.68 92.28,67.39 92.28,68.3 93.28,69.3 93.28,69.79 94.65,71.16 97.65,71.16 v2(98.04,71.55)
  BOTTOM w0.109: U400.V17 108.61,78.86 v2(108.16,79.32)
CFG15: length 87.2
  TOP w0.109: v1(43.59,48.39) 43.18,47.98 CON7703.36 ; R1029.2 96.25,70.86 96.81,71.41 96.81,71.76 97.1,72.05 97.49,72.31 R1002.1 97.7,72.5 v2(97.92,72.72)
  IN2 w0.089: v1(43.59,48.39) 44.41,47.57 45.87,47.57 47.01,46.43 52.12,46.43 52.45,46.1 65.48,46.1 65.77,45.81 68.98,45.81 77.8,54.63 79.35,54.63 80.59,55.87 81.45,55.87 83.59,58.01 83.59,59.66 89.89,65.97 89.89,66.68 94.77,71.56 94.77,71.86 95.32,72.41 96.48,72.41 96.79,72.72 v2(97.92,72.72) 97.92,73.71 98.34,74.13 98.34,75.32 100.33,77.31 101.07,77.31 103.56,79.8 106.74,79.8 107.14,80.2 v2(107.14,80.22)
  BOTTOM w0.109: U400.T15 107.14,79.98 v2(107.14,80.22)
CFG16: length 91.5
  TOP w0.109: CON7703.21 46.1,44.48 45.86,44.24 45.86,38.91 46.97,37.81 v1(48.56,37.81)
  IN3 w0.089: v1(48.56,37.81) 50.8,37.81 51.79,38.79 51.79,39.45 54.79,42.46 59.55,42.46 60.17,43.08 67.26,43.08 78.45,54.27 78.82,54.27 80.44,55.89 81.4,55.89 86.4,60.89 86.87,60.89 91.39,65.4 91.39,66.75 92.1,67.46 92.1,68.37 93.1,69.38 93.1,69.91 95.29,72.1 96.9,72.1 v2(97.47,71.52)
  BOTTOM w0.079: U400.H11 103.37,81.37 103.37,80.87 103.68,80.57 103.68,80.28 103.02,79.62 101.29,79.62 100.96,79.29 100.57,79.29
  BOTTOM w0.109: v2(97.47,71.52) 97.12,71.88 R1037.2 97.68,72.32 97.81,72.19 98.58,72.19 98.88,72.49 98.88,72.92 98.79,73.01 98.79,75.7 99.65,76.56 99.65,78.91 100.03,79.29 100.57,79.29
CFG17: length 91.8
  TOP w0.109: CON7703.4 43.17,39.98 v1(43.27,40.08)
  IN2 w0.089: v2(107.53,79.31) 107.53,79.19 106.9,78.56 103.23,78.56 100.25,75.59 100.25,75.08 99.29,74.12 99.29,72.58 98.73,72.02 98.36,72.02 98.29,71.95 96.91,71.95 96.81,71.84 96.81,71.39 96.49,71.07 95.03,71.07 90.48,66.51 90.48,65.69 84.2,59.41 84.2,57.87 79.72,53.39 77.43,53.39 69.29,45.24 65.58,45.24 65.33,45.49 53.9,45.49 53.57,45.16 47.3,45.16 45.54,46.91 44.3,46.91 43.96,46.58 43.96,46.21 44.73,45.44 44.73,44.22 45.21,43.74 45.21,42.02 v1(43.27,40.08)
  BOTTOM w0.109: U400.U17 107.98,78.86 v2(107.53,79.31)
CFG_RCOMP: length 9.6
  BOTTOM w0.14: U400.B5 101.29,84.6 101.09,84.4 100.41,84.4
  BOTTOM w0.381: R1000.1 94.72,86.09 v1(94.78,86.16) 96.19,87.57 97.24,87.57 100.41,84.4
CHA_SA0: length 8
  TOP w0.109: R2812.1 185.04,25.66 R2817.2 184.27,25.3 183.99,25.3 183.68,25.17 183.11,25.17 v1(183.06,25.22)
  BOTTOM w0.109: JDIM2800.256 182.18,21.52 182.47,21.82 182.47,24.69 183,25.22 v1(183.06,25.22)
CHA_SA1: length 8.6
  TOP w0.109: R2813.1 R2818.2 185.19,23.72 184.76,23.29 183.79,23.29 183.13,23.95 v1(183.06,23.95) v1(183.06,24.58)
  BOTTOM w0.109: JDIM2800.260 183.18,22.02 183.06,22.14 v1(183.06,24.58)
CHA_SA2: length 3.4
  TOP w0.109: R2814.1 R2819.2 160.3,22.02 v1(160.17,22.15)
  BOTTOM w0.109: JDIM2800.166 159.68,21.65 v1(160.17,22.15)
CHB_SA0: length 3
  TOP w0.109: R2902.2 R2905.1 105.43,18.68 v1(105.22,18.9)
  BOTTOM w0.109: JDIM2900.256 v1(105.22,18.9)
CHB_SA1: length 4
  TOP w0.109: v1(105.97,18.92) 106.04,19 106.88,19 107.21,18.66 R2906.1 107.21,17.82 107.26,17.78 R2903.2
  BOTTOM w0.109: v1(105.97,18.92) 106.22,19.17 JDIM2900.260
CHB_SA2: length 2.7
  TOP w0.109: v1(82.65,21.5) 82.72,21.57 R2907.1 R2904.2
  BOTTOM w0.109: JDIM2900.166 82.72,21.44 v1(82.65,21.5)
CK_XDP_N: length 3.7
  TOP w0.109: CON7703.42 40.51,49.48 40.36,49.32 39.81,49.32 39.19,48.71 38.81,48.71 38.68,48.84 TP7704.1
CK_XDP_P: length 3.7
  TOP w0.109: TP7703.1 38.68,48.37 38.8,48.49 39.28,48.49 39.9,49.1 40.38,49.1 40.5,48.98 CON7703.40
CL_CLK: length 51
  IN1 w0.079: v1(182.83,83) 182.45,83 181.75,82.31 180.14,82.31 179.79,82.66 174.36,82.66 171.76,85.27 168.58,85.27 168.53,85.21 166.46,85.21 164.61,87.07 156.5,87.07 155.14,85.71 150.47,85.71 149.27,86.91 148.39,87.79 142.27,87.79 141.7,87.22 v2(141.3,87.22)
  BOTTOM w0.079: U400.DH3 139.94,85.45 139.94,86.49 140.67,87.22 v2(141.3,87.22)
  BOTTOM w0.109: C4112.2 182.84,83.01 v1(182.83,83) 183.08,83 183.43,82.65 183.51,82.46 183.51,82.17 183.41,82.07 R4130.1
CL_CS_ME_CL: length 18.2
  TOP w0.109: Q7506.3 11.91,38.38 12.47,37.82 14.93,37.82 15.24,38.12 17.9,38.12 18.45,37.57 18.91,37.57 19.56,36.93 19.56,36.12 18.69,35.25 18.69,34.24 19.07,33.86 v1(19.07,33.55) 18.34,32.81 18.34,32 18.78,31.56 R7509.2 18.9,31.31 R7515.1 20.4,30.29 20.47,30.36 D7501.2
CL_DATA: length 50.7
  IN1 w0.079: v1(183.08,82.37) 182.81,82.37 182.4,81.96 180.53,81.96 180.14,81.57 179.44,81.57 178.68,82.33 174.22,82.33 172.28,84.27 171.32,84.27 170.86,84.73 168.45,84.73 167.82,84.1 166.44,84.1 165.02,85.52 164.5,85.52 163.27,86.74 156.67,86.74 155.28,85.36 150.32,85.36 149.02,86.66 148.24,87.44 142.43,87.44 141.85,86.86 v2(140.86,86.86)
  BOTTOM w0.079: v2(140.86,86.86) 140.53,86.86 140.15,86.48 140.15,85.26 139.88,84.98 U400.DH4
  BOTTOM w0.109: R4129.1 182.7,81.99 v1(183.08,82.37)
CL_RST: length 53.8
  TOP w0.109: v1(158,87.5) 157.98,87.5 157.07,86.59 157.07,86.51 155.13,84.57 154.75,84.57 154.43,84.25 153.47,84.25 153.42,84.19 151.08,84.19 150.77,84.5 150.54,84.5 147.96,87.08 147.96,89.35 147.61,89.71 146.1,89.71 144.22,87.83 141.32,87.83 v2(140.93,88.22)
  IN1 w0.079: v1(181.81,83) 181.45,82.64 180.57,82.64 180.22,82.99 174.5,82.99 171.89,85.6 169.22,85.6 168.58,86.24 165.91,86.24 164.65,87.5 v1(158,87.5)
  BOTTOM w0.109: R4128.1 181.81,81.53 v1(181.81,82.29) v1(181.81,83) ; U400.DF2 139.26,85.89 139.55,86.18 139.55,86.62 140.93,88 v2(140.93,88.22)
CLICKPAD_INT#: length 247.7
  TOP w0.109: v1(112.6,16.18) 112.39,15.97 112.39,15.11 112.14,14.86 112.14,14.17 112.39,13.92 112.39,10.94 111.83,10.39 111.83,8.71 111.4,8.28 v1(111.4,7.47) 111.1,7.47 v1(110.46,6.83)
  IN2 w0.089: v2(42.47,6.13) 42.66,6.32 50.26,6.32 50.85,6.91 51.2,6.91 51.81,6.3 54.91,6.3 56.56,4.65 60.73,4.65 61.21,4.16 65.48,4.16 65.96,4.65 70.2,4.65 73.28,7.72 73.84,7.72 75.87,9.75 86.28,9.75 86.51,9.98 93.62,9.98 94.23,9.37 98.45,9.37 99.39,8.43 101.47,8.43 102.46,7.44 106.27,7.44 106.45,7.26 110.03,7.26 v1(110.46,6.83) ; v2(147.64,74.95) 147.66,74.93 147.66,74.59 147.75,74.5 147.75,74.5 148.37,73.89 148.37,72.48 146.06,70.18 145.65,70.18 144.85,69.37 144.85,66.36 145.18,66.02 145.18,63.49 144.89,63.19 144.89,61.23 145.6,60.52 145.6,59.07 145.96,58.71 145.96,57.4 146.24,57.13 146.24,56.72 145.8,56.28 v1(145.8,56.09)
  IN3 w0.089: v1(145.8,56.09) 146.23,55.66 146.23,54.83 148.1,52.96 156.46,52.96 156.91,53.4 157.27,53.4 157.94,52.74 157.94,52.38 157.85,52.28 157.85,51.73 158.41,51.16 158.78,51.16 158.99,51.37 160.64,51.37 161.59,50.42 161.59,50.24 163.58,48.26 164.51,48.26 165.46,47.3 165.85,47.3 166.93,46.22 167.29,46.22 167.61,45.9 167.61,45.01 168.74,43.88 168.74,41.99 170.5,40.22 171.02,40.22 172.62,38.63 172.62,37.09 175.54,34.17 175.54,31.78 178.15,29.18 178.15,27.8 179.19,26.75 179.19,24.15 179.43,23.91 179.43,21.37 178.87,20.81 178.5,20.81 177.65,19.96 176.67,19.96 175.78,19.07 165.81,19.07 163.8,17.07 163.3,17.07 162.24,16.01 159.86,16.01 159.49,15.64 157.66,15.64 155.37,17.93 148.87,17.93 147.85,16.91 144.45,16.91 144.15,17.22 142.82,17.22 142.71,17.33 136.03,17.33 136.01,17.31 135,17.31 134.46,17.85 132.67,17.85 132.06,18.46 125.06,18.46 124.66,18.05 124.66,17.94 124.3,17.59 123.32,17.59 122.3,18.62 119.99,18.62 119.4,19.2 115.62,19.2 v1(112.6,16.18)
  BOTTOM w0.079: U400.DT25 143.62,75.02 144.99,75.02 145.62,74.39 146.07,74.39 146.16,74.48 147.16,74.48 v2(147.64,74.95)
  BOTTOM w0.109: CON5202.4 38.19,6.87 38.33,7.01 40.34,7.01 R5212.2 40.67,6.67 41.21,6.13 v2(42.47,6.13)
CLK_BIASREF: length 5.8
  TOP w0.109: R1422.2 140.04,88.77 140.04,87.66 139.88,87.51 139.88,85.89 140.22,85.56 140.22,84.46 140.03,84.27 v2(140,84.27)
  BOTTOM w0.109: U400.DJ5 140.3,84.27 v2(140,84.27)
CLK_GFX_N: length 120.6
  IN3 w0.089: v2(132.53,82.67) 132.26,82.67 132.21,82.62 132.21,82.32 131.94,82.05 131.44,82.05 131.11,82.38 131.11,84.13 129.14,86.1 128.64,86.1 128.05,86.68 127.9,86.74 127.3,86.74 125.09,84.53 122.54,84.53 122.16,84.16 122.16,80.62 118.76,77.21 111.45,77.21 109.5,79.16 108.82,79.16 108.31,79.68 108.02,79.68 108.02,79.67 107.55,79.67 107.5,79.69 107.37,79.69 107.34,79.66 106.83,79.66 106.46,80.03 106.46,81.1 106.39,81.16 106.39,82.29 106.82,82.71 107.08,82.71 107.27,82.9 109.8,82.9 110.03,83.13 110.03,83.86 110.18,84.22 110.72,84.76 110.72,85.32 111.28,85.88 112.32,85.88 112.66,85.53 113.66,85.53 115.44,87.31 115.44,91.18 114.58,92.05 112.44,92.05 111.24,93.25 110.23,93.25 107.5,95.99 93.6,95.99 92.13,94.52 91.18,94.52 89.88,93.22 89.43,93.22 87.84,91.62 87.64,91.14 87.44,90.65 87.44,89.96 85.84,88.36 85.84,85.04 84.1,83.3 84.1,82.19 83.06,81.15 83.06,78.18 82.19,77.32 82.19,75.38 79.51,72.71 79.51,72.03 78.63,71.15 78.18,71.15 75.91,68.88 74.51,68.88 73.9,68.27 73.27,68.01 72.93,68.01 72.64,68.3 72.64,68.88 73.18,69.42 v1(73.22,69.42)
  BOTTOM w0.109: U400.CL8 132.49,82.67 v2(132.53,82.67) ; v1(73.22,69.42) U6600.AD8
CLK_GFX_P: length 120.6
  IN3 w0.089: v2(132.53,83.21) 132.02,82.7 132.02,82.4 131.86,82.24 131.52,82.24 131.3,82.46 131.3,84.21 129.21,86.29 128.71,86.29 128.16,86.84 127.94,86.94 127.22,86.94 125.01,84.72 122.46,84.72 121.97,84.23 121.97,80.7 118.68,77.4 111.53,77.4 109.58,79.35 108.9,79.35 108.39,79.87 107.95,79.87 107.94,79.86 107.58,79.86 107.54,79.88 107.29,79.88 107.26,79.85 106.91,79.85 106.65,80.11 106.65,81.17 106.59,81.24 106.59,82.21 106.9,82.52 107.16,82.52 107.34,82.71 109.88,82.71 110.22,83.05 110.22,83.82 110.34,84.11 110.91,84.68 110.91,85.24 111.35,85.68 112.24,85.68 112.58,85.34 113.74,85.34 115.63,87.23 115.63,91.26 114.66,92.24 112.52,92.24 111.32,93.44 110.31,93.44 107.58,96.18 93.52,96.18 92.05,94.71 91.1,94.71 89.8,93.41 89.35,93.41 87.68,91.73 87.25,90.69 87.25,90.04 85.65,88.44 85.65,85.12 83.91,83.38 83.91,82.27 82.87,81.23 82.87,78.26 82,77.39 82,75.46 79.32,72.79 79.32,72.11 78.55,71.34 78.1,71.34 75.83,69.07 74.43,69.07 73.79,68.43 73.23,68.2 73.01,68.2 72.83,68.38 72.83,68.8 73,68.97 73.11,68.97 73.22,68.87 v1(73.22,68.62)
  BOTTOM w0.109: v2(132.53,83.21) 132.5,83.25 132.31,83.25 132.11,83.45 U400.CL7 ; U6600.AE8 72.95,68.2 73.22,68.48 v1(73.22,68.62)
CLK_PCIE_CRN: length 82.9
  TOP w0.109: U7600.6 177.02,42.68 176.96,42.74 176.96,46.95 176.83,47.08 176.83,50.65 177.4,51.22 177.54,51.22 177.81,51.49 v1(177.81,51.61)
  IN3 w0.089: v2(127.72,86.38) 128.64,85.47 129.2,85.47 130.38,84.28 130.38,82.21 130.59,82 130.59,79.41 133.18,76.82 142.64,76.82 143.05,77.22 144.99,77.22 145.05,77.16 146.9,77.16 147.3,76.77 149.53,76.77 150.04,76.26 153.38,76.26 154.06,75.58 154.63,75.58 155.27,76.21 156.35,76.21 156.83,75.73 156.83,75.3 159.95,72.18 161.41,72.18 161.73,71.86 161.73,71.61 163.78,69.57 164.06,69.57 165.17,68.45 165.17,67.59 166.13,66.63 167.47,66.63 168.6,65.51 168.6,64.94 171.95,61.59 171.95,59.92 173.18,58.69 173.18,57.49 174,56.66 174,55.85 177.21,52.65 177.21,51.48 177.36,51.33 177.53,51.33 v1(177.81,51.61)
  BOTTOM w0.079: v2(127.72,86.38) 127.73,86.39 128.1,86.39 U400.CB1
CLK_PCIE_CRP: length 82.9
  TOP w0.109: v1(177.81,50.84) 177.65,51 177.49,51 177.05,50.56 177.05,47.17 177.18,47.04 177.18,42.84 177.42,42.61 U7600.5
  IN3 w0.089: v2(127.72,85.82) 127.72,85.81 128.02,85.81 128.56,85.28 129.12,85.28 130.19,84.21 130.19,82.13 130.4,81.92 130.4,79.33 133.1,76.63 142.72,76.63 143.13,77.03 144.91,77.03 144.97,76.97 146.83,76.97 147.22,76.58 149.45,76.58 149.96,76.07 153.3,76.07 153.98,75.38 154.71,75.38 155.34,76.02 156.27,76.02 156.64,75.65 156.64,75.22 159.87,71.99 161.33,71.99 161.54,71.78 161.54,71.53 163.7,69.38 163.98,69.38 164.98,68.37 164.98,67.51 166.05,66.44 167.39,66.44 168.41,65.43 168.41,64.86 171.76,61.51 171.76,59.84 172.99,58.61 172.99,57.41 173.81,56.58 173.81,55.77 177.02,52.57 177.02,51.4 177.28,51.14 177.67,51.14 177.81,50.99 v1(177.81,50.84)
  BOTTOM w0.079: U400.CB2 128.12,86.04 128.06,86.1 128,86.1 v2(127.72,85.82)
CLK_PCIE_LANN: length 174.1
  TOP w0.109: R7617.2 12.41,16.47 12.41,16.06 12.16,15.81 v1(12.16,15.52)
  IN1 w0.079: v2(126.41,88.53) 126.04,88.16 125.71,88.16 124.77,87.22 124.39,87.22 121.22,84.05 121.22,82.46 120.29,81.53 120.29,80.8 119.63,80.13 118.13,80.13 117.84,79.84 111.75,79.84 110.98,80.61 110.98,81.23 110.06,82.15 110.06,84.78 109.84,85 109.35,85 108.27,86.08 104.76,86.08 104.03,85.77 101.43,85.77 100.87,85.21 98.48,85.21 95.22,81.95 94.26,81.95 93.48,81.17 91.16,81.17 90.26,80.27 88.26,80.27 87.5,79.51 87.5,78.43 85,75.93 85,75.64 81.95,72.6 81.95,72.32 80.98,71.35 80.47,71.35 79.12,69.99 79.12,69.48 76.8,67.16 76.8,65.48 75.58,64.26 73.89,64.26 71.19,61.57 71.19,57.09 65.65,51.54 65.65,51.11 59.93,45.39 55.8,45.39 52.07,41.66 51.56,41.66 49.2,39.29 45.28,39.29 44.36,38.36 43.4,38.36 42.91,38.85 37.37,38.85 37.02,39.2 31.57,39.2 31.25,38.88 28.6,38.88 27.3,37.59 25.48,37.59 23.9,36.01 23.9,32 20.21,28.32 20.21,28.18 18.08,26.05 18.08,23.65 16.46,22.02 14.66,22.02 13.63,20.98 13.63,19.88 11.95,18.2 11.95,15.73 v1(12.16,15.52)
  BOTTOM w0.079: U400.CB5 128.12,84.6 127.84,84.88 127.84,85.16 128.09,85.42 128.2,85.42 128.35,85.58 128.35,86.8 128.05,87.11 128.05,89.1 127.74,89.4 127.36,89.4 127.06,89.11 127.06,88.95 126.84,88.73 126.61,88.73 v2(126.4,88.53)
CLK_PCIE_LANN_R: length 4.4
  TOP w0.109: CON7602.18 10.49,18.18 10.62,18.06 10.76,18.06 11,18.3 11,18.7 11.38,19.08 12.19,19.08 12.57,18.69 12.57,17.86 R7617.1
CLK_PCIE_LANP: length 174.3
  TOP w0.109: R7618.2 12.19,16.5 12.19,16.15 11.55,15.52 v1(11.53,15.52)
  IN1 w0.079: v2(126.4,89.08) 126.25,88.92 126.09,88.68 126.03,88.55 126.03,88.39 125.97,88.33 125.64,88.33 124.7,87.39 124.32,87.39 121.05,84.12 121.05,82.53 120.12,81.6 120.12,80.87 119.56,80.3 118.06,80.3 117.77,80.01 111.82,80.01 111.15,80.68 111.15,81.3 110.22,82.22 110.22,84.85 109.91,85.16 109.42,85.16 108.34,86.24 104.73,86.24 104,85.94 101.36,85.94 100.8,85.38 98.41,85.38 95.15,82.12 94.19,82.12 93.41,81.34 91.09,81.34 90.19,80.44 88.19,80.44 87.34,79.58 87.34,78.5 84.83,76 84.83,75.71 81.79,72.67 81.79,72.39 80.91,71.51 80.4,71.51 78.95,70.06 78.95,69.55 76.63,67.23 76.63,65.55 75.51,64.43 73.82,64.43 71.03,61.64 71.03,57.16 65.48,51.61 65.48,51.18 59.86,45.56 55.73,45.56 52,41.82 51.49,41.82 49.13,39.46 45.21,39.46 44.29,38.53 43.47,38.53 42.98,39.02 37.44,39.02 37.09,39.37 31.5,39.37 31.18,39.05 28.53,39.05 27.23,37.76 25.41,37.76 23.73,36.08 23.73,32.07 20.05,28.39 20.05,28.25 17.92,26.12 17.92,23.71 16.39,22.19 14.59,22.19 13.46,21.05 13.46,19.95 11.78,18.27 11.78,15.77 v1(11.53,15.52)
  BOTTOM w0.079: U400.CB4 128.12,85.19 128.19,85.26 128.26,85.26 128.51,85.51 128.51,86.87 128.2,87.18 128.2,89.17 127.81,89.56 127.29,89.56 126.91,89.17 126.91,89.01 126.78,88.89 126.47,88.89 126.4,88.96 v2(126.4,89.08)

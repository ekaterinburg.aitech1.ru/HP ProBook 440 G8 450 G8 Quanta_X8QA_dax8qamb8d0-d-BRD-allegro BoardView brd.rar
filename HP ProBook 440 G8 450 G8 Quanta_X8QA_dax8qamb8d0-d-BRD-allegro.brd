# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1 (solid shape): 209.2,18.8 209.3,18.72 209.43,18.69 209.58,18.72 209.68,18.82 209.78,18.82 209.84,18.76 209.84,16.92 209.81,16.84 209.73,16.81 209.7,16.82 209.39,16.51 209.7,16.2 209.73,16.2 209.81,16.17 209.84,16.1 209.84,15.37 209.79,15.29 209.7,15.27 209.65,15.29 209.6,15.29 209.27,14.96 209.6,14.63 209.65,14.63 209.7,14.64 209.79,14.63 209.84,14.55 209.84,14.26 209.81,14.19 209.73,14.16 209.73,14.16 209.42,13.85 209.73,13.54 209.73,13.54 209.81,13.52 209.84,13.44 209.84,13.03 209.81,12.96 209.74,12.93 209.42,12.6 209.74,12.26 209.81,12.23 209.84,12.17 209.84,11.5 209.05,10.72 208.76,10.72 208.66,10.82 208.66,18.63 208.71,18.72 208.8,18.73 208.84,18.72 208.89,18.71 208.99,18.74 209.08,18.79 209.1,18.81 209.13,18.82 209.18,18.82
GND on IN1 (solid shape): outline of 172 points within 186.83,9.26 191.31,12.96
GND on IN1 (solid shape): 33.63,95.67 33.44,95.48 33.44,92.24 34.35,91.32 34.35,91.3 34.45,91.09 34.66,91 34.87,91.08 34.97,91.29 34.97,91.33 35.11,91.33 35.18,91.31 35.21,91.24 35.24,91.11 35.31,91.01 35.4,90.92 35.42,90.84 35.38,90.77 35.33,90.73 35.28,90.68 34.99,90.68 34.75,90.81 34.5,90.68 34.28,90.68 32,88.4 31.94,88.38 31.87,88.4 31.82,88.44 31.8,88.48 31.82,88.52 31.84,88.53 32,88.82 31.87,89.14 31.84,89.21 31.87,89.29 31.87,89.3 31.97,89.42 32.01,89.58 32.02,89.63 32.06,89.66 32.09,89.67 32.11,89.67 32.14,89.67 32.23,89.66 32.32,89.68 32.53,89.99 32.32,90.31 32.32,90.36 32.12,90.55 32.12,90.89 32.13,90.89 32.13,94.95 32.23,94.97 32.25,94.94 32.28,94.91 32.32,94.88 32.41,94.83 32.51,94.81 32.74,94.9 32.84,95.13 32.84,95.15 32.94,95.25 33.03,95.25 33.06,95.25 33.17,95.3 33.26,95.38 33.27,95.39 33.31,95.48 33.33,95.58 33.36,95.67 33.43,95.7 33.46,95.7 33.51,95.71 33.57,95.72
GND on IN1 (solid shape): outline of 163 points within 204.61,11.75 208.07,15.04
GND on IN1 (solid shape): 139.1,70.3 139.22,70.28 139.32,70.3 139.42,70.35 139.45,70.37 139.48,70.35 139.8,70.03 140.51,70.03 140.53,70 140.56,69.93 140.53,69.86 140.5,69.86 140.19,69.55 140.5,69.25 140.64,69.28 140.74,69.36 140.78,69.35 140.82,69.33 141.01,69.14 141.04,69.09 141.04,69.04 140.97,69 140.93,68.95 140.84,68.9 140.75,68.96 140.64,69.07 140.48,69.12 140.35,69.09 140.24,69 140.17,68.97 140.1,68.99 140,69.06 139.88,69.08 139.66,68.99 139.57,68.77 139.59,68.68 139.63,68.59 139.6,68.53 139.54,68.51 139.5,68.51 139.44,68.53 139.4,68.59 139.45,68.67 139.46,68.76 139.37,68.98 139.15,69.07 139.12,69.07 139.09,69.06 139.06,69.1 139.05,69.14 139.05,69.17 139.08,69.25 139.17,69.27 139.23,69.27 139.44,69.36 139.53,69.57 139.52,69.68 139.47,69.77 139.36,69.86 139.23,69.9 139.19,69.9 139.13,69.88 138.9,70.11 138.9,70.27 138.93,70.34 139,70.37
GND on IN1 (solid shape): 65.97,63.16 66.08,63.18 66.15,63.09 66.15,60.8 66.11,60.72 66.02,60.7 65.99,60.71 65.96,60.71 65.8,60.67 65.68,60.55 65.59,60.51 65.51,60.55 65.39,60.64 65.25,60.68 64.91,60.34 65.25,60.01 65.41,60.05 65.53,60.16 65.61,60.21 65.69,60.17 65.72,60.14 65.74,60.12 65.78,60.05 65.75,59.97 64.03,58.25 64.03,56.02 62.93,54.91 62.86,54.88 62.78,54.91 62.72,54.97 62.65,55 62.63,55.01 62.38,55.26 61.52,55.26 61.46,55.19 60.12,55.19 60.12,55.19 59.89,55.42 59.89,56.73 63.09,59.93 63.19,59.96 63.26,59.88 63.38,59.68 63.59,59.6 63.75,59.63 63.87,59.74 63.95,59.78 64.03,59.74 64.15,59.64 64.3,59.61 64.63,59.94 64.3,60.27 64.14,60.24 64.02,60.13 63.94,60.09 63.86,60.13 63.74,60.23 63.59,60.26 63.52,60.26 63.47,60.31 63.56,60.4 64.64,60.4 65.72,61.47 65.72,62.9
GND on IN1 (solid shape): 82.96,105.55 83.07,105.53 83.91,104.68 84.67,104.68 84.76,104.62 84.74,104.51 84.68,104.41 84.75,104.05 84.98,103.95 85.22,104.05 85.32,104.28 85.32,104.3 85.38,104.4 85.49,104.38 87.23,102.63 87.23,101.97 88.45,100.75 88.45,100.14 88.42,100.1 88.37,100.11 88.34,100.13 87.65,100.13 86.73,101.06 86.73,102.38 85.36,103.74 83.62,103.74 83.53,103.8 83.54,103.9 83.58,103.99 83.59,104.09 83.26,104.42 82.93,104.09 82.96,103.95 83.04,103.83 83.06,103.82 83.06,103.74 82.97,103.74 81.83,104.88 81.83,105.41 81.87,105.48 81.94,105.51 81.96,105.51 82.03,105.51 82.09,105.53 82.18,105.52 82.23,105.44 82.27,105.3 82.36,105.19 82.4,105.12 82.37,105.04 82.3,104.94 82.28,104.81 82.61,104.48 82.94,104.81 82.91,104.96 82.81,105.08 82.77,105.15 82.8,105.23 82.87,105.33 82.89,105.46
GND on IN1 (solid shape): outline of 183 points within 205.03,14.68 207.2,22.76
GND on IN1 (solid shape): 133.19,6.92 136.35,6.92 136.73,7.29 137.16,7.29 137.25,7.22 137.23,7.11 136.61,6.5 132.53,6.5 132.47,6.5 132.12,6.14 131.11,6.14 131.1,6.16 130.97,6.16 130.95,6.15 130.92,6.14 130.75,6.14 130.66,6.19 130.66,6.29 130.68,6.36 130.69,6.44 130.36,6.77 130.02,6.44 130.03,6.36 130.06,6.29 130.05,6.19 129.97,6.14 129.87,6.14 129.79,6.19 129.78,6.29 129.81,6.36 129.81,6.44 129.48,6.77 129.15,6.44 129.16,6.36 129.18,6.29 129.18,6.19 129.09,6.14 128.73,6.14 128.64,6.19 128.64,6.29 128.66,6.36 128.67,6.44 128.34,6.77 128,6.44 128.01,6.36 128.04,6.29 128.03,6.19 127.95,6.14 125.4,6.14 125.17,6.37 125.16,6.41 124.84,6.67 124.51,6.41 124.5,6.37 124.12,6.37 124.11,6.41 123.78,6.67 123.46,6.41 123.45,6.37 117.63,6.37 117.5,6.5 117.5,6.83 117.6,6.93 123.78,6.93 130.26,6.93 130.8,7.47 130.91,7.59 132.51,7.59
GND on IN1 (solid shape): 31.11,89.44 31.2,89.47 31.27,89.42 31.32,89.35 31.37,89.29 31.41,89.2 31.37,89.14 31.24,88.85 31.41,88.48 31.37,88.4 31.24,88.14 31.33,87.86 31.35,87.8 31.33,87.73 31.31,87.71 31.31,75.59 31.27,75.58 31.2,75.56 31.13,75.52 31.02,75.5 30.96,75.59 30.96,82.79 30.91,82.91 30.79,82.97 30.59,83.05 30.5,83.24 30.41,83.38 30.24,83.39 30.18,83.37 30.12,83.37 29.9,83.45 29.81,83.67 29.84,83.8 29.92,83.9 29.98,84.04 29.81,84.41 29.98,84.78 29.81,85.14 29.98,85.51 29.92,85.65 29.84,85.75 29.81,85.88 29.9,86.1 30.12,86.19 30.2,86.17 30.27,86.14 30.44,86.14 30.54,86.27 30.64,86.44 30.84,86.52 30.93,86.55 30.96,86.65 30.96,89.3
GND on IN1 (solid shape): 95.46,26.81 95.54,26.78 96.06,26.26 95.99,26.08 96.04,25.9 95.85,25.7 95.78,25.43 95.78,25.16 95.79,25.04 95.83,24.93 95.79,24.83 95.78,24.71 95.78,24.67 96.12,24.16 96.72,24.29 96.73,24.3 96.81,24.3 96.95,24.32 97.09,24.37 97.19,24.37 97.24,24.29 97.24,22.98 97.83,22.39 97.88,22.35 97.93,22.31 97.88,22.15 97.92,21.99 97.83,21.9 97.7,21.7 97.67,21.48 97.64,21.4 97.57,21.37 96.65,21.37 96.57,21.4 96.55,21.48 96.19,21.83 95.89,21.43 95.89,21.37 95.75,21.37 95.76,21.43 95.63,21.87 95.22,22.07 94.83,22.07 94.75,22.15 94.73,22.21 94.78,22.24 95.22,22.24 95.76,22.79 95.22,23.34 94.83,23.34 94.83,25.2 94.86,25.28 94.94,25.3 95.47,25.63 95.35,26.24 95.26,26.33 95.3,26.49 95.25,26.66 95.33,26.71 95.39,26.77
GND on IN1 (solid shape): 142.69,63.18 142.79,62.98 143,62.9 143.07,62.91 143.12,62.92 143.15,62.88 143.16,62.84 143.16,62.34 144.23,61.27 144.82,60.68 144.8,60.65 144.77,60.57 144.75,60.48 144.84,60.26 145.04,60.15 145.09,60.15 145.19,60.16 145.28,60.21 145.33,60.09 145.23,60.02 145.21,60.02 145.08,59.99 144.97,59.91 144.89,59.88 144.82,59.91 144.71,59.99 144.58,60.02 144.24,59.69 144.58,59.35 144.71,59.38 144.82,59.46 144.89,59.49 144.97,59.46 145.08,59.38 145.21,59.35 145.45,59.45 145.54,59.69 145.54,59.71 145.61,59.8 145.72,59.78 146.15,59.35 146.17,59.24 146.08,59.18 144.1,59.18 143.63,58.7 143.63,58.42 143.57,58.32 143.46,58.35 143.08,58.73 143.05,58.82 143.11,58.89 143.27,59.01 143.33,59.21 143.24,59.44 143,59.54 142.81,59.48 142.69,59.32 142.61,59.26 142.52,59.28 141.72,60.09 141.72,60.67 141.76,60.76 141.85,60.77 141.9,60.76 141.96,60.75 142.19,60.85 142.29,61.08 142.28,61.16 142.26,61.23 142.25,61.24 142.25,63.23 142.69,63.23
GND on IN1 (solid shape): outline of 213 points within 172.35,72.59 187.17,76.02
GND on IN1 (solid shape): outline of 197 points within 175.21,87.54 180.42,90.02
GND on IN1 (solid shape): outline of 83 points within 203.67,7.69 208.4,13.6
GND on IN1 (solid shape): outline of 209 points within 68.65,105.43 77.87,111.63
GND on IN1 (solid shape): outline of 217 points within 28.81,31.01 31.75,35.1
GND on IN1 (solid shape): outline of 86 points within 68.2,82.37 70.89,85.78
GND on IN1 (solid shape): outline of 229 points within 20.91,16.96 29.6,28.52
GND on IN1 (solid shape): 128.97,27.16 129,27.21 129.06,27.2 129.21,27.04 129.91,27.04 130,26.98 129.98,26.87 129.86,26.69 129.82,26.48 129.82,26.17 129.83,26.06 129.87,25.95 130.06,25.27 130.76,25.34 130.99,25.34 131.27,25.63 131.36,25.66 131.44,25.6 131.64,25.38 131.93,25.3 132,25.27 132.03,25.2 132.03,23.93 131.83,23.72 131.76,23.75 131.68,23.76 131.44,23.67 131.34,23.43 131.35,23.35 131.38,23.27 131.29,23.18 131.13,22.73 131.39,22.33 131.34,22.17 131.38,22 131.29,21.91 131.14,21.66 131.15,21.36 131.14,21.27 131.06,21.23 130.03,21.23 129.93,21.28 129.94,21.39 129.99,21.48 130.01,21.59 129.68,21.92 129.34,21.59 129.36,21.48 129.41,21.39 129.42,21.28 129.32,21.23 129.29,21.23 129.21,21.27 129.2,21.36 129.21,21.66 129.06,21.92 128.97,22.01 129.01,22.17 128.96,22.33 129.22,22.73 129.06,23.19 128.97,23.28 129,23.52 128.85,23.72 128.85,24.52 128.25,25.12 128.22,25.23 128.32,25.29 128.42,25.29 128.95,25.69 128.71,26.31 128.76,26.48 128.71,26.65 128.9,26.84 128.97,27.11
GND on IN1 (solid shape): outline of 268 points within 102.18,20.7 111.04,25.07
GND on IN1 (solid shape): outline of 259 points within 192.81,69.04 197.58,74.95
GND on IN1 (solid shape): outline of 267 points within 168.13,66.87 176.38,71.94
GND on IN1 (solid shape): outline of 288 points within 191.02,8.95 194.8,14.96
GND on IN1 (solid shape): outline of 310 points within 193.87,38.45 202.38,42.35
GND on IN1 (solid shape): outline of 313 points within 52,2.37 75.25,9.03
GND on IN1 (solid shape): outline of 313 points within 133.69,92.17 147.88,96.37
GND on IN1 (solid shape): outline of 340 points within 68.68,66.01 72.93,71.29
GND on IN1 (solid shape): outline of 328 points within 170.61,83.68 184.57,89.47
GND on IN1 (solid shape): outline of 317 points within 79.24,78.57 84.79,87.7
GND on IN1 (solid shape): outline of 325 points within 155.24,90.78 174.93,95.56
GND on IN1 (solid shape): outline of 356 points within 47.57,96.69 87.33,106.44
GND on IN1 (solid shape): outline of 353 points within 60.15,66.62 68.84,75.57
GND on IN1 (solid shape): outline of 453 points within 26.95,51.83 36.85,57.42
GND on IN1 (solid shape): outline of 460 points within 190.1,92.9 195.67,101.05
GND on IN1 (solid shape): outline of 170 points within 99.74,80.26 107.69,84.28
GND on IN1 (solid shape): outline of 479 points within 113.82,21.23 120.55,45.93
GND on IN1 (solid shape): outline of 492 points within 20.93,54.3 47.61,63.71
GND on IN1 (solid shape): outline of 565 points within 121.34,21.23 128.06,34.73
GND on IN1 (solid shape): outline of 621 points within 98.99,21.37 115.55,53.35
GND on IN1 (solid shape): outline of 621 points within 182.69,54.92 197.16,62.06
GND on IN1 (solid shape): outline of 765 points within 202.66,42.37 216.83,68.39
GND on IN1 (solid shape): outline of 827 points within 132.3,21.23 143.94,29.12
GND on IN1 (solid shape): outline of 829 points within 133.8,73.49 141.8,80.87
GND on IN1 (solid shape): outline of 806 points within 86.43,83.69 119.4,92.95
GND on IN1 (solid shape): outline of 890 points within 127.59,96.51 172.18,103.62
GND on IN1 (solid shape): outline of 1619 points within 156.47,21.42 176.23,30.38
GND on IN1 (solid shape): outline of 3309 points within 56.98,20.61 92.96,38.64
GND on IN1 (solid shape): outline of 3413 points within 23.95,6.82 73.38,28.01
GND on IN1 (solid shape): outline of 3741 points within 82.56,96.9 131.73,110.78
GND on IN1 (solid shape): outline of 4600 points within 93.47,63.6 145.78,75.01
GND on IN1 (solid shape): outline of 9921 points within 0.51,0.51 218.33,119.74
GND on SVCC (solid shape): 214.66,116.06 214.67,115.83 214.71,115.6 214.31,115.71 213.89,115.75 212.24,115.07 211.56,113.42 211.56,104.02 212.21,102.4 213.79,101.69 213.55,101.26 213.41,100.78 212.08,100.78 211.51,101.08 210.87,101.18 208.38,101.18 207.67,101.55 206.87,101.68 205.08,100.94 204.34,99.15 204.34,93.42 203.96,93.04 195.18,93.04 195.02,93.19 195.02,94.73 196.92,96.63 197.07,96.76 197.13,96.95 197.11,97.06 197.05,97.16 197.05,97.28 197.15,97.52 197.05,97.76 197.05,105.1 197.12,105.17 201.08,105.17 202.12,105.37 203.01,105.95 203.04,105.98 204.61,107.55 204.64,107.58 205.22,108.47 205.42,109.51 205.42,113.33 206.07,113.79 206.32,114.55 206.29,114.86 206.17,115.15 209.24,118.22 214.66,118.22
GND on SVCC (solid shape): outline of 2981 points within 24.33,12.39 184.38,112.37
GND on IN2 (solid shape): 91.72,11.96 91.72,11.61 91.57,11.46 88.97,11.46 88.84,11.59 88.84,11.87 89.03,12.06 91.62,12.06
GND on IN2 (solid shape): 196.97,36.25 196.87,36.14 193.44,36.14 193.27,36.32 193.27,38.03 193.42,38.18 196.97,38.18
GND on IN2 (solid shape): 78.38,103.83 78.38,102.41 77.98,102 67.49,102 67.45,102.04 67.45,104.4 67.59,104.54 77.67,104.54
GND on IN2 (solid shape): 92.08,75.99 92.08,73.03 92,72.95 91.55,72.95 91.48,73.02 91.48,75.91 91.62,76.05 92.02,76.05
GND on IN2 (solid shape): 165.41,81.68 165.44,81.67 165.46,81.65 166.6,80.52 166.6,79.77 166.42,79.59 165.73,79.59 165.41,79.91
GND on IN2 (solid shape): 202.92,7.08 202.92,6.73 202.66,6.47 201.32,6.47 201.16,6.63 201.16,7.01 201.38,7.24 202.77,7.24
GND on IN2 (solid shape): 160.16,63.74 160.16,62.36 160.09,62.27 159.98,62.29 159.38,62.89 159.38,63.93 159.68,64.22
GND on IN2 (solid shape): 181.93,34.65 181.93,34.53 181.9,34.49 181.85,34.5 181.19,35.16 180.59,35.16 180.3,35.45 180.3,36.01 180.43,36.15
GND on IN2 (solid shape): 78.97,67.94 79.08,67.97 79.14,67.87 79.14,66.03 78.49,65.38 77.99,65.38 77.81,65.56 77.81,66.79
GND on IN2 (solid shape): 81.46,67.62 81.57,67.64 81.64,67.55 81.64,65.3 81.47,65.14 81.07,65.14 80.88,65.33 80.88,67.03
GND on IN2 (solid shape): 107.63,78.94 106.6,77.91 103.01,77.91 102.91,77.97 102.93,78.08 103.28,78.43 106.95,78.43 107.51,78.99 107.58,78.99
GND on IN2 (solid shape): 169.43,67.07 169.49,67.08 169.55,67.05 169.9,66.7 169.9,64.21 169.84,64.12 169.72,64.14 169.43,64.43
GND on IN2 (solid shape): 163.62,102.03 163.69,101.94 163.78,101.87 164.55,101.1 164.55,95.13 163.17,93.75 163.17,93.73 163.11,93.7 162.26,94.55 162.26,97.79 161.36,98.69 156.25,98.69 155.87,99.07 155.87,99.81 158.42,102.36 163.29,102.36
GND on IN2 (solid shape): 208.99,12.71 209.1,12.73 209.16,12.64 209.16,12.36 209.36,12.16 209.36,11.43 208.73,10.8 208.67,10.86 208.69,10.92 208.69,10.94 208.69,12.41
GND on IN2 (solid shape): 106.72,10.78 107.71,10.78 107.86,10.63 108.15,10.63 108.16,10.63 109.25,10.63 109.45,10.44 109.45,10.13 109.27,9.95 108.2,9.95 107.88,10.27 106.84,10.27 106.83,10.28 106.3,10.28 105.87,10.72 103.66,10.72 103.4,10.97 103.4,12.61 103.55,12.76 104.74,12.76
GND on IN2 (solid shape): 203.5,25.4 204.12,25.4 204.94,24.57 204.94,24.07 204.88,23.97 204.77,24 204.38,24.38 202.46,24.38 201.88,24.97 201.88,26.12 201.95,26.2 202.7,26.2
GND on IN2 (solid shape): 76.05,69.74 76.14,69.68 76.12,69.57 75.75,69.2 75.32,69.2 73.62,67.5 73.57,67.49 73.54,67.54 73.54,67.57 74.86,68.9 74.86,69.18 75.43,69.74
GND on IN2 (solid shape): 84.94,74.51 85.05,74.53 85.11,74.43 85.11,73.33 79.58,67.8 79.47,67.78 79.41,67.88 79.41,68.13 81.06,69.78 81.06,70.63
GND on IN2 (solid shape): 199.57,63.52 199.61,63.56 199.66,63.55 199.73,63.48 201.1,63.48 202.01,62.57 202.04,62.46 201.94,62.4 201.68,62.4 201.21,62.87 199.88,62.87 199.57,63.17
GND on IN2 (solid shape): 97.25,84 97.36,84.02 97.43,83.93 97.43,83.25 96.84,82.66 96.84,81.79 96.36,81.31 96.25,81.29 96.19,81.39 96.19,81.58 96.59,81.99 96.59,83.34
GND on IN2 (solid shape): 165.64,64.15 165.64,61.61 164.54,60.5 164.42,60.48 164.36,60.57 164.36,61.37 164.73,61.74 164.73,64.24 164.53,64.44 164.51,64.55 164.6,64.61 165.18,64.61
GND on IN2 (solid shape): 171.51,71.51 171.57,71.61 171.68,71.59 171.99,71.27 171.99,68.82 171.93,68.72 171.82,68.74 171.23,69.33 171.23,69.94 171.51,70.22
GND on IN2 (solid shape): 162.83,64.82 162.89,64.92 163,64.89 163.46,64.43 164.15,64.43 164.46,64.13 164.46,61.85 164.09,61.48 164.09,60.53 164.03,60.44 163.92,60.46 162.65,61.73 162.65,64.29 162.83,64.47
GND on IN2 (solid shape): 99.9,86.14 99.9,86.13 99.99,85.96 100.16,85.86 100.17,85.82 100.19,85.78 100.19,85.68 100.1,85.64 99.55,85.64 99.29,85.9 98.28,85.9 96.01,83.62 95.7,83.93 95.7,84.76 97.37,86.43 99.61,86.43
GND on IN2 (solid shape): 106.55,79.44 106.62,79.41 106.65,79.35 106.6,79.25 106.58,79.14 106.58,79.1 106.59,79.03 106.46,78.9 103.37,78.9 103.28,78.96 103.31,79.07 103.68,79.44
GND on IN2 (solid shape): 22.53,34.24 22.53,33.46 21.52,32.45 21.52,27.41 21.49,27.35 21.43,27.31 20.88,27.87 20.88,29.36 20.99,29.61 20.88,29.87 20.88,30.31 20.9,30.33 20.9,34.24 21.71,35.06
GND on IN2 (solid shape): 80.41,63.97 80.42,63.95 80.43,63.93 80.52,63.72 80.73,63.62 80.82,63.55 80.79,63.44 80.1,62.75 80.1,62.41 77,59.31 76.53,59.31 76.38,59.45 76.38,59.73 79.13,62.47 79.13,62.69
GND on IN2 (solid shape): 88.51,66.84 88.51,66.56 87.69,65.75 86.82,65.75 86.34,65.26 86.25,65.24 86.17,65.29 86.09,65.41 85.98,65.48 85.92,65.55 85.94,65.65 86.83,66.53 87.74,66.53 88.16,66.95 88.39,66.95
GND on IN2 (solid shape): 77.19,73.01 77.28,72.95 77.26,72.84 75.18,70.75 74.32,70.75 74.22,70.81 74.25,70.92 74.36,71.04 74.36,72.07 74,72.43 73.98,72.55 74.07,72.61 75.13,72.61 75.53,73.01
GND on IN2 (solid shape): 169.34,81.69 169.45,81.67 169.71,81.41 169.71,80.53 169.45,80.27 169.45,79.6 169.29,79.45 168.91,79.45 168.74,79.63 168.74,81.17 168.77,81.25 168.86,81.27 168.9,81.27 168.93,81.26 169.17,81.36 169.28,81.6
GND on IN2 (solid shape): 101.02,81.71 101.13,81.73 101.2,81.63 101.2,80.23 100.24,79.27 99.51,79.27 99.27,79.03 99.18,79.01 99.1,79.07 99.01,79.22 98.85,79.31 98.77,79.38 98.79,79.48
GND on IN2 (solid shape): 53.92,11.68 56.04,11.68 56.66,11.07 57.22,11.07 57.26,11.03 57.25,10.98 57.21,10.93 55.14,10.93 54.5,10.93 54.48,10.92 54.41,10.88 54.34,10.87 54.28,10.85 54.23,10.84 54.12,10.87 54.03,10.93 50.64,10.93 50.17,11.4 48.46,11.4 48.25,11.61 48.25,12.15 48.52,12.41 53.19,12.41
GND on IN2 (solid shape): 129.04,78.86 129.07,78.91 129.13,78.9 129.3,78.72 129.3,78.28 128.94,77.92 128.94,77.18 128.95,77.16 128.98,77.1 128.99,77.03 128.98,76.96 128.96,76.9 128.94,76.87 128.94,76.77 128.64,76.47 126.48,76.47 125.81,75.8 125.7,75.78 125.64,75.87 125.64,76.36 126.57,77.28 127.13,77.28 128.47,78.62 128.87,78.62 129.04,78.79
GND on IN2 (solid shape): 162.03,73.14 162.09,73.15 162.12,73.1 162.12,70.85 163.05,69.92 163.05,68.75 163,68.67 162.91,68.65 162.85,68.67 162.79,68.67 162.69,68.66 162.6,68.61 162.49,68.61 162.44,68.7 162.44,69.49 161.37,70.56 161.37,70.99 161.97,71.58 161.97,73.08
GND on IN2 (solid shape): 82.96,63.99 83.07,64.01 83.13,63.92 83.13,63.33 80.17,60.37 80.17,59.71 79.36,58.9 79.26,58.88 79.19,58.96 79.11,59.14 78.94,59.25 78.87,59.33 78.9,59.42 82,62.52 82,63.03
GND on IN2 (solid shape): 158.02,70.85 158.13,70.87 158.19,70.78 158.19,70.48 158.25,70.42 158.25,69.19 157.87,68.81 157.76,68.81 157.63,68.93 157.63,69.51 157.84,69.72 157.91,69.83 157.94,69.96 157.87,70.17 157.68,70.29 157.61,70.36 157.63,70.46
GND on IN2 (solid shape): 142.68,58.92 142.71,58.97 142.76,58.96 142.87,58.89 143,58.86 143.07,58.87 143.14,58.89 143.24,58.89 143.29,58.8 143.29,58.09 143.61,57.77 143.61,57.38 143.3,57.06 143.04,57.06 142.95,57.12 142.97,57.23 143.05,57.31 143.05,58.44 142.68,58.81
GND on IN2 (solid shape): 189.49,33.78 189.49,31.93 189.42,31.83 189.31,31.86 188.95,32.22 188.95,32.94 186.8,35.09 186.77,35.18 186.83,35.25 186.98,35.38 187.03,35.57 187.02,35.65 186.99,35.73 186.99,35.83 187.08,35.88 187.39,35.88
GND on IN2 (solid shape): 200.23,61.9 200.03,61.78 199.96,61.57 200.06,61.32 200.3,61.22 200.36,61.23 200.42,61.24 200.42,59.22 200.92,58.71 200.92,55.36 200.72,55.15 199.83,55.15 199.15,54.47 199.04,54.45 198.98,54.54 198.98,61.85 199.26,62.13 200,62.13
GND on IN2 (solid shape): 173.19,76.27 173.3,76.29 173.36,76.2 173.36,75.38 173.46,75.28 173.46,74.35 173.48,74.28 173.49,74.24 173.48,74.2 173.46,74.14 173.46,74.12 173.39,74.04 173.06,73.71 173.06,73.47 173.07,73.46 173.07,72.4 173,72.31 172.89,72.33 172.84,72.38 172.84,75.92
GND on IN2 (solid shape): 191.29,37.31 191.38,37.25 191.36,37.14 191.3,37.04 191.28,36.92 191.38,36.68 191.62,36.58 191.72,36.59 191.81,36.63 191.91,36.63 191.96,36.54 191.96,35.28 191.66,34.97 190.62,36.01 190.62,37.18 190.75,37.31
GND on IN2 (solid shape): 186.76,43.31 186.82,43.41 186.93,43.39 187.02,43.3 187.02,39.45 188.76,37.71 188.76,36.92 188.7,36.83 188.59,36.85 188.29,37.15 187.87,37.57 187.87,37.84 187.06,38.65 187.07,38.68 187.08,38.73 187.09,38.78 187,39.01 186.78,39.13 186.76,39.13 186.71,39.18 186.76,39.22
GND on IN2 (solid shape): 154.74,54.57 155.31,54.57 155.41,54.5 155.38,54.39 155.29,54.27 155.26,54.13 155.31,53.95 155.44,53.83 155.47,53.81 155.47,53.66 155.7,53.43 155.72,53.32 155.63,53.26 155.53,53.26 152.48,56.31 152.46,56.42 152.55,56.48 152.83,56.48
GND on IN2 (solid shape): 159.42,60.1 159.48,60.19 159.59,60.17 160.36,59.4 160.36,58.97 159.9,58.51 159.9,56.49 159.72,56.49 159.19,57.02 159.19,57.09 159.26,57.09 159.27,57.08 159.35,57.05 159.45,57.04 159.69,57.14 159.79,57.38 159.7,57.61 159.44,57.74 159.42,57.77
GND on IN2 (solid shape): 44.22,12.73 44.22,12.34 43.84,11.97 43.78,11.97 43.43,11.61 42.59,11.61 42.52,11.68 42.52,12.18 42.92,12.18 42.92,12.12 42.93,12.07 42.95,12.02 42.98,11.98 43.01,11.94 43.05,11.9 43.1,11.87 43.15,11.85 43.2,11.84 43.25,11.83 43.3,11.84 43.35,11.85 43.4,11.86 43.45,11.89 43.49,11.92 43.53,11.96 43.56,12 43.58,12.05 43.6,12.1 43.6,12.15 43.6,12.2 43.6,12.26 43.58,12.31 43.56,12.35 43.53,12.4 43.49,12.43 43.45,12.47 43.4,12.49 43.35,12.51 43.3,12.52 43.25,12.52 43.2,12.51 43.15,12.5 43.1,12.48 43.05,12.45 43.01,12.42 42.98,12.37 42.95,12.33 42.93,12.28 42.92,12.23 42.92,12.18 42.52,12.18 42.52,12.88 42.87,13.23 43.72,13.23
GND on IN2 (solid shape): 98.68,94.02 98.68,93.77 98.71,93.66 98.8,93.59 98.83,93.57 98.83,93.53 98.82,93.43 98.83,93.34 98.83,93.3 98.8,93.28 98.71,93.21 98.68,93.1 98.68,89.52 102.5,85.7 103.88,85.7 103.94,85.64 103.95,85.58 103.9,85.55 101.18,85.55 101.18,86.24 98.57,88.86 98.57,93.83 98.49,93.91 98.49,93.94 98.48,94.03 98.45,94.11 98.43,94.14 98.49,94.21
GND on IN2 (solid shape): 141.92,85.49 142.02,85.42 141.99,85.31 141.18,84.5 141.18,84.44 141.18,83.59 141.06,83.48 141.03,83.27 141.04,83.22 141.03,83.13 140.94,83.09 140.81,83.09 140.75,83.11 140.71,83.15 140.74,83.22 140.74,83.29 140.7,83.45 140.59,83.57 140.56,83.58 140.56,84.7 141.34,85.49
GND on IN2 (solid shape): 163.48,67.8 163.53,67.81 163.57,67.76 163.57,67.74 164.66,66.64 164.66,65.95 164.61,65.87 164.51,65.86 164.44,65.89 164.36,65.9 164.23,65.87 164.11,65.79 164.04,65.76 163.96,65.79 163.85,65.87 163.71,65.9 163.64,65.9 163.57,65.87 163.47,65.88 163.42,65.96 163.42,67.74
GND on IN2 (solid shape): 193.8,75.35 193.84,75.27 193.84,74.7 193.58,74.44 193.58,73.46 193.58,73.38 193.58,71.43 193.52,71.33 193.41,71.35 192.87,71.89 192.87,74.55 193.13,74.81 193.16,74.81 193.21,74.79 193.26,74.79 193.5,74.89 193.6,75.13 193.6,75.18 193.59,75.22 193.6,75.3 193.66,75.35 193.7,75.36
GND on IN2 (solid shape): 176.91,5.81 176.91,5.51 176.01,4.61 175.36,4.61 175.27,4.66 175.27,4.76 175.3,4.83 175.31,4.91 174.97,5.26 174.62,4.91 174.63,4.83 174.66,4.76 174.66,4.66 174.57,4.61 172.82,4.61 172.62,4.81 172.62,5.55 172.77,5.7 174.69,5.7 174.98,5.99 176.74,5.99
GND on IN2 (solid shape): 142.54,55.46 142.59,55.55 142.69,55.55 142.74,55.53 142.8,55.51 142.86,55.47 142.88,55.4 142.88,55.35 142.98,55.11 143.22,55.01 143.29,55.02 143.36,55.04 143.45,55.03 143.5,54.94 143.5,54.11 144.44,53.16 144.46,53.05 144.37,52.99 144.15,52.99 142.54,54.6
GND on IN2 (solid shape): 148.83,56.26 148.82,56.23 148.81,56.18 148.8,56.13 148.9,55.89 149.15,55.79 149.34,55.85 149.46,56 149.54,56.06 149.63,56.03 150.6,55.06 151.59,55.06 152.6,54.05 152.62,53.94 152.53,53.88 151.11,53.88 150.17,54.82 149.74,54.82 148.15,56.41 148.13,56.52 148.22,56.58 148.51,56.58
GND on IN2 (solid shape): 176.34,76.66 176.36,76.65 176.46,76.56 176.5,76.43 176.49,76.35 176.46,76.29 176.45,76.26 176.45,75.56 177.26,74.75 177.26,72.34 177.23,72.31 177.12,72.28 177.05,72.38 177.05,74.67 175.36,76.37 175.33,76.46 175.4,76.53 175.55,76.64 175.62,76.8 175.67,76.87 175.75,76.88 175.8,76.87 175.84,76.87 175.94,76.88 176.03,76.92 176.06,76.94
GND on IN2 (solid shape): 53.61,13.12 53.69,13.08 53.77,13.07 53.85,13.03 53.87,12.94 53.86,12.91 53.86,12.88 53.96,12.63 54.2,12.53 54.38,12.58 54.51,12.73 54.64,12.73 55.25,12.12 55.27,12.01 55.18,11.95 54.03,11.95 53.3,12.68 48.41,12.68 48.06,12.33 46.8,12.33 46.74,12.39 46.11,12.39 46.01,12.45 46.04,12.56 46.4,12.92 52.28,12.92 52.48,13.12
GND on IN2 (solid shape): 68.11,57.95 68.19,57.92 68.23,57.92 68.31,57.9 68.34,57.82 68.34,55.35 64.78,51.79 64.78,51.77 64.75,51.76 64.62,51.63 64.57,51.45 64.58,51.39 64.59,51.33 64.58,51.24 64.5,51.19 64.06,51.19 63.97,51.26 63.99,51.37 67.87,55.25 67.87,57.52 67.85,57.55 67.81,57.62 67.8,57.7 67.87,57.88 68.05,57.96
GND on IN2 (solid shape): 146.37,57.06 146.43,57.15 146.54,57.13 149.48,54.19 149.91,54.19 150.18,53.92 150.2,53.81 150.11,53.75 147.7,53.75 146.51,54.94 145.82,54.94 145.7,55.07 145.75,55.12 145.77,55.12 146.01,55.22 146.11,55.46 146.09,55.58 146.02,55.69 146,55.76 146.03,55.83 146.11,55.95 146.14,56.09 146.12,56.22 146.04,56.33 146.37,56.67
GND on IN2 (solid shape): 141.14,58.12 141.23,58.09 141.57,57.75 141.57,57.53 140.37,56.34 140.37,54.75 140.31,54.65 140.2,54.67 140.07,54.81 140.07,57.49 140.13,57.58 140.24,57.56 140.42,57.39 140.46,57.39 140.47,57.36 140.59,57.24 140.75,57.2 140.97,57.3 141.06,57.52 141.02,57.67 140.92,57.79 140.91,57.85 140.94,57.9 141.02,57.97 141.06,58.06
GND on IN2 (solid shape): 104.75,84.51 104.76,84.5 104.8,84.39 104.87,84.31 104.87,84.28 104.86,84.25 104.78,84.14 104.75,84 104.76,83.92 104.58,83.74 104.58,83.32 103.67,82.41 103.6,82.38 103.53,82.41 103.5,82.51 103.45,82.61 103.42,82.68 103.45,82.75 103.51,82.84 103.53,82.96 103.52,83.03 103.94,83.45 103.94,84.85 103.68,85.11 103.65,85.22 103.75,85.29 103.98,85.29
GND on IN2 (solid shape): 121.53,11.09 121.74,11.09 121.83,11.04 121.83,10.94 121.81,10.87 121.8,10.8 121.9,10.55 122.14,10.45 122.19,10.46 122.24,10.47 122.27,10.48 122.62,10.13 122.64,10.02 122.55,9.96 121.34,9.96 120.96,10.34 120.93,10.44 121,10.51 121.17,10.64 121.24,10.84 121.22,10.94 121.18,11.03 121.17,11.14 121.26,11.19 121.43,11.19
GND on IN2 (solid shape): 173.8,61.69 173.8,61.7 173.81,61.73 173.83,61.76 173.85,61.78 173.88,61.79 173.91,61.79 173.94,61.78 173.97,61.77 173.98,61.76 175.7,60.04 175.7,58.49 175.7,58.47 175.69,58.44 175.68,58.42 175.65,58.4 175.63,58.39 175.6,58.38 175.57,58.39 175.54,58.4 175.53,58.41 174.29,59.66 174.28,59.67 174.26,59.7 174.26,59.72 174.01,59.96 174.01,60.14 173.99,60.16 173.99,60.17 173.8,60.37 173.8,60.38 174.19,60.38 174.19,60.33 174.2,60.28 174.22,60.23 174.25,60.18 174.28,60.14 174.32,60.11 174.37,60.08 174.42,60.06 174.47,60.04 174.52,60.04 174.57,60.04 174.62,60.05 174.67,60.07 174.72,60.09 174.76,60.12 174.8,60.16 174.83,60.2 174.85,60.25 174.87,60.3 174.88,60.35 174.88,60.41 174.87,60.46 174.85,60.51 174.83,60.55 174.8,60.6 174.76,60.64 174.72,60.67 174.67,60.69 174.62,60.71 174.57,60.72 174.52,60.72 174.47,60.72 174.42,60.7 174.37,60.68 174.32,60.65 174.28,60.62 174.25,60.58 174.22,60.53 174.2,60.48 174.19,60.43 174.19,60.38 173.8,60.38
GND on IN2 (solid shape): 156.68,50.39 156.7,50.29 156.62,50.22 156.41,50.1 156.32,49.88 156.42,49.64 156.67,49.53 156.89,49.62 157.01,49.83 157.07,49.92 157.18,49.89 157.36,49.71 157.36,48.52 157.29,48.43 157.18,48.45 156.93,48.71 156.93,49.03 156.59,49.37 156.32,49.37 154.64,51.05 154.61,51.16 154.71,51.22 155.85,51.22
GND on IN2 (solid shape): 186.42,54.77 186.42,51.6 186.45,51.57 186.45,51.45 187.35,50.54 187.35,48.93 187.32,48.91 187.32,47.96 187.35,47.94 187.35,47.9 189.15,46.1 189.15,45.74 189.35,45.54 189.35,39.95 190.06,39.24 190.06,37.89 190.06,37.89 190.06,36.63 190,36.54 189.89,36.56 189.56,36.88 189.56,38.04 188.62,38.98 188.62,44.14 188.51,44.25 188.48,44.32 188.52,44.4 188.6,44.51 188.63,44.65 188.53,44.89 188.29,44.99 188.15,44.96 188.03,44.88 187.96,44.85 187.88,44.88 187.25,45.51 187.25,46.05 187.25,46.07 186.82,46.5 186.82,47.4 186.28,47.94 186.28,50.87 185.72,51.43 185.72,54.73 185.93,54.94 186.26,54.94
GND on IN2 (solid shape): 150.33,67.03 150.43,66.97 150.54,66.95 150.6,66.96 150.62,66.95 150.65,66.94 150.66,66.9 150.66,65.97 150.11,65.41 150.07,65.37 150.07,64.14 150.03,64.07 149.95,64.05 149.83,64.15 149.68,64.19 149.63,64.19 149.6,64.22 149.59,64.26 149.38,64.26 149.12,64.51 149.12,65.38 148.94,65.56 148.92,65.61 148.92,65.94 148.99,66.01 149.25,66.01 149.37,65.89 149.37,65.89 149.43,65.8 149.52,65.74 149.6,65.71 149.66,65.71 149.87,65.78 149.97,65.98 149.97,65.99 149.97,66.08 149.94,66.17 149.94,66.18 149.94,66.76 150.22,67.05 150.32,67.05
GND on IN2 (solid shape): 142.17,73.01 142.24,72.98 142.33,72.92 142.44,72.9 142.51,72.87 142.54,72.81 142.65,72.61 142.86,72.53 143.08,72.62 143.18,72.84 143.17,72.88 143.24,72.91 143.31,72.88 143.7,72.49 143.7,68.47 143.63,68.38 143.52,68.4 143.18,68.74 143.18,71.8 143.15,71.84 142.65,72.34 142.61,72.38 142.26,72.38 141.89,72.75 141.86,72.81 141.89,72.88 142,72.91 142.1,72.98
GND on IN2 (solid shape): 144.55,73.25 146.74,73.25 146.75,73.23 146.81,73.16 146.88,73.11 146.9,73.09 146.9,72.85 146.54,72.49 145.94,72.49 145.87,72.52 145.84,72.59 145.91,72.69 145.94,72.82 145.62,73.13 145.3,72.82 145.33,72.69 145.4,72.59 145.37,72.52 145.3,72.49 144.77,72.49 144.34,72.06 144.26,72.03 144.19,72.06 144.19,72.61 144.18,72.66 144.15,72.7 143.08,73.77 143.08,74.54 142.88,74.75 142.93,74.79 143,74.81
GND on IN2 (solid shape): 185.33,23.16 185.44,23.18 185.5,23.09 185.5,22.68 185.46,22.6 185.36,22.58 185.31,22.6 185.25,22.6 184.93,22.29 185.25,21.97 185.31,21.97 185.36,21.99 185.46,21.98 185.5,21.89 185.5,20.94 186.18,20.26 186.21,20.2 186.2,20.14 186.05,20.03 185.99,19.84 186.01,19.73 186.07,19.63 186.1,19.56 186.08,19.5 186.03,19.43 186.01,19.35 184.61,20.75 184.61,22.44
GND on IN2 (solid shape): 155.65,68.78 155.72,68.81 155.8,68.77 155.8,67.95 155.81,67.9 155.84,67.86 156.18,67.52 156.18,66.48 156.93,65.73 156.93,65.32 156.86,65.23 156.75,65.26 155.57,66.44 155.55,66.48 155.54,66.53 155.71,66.65 155.78,66.84 155.68,67.06 155.46,67.16 155.42,67.15 155.39,67.17 155.37,67.19 155.38,67.24 155.32,67.43 155.15,67.54 155.14,67.58 155.17,67.68 155.18,67.75 155.12,67.93 154.97,68.04 154.98,68.09 155,68.13
GND on IN2 (solid shape): 139.21,61.83 139.2,61.8 139.18,61.75 139.18,61.7 139.27,61.48 139.5,61.39 139.62,61.41 139.72,61.47 139.77,61.48 139.8,61.44 139.8,55.06 139.74,54.97 139.63,54.99 139.04,55.59 139.04,57.79 139.09,57.88 139.18,57.88 139.27,57.84 139.36,57.83 139.6,57.94 139.7,58.18 139.6,58.42 139.36,58.52 139.27,58.51 139.19,58.48 139.09,58.48 139.04,58.56 139.04,61.83 139.04,61.87 139.1,61.94
GND on IN2 (solid shape): 144.34,65.67 144.34,65.42 144.32,65.36 144.27,65.33 144.19,65.36 144.1,65.37 143.79,65.05 144.1,64.73 144.19,64.75 144.27,64.78 144.32,64.75 144.34,64.69 144.34,63.84 143.73,63.22 143.62,63.2 143.55,63.29 143.55,63.89 143.63,63.98 143.64,64.03 143.64,64.37 143.63,64.42 143.6,64.46 143.36,64.7 143.33,64.77 143.35,64.84 143.58,64.93 143.67,65.15 143.63,65.31 143.52,65.42 143.48,65.46 144.01,66
GND on IN2 (solid shape): 111.56,16.48 111.65,16.43 111.66,16.33 111.63,16.26 111.62,16.18 111.72,15.93 111.96,15.83 112.09,15.86 112.21,15.94 112.28,15.97 112.35,15.94 112.46,15.86 112.6,15.83 112.73,15.86 112.84,15.94 112.91,15.97 112.99,15.94 113.1,15.86 113.23,15.83 113.36,15.86 113.48,15.94 113.55,15.97 113.62,15.94 113.73,15.86 113.87,15.83 114.01,15.87 114.13,15.95 114.2,15.99 114.28,15.96 115.03,15.21 115.03,14.28 111.38,14.28 111.05,14.61 111.05,16.29 111.25,16.48
GND on IN2 (solid shape): 143.79,96.52 143.79,96.11 144.61,95.29 144.61,94.35 145.3,93.65 146.3,93.65 146.31,93.63 146.44,93.49 146.62,93.44 146.96,93.79 146.62,94.13 146.44,94.08 146.31,93.95 146.3,93.92 145.41,93.92 145.11,94.23 145.08,94.33 145.17,94.4 145.39,94.51 145.47,94.8 145.46,94.86 145.47,94.95 145.55,95 146.49,95 148.14,93.34 148.16,93.23 148.07,93.17 140.11,93.17 139.32,93.97 139.33,94 139.34,94.05 139.34,94.1 139.34,94.15 139.33,94.2 139.32,94.23 139.96,94.87 139.96,96.84 140.52,97.41 140.8,97.69 142.62,97.69
GND on IN2 (solid shape): 98.15,75.85 98.24,75.79 98.22,75.68 97.77,75.23 97.71,75.23 97.47,74.64 98.05,74.89 98.04,74.97 98.01,75.05 98,75.08 98.03,75.12 98.14,75.14 98.21,75.04 98.21,74.18 97.79,73.76 97.79,73.01 97.76,73 97.7,72.94 97.65,72.88 97.63,72.85 97.13,72.85 97.04,72.91 97.06,73.02 97.12,73.12 97.14,73.24 97.04,73.48 96.79,73.58 96.74,73.58 96.69,73.57 96.66,73.56 96.47,73.75 96.47,74.43 96.79,74.75 96.79,75.39 97.25,75.85
GND on IN2 (solid shape): 167.64,76.17 167.71,76.26 167.82,76.24 168.14,75.91 168.14,75.28 168.06,75.17 168.03,75.03 168.13,74.79 168.37,74.69 168.57,74.75 168.69,74.9 168.77,74.96 168.86,74.94 170.23,73.57 170.23,72.64 169.94,72.35 169.89,72.4 169.89,72.42 169.79,72.66 169.55,72.76 169.38,72.71 169.25,72.59 169.16,72.54 169.08,72.59 168.95,72.71 168.78,72.76 168.54,72.66 168.44,72.41 168.45,72.33 168.48,72.26 168.49,72.23 168.43,72.16 168.28,72.32 168.28,73.75 167.43,74.6 167.43,75.96
GND on IN2 (solid shape): outline of 89 points within 184.94,91.05 186.97,94.17
GND on IN2 (solid shape): 206.28,27.24 206.35,27.21 206.38,27.15 206.27,27.03 206.23,26.88 206.33,26.65 206.55,26.56 206.61,26.57 206.67,26.58 206.74,26.58 206.79,26.54 206.91,26.42 207.07,26.38 207.39,26.69 207.07,27.01 206.98,27 206.9,26.96 206.87,26.98 206.85,27 206.82,27.05 206.78,27.1 206.79,27.19 206.88,27.24 208.29,27.24 208.94,26.58 208.97,26.47 208.88,26.41 208.32,26.41 208.17,26.25 206.57,26.25 205.75,27.07 205.73,27.18 205.83,27.24
GND on IN2 (solid shape): 154.91,76.57 154.97,76.54 155.57,75.94 155.57,75.37 155.5,75.32 155.45,75.26 155.43,75.23 155.39,75.22 155.28,75.3 155.14,75.33 154.92,75.24 154.83,75.02 154.83,74.95 154.86,74.88 154.86,74.37 154.8,74.32 154.75,74.37 154.75,74.39 154.65,74.62 154.43,74.71 154.3,74.68 154.19,74.6 154.11,74.62 154.08,74.69 154.08,75.49 154.04,75.52 154.03,75.57 154.08,75.61 154.28,75.61 154.47,75.8 154.59,75.78 154.82,75.87 154.91,76.1 154.88,76.23 154.8,76.34 154.78,76.4 154.8,76.46 154.83,76.5 154.85,76.55
GND on IN2 (solid shape): outline of 105 points within 170.13,65.68 171.82,69.19
GND on IN2 (solid shape): outline of 108 points within 200.3,38.45 202.38,41.86
GND on IN2 (solid shape): 186.76,15.29 186.85,15.26 186.89,15.23 186.89,15.21 187,15.01 187.21,14.93 187.41,15 187.52,15.19 187.57,15.19 187.61,15.17 187.61,13.55 187.43,13.36 187.13,13.36 187.07,13.41 187.06,13.49 187.07,13.54 187.08,13.59 186.99,13.82 186.76,13.91 186.65,13.89 186.56,13.83 186.49,13.81 186.42,13.84 186.14,14.12 186.13,14.12 186.07,14.14 186.03,14.18 186.1,14.28 186.13,14.41 186.16,14.48 186.44,14.61 186.52,14.83 186.52,14.89 186.5,14.95 186.5,15.02 186.55,15.07 186.63,15.14 186.69,15.23
GND on IN2 (solid shape): outline of 92 points within 137.47,63.44 138.97,66.47
GND on IN2 (solid shape): 131.68,102.69 131.68,102.35 131.66,102.29 131.65,102.22 131.65,102.17 131.63,102.1 131.56,102.07 131.49,102.09 131.42,102.1 131.17,102 131.07,101.76 131.08,101.68 131.11,101.61 131.11,99.99 129.54,99.99 128.95,100.57 122.92,100.57 122.28,101.2 121.94,101.2 121.78,101.2 121.74,101.16 121.64,101.09 121.57,100.99 120.86,100.29 120.86,99.55 120.86,98.56 125.47,93.96 125.47,92.59 124.47,91.59 124.13,91.59 121.78,93.94 121.31,94.41 120.42,94.41 119.77,95.06 119.56,95.06 119.47,95.11 119.47,95.21 119.51,95.29 119.42,95.62 119.17,95.72 119.04,95.7 118.93,95.62 118.86,95.59 118.78,95.62 118.67,95.7 118.54,95.72 118.38,95.68 118.25,95.57 118.21,95.55 118.17,95.57 118.13,95.62 120.07,97.55 120.07,99.94 123.26,103.13 131.24,103.13
GND on IN2 (solid shape): 143.32,64.36 143.32,64.04 143.29,64 143.29,63.56 143.27,63.5 143.22,63.46 143.13,63.51 143.03,63.53 142.71,63.21 143.03,62.89 143.13,62.91 143.22,62.96 143.27,62.92 143.29,62.87 143.29,59.6 143.24,59.52 143.14,59.52 143.07,59.54 143,59.55 142.91,59.54 142.83,59.5 142.73,59.5 142.68,59.59 142.68,60.56 142.84,60.72 142.84,61.73 142.32,62.24 142.32,64.08 142.37,64.17 142.47,64.17 142.55,64.14 142.63,64.13 142.86,64.22 142.95,64.44 142.89,64.62 142.75,64.74 142.69,64.8 142.7,64.89 142.74,64.94
GND on IN2 (solid shape): 158.2,89.26 158.2,87.94 158.16,87.86 158.08,87.84 158.04,87.84 158,87.85 157.66,87.5 158,87.16 158.21,87.23 158.33,87.41 158.4,87.48 158.5,87.46 159.71,86.25 159.71,84.33 159.65,84.23 159.54,84.26 159.27,84.53 159.28,84.56 159.29,84.6 159.29,84.66 159.19,84.9 158.95,85 158.83,84.98 158.73,84.91 158.65,84.89 158.58,84.93 158.46,85.02 158.32,85.05 158.27,85.05 158.19,85.07 158.15,85.15 158.15,86.33 157.45,87.04 157.45,89.82 154.49,92.78 150.71,92.78 150.45,93.05 150.43,93.16 150.52,93.22 154.24,93.22
GND on IN2 (solid shape): outline of 102 points within 158.15,77.36 161.15,84.47
GND on IN2 (solid shape): 108.04,80.13 108.1,80.1 108.8,79.4 108.8,78.05 108.45,77.68 108.31,77.56 107.08,77.56 106.56,77.04 102.55,77.04 102.45,77.11 102.48,77.22 102.87,77.61 106.63,77.61 106.68,77.62 106.72,77.65 108.08,79.01 108.12,79 108.16,79 108.47,79.32 108.16,79.63 108.09,79.63 108.03,79.61 107.93,79.58 107.82,79.5 107.79,79.49 107.67,79.59 107.53,79.63 107.35,79.57 107.23,79.44 107.17,79.38 107.08,79.39 107.05,79.42 107.01,79.43 106.99,79.5 107.02,79.55 107.17,79.7 107.34,79.7 107.57,79.93 107.64,79.91 107.68,79.91 107.87,79.97 107.98,80.12
GND on IN2 (solid shape): outline of 113 points within 201.53,8.2 206.55,13.24
GND on IN2 (solid shape): 206.13,20.62 206.19,20.71 206.31,20.69 206.75,20.25 206.75,19.47 206.76,19.42 206.79,19.38 207.71,18.46 207.71,16.56 207.39,16.24 207.36,16.25 207.31,16.26 207.26,16.27 207.04,16.17 206.94,15.95 206.95,15.89 206.97,15.83 206.97,15.76 206.92,15.71 206.79,15.6 206.74,15.45 206.74,15.43 206.69,15.38 206.64,15.43 206.39,15.43 206.33,15.45 206.29,15.51 206.32,15.59 206.34,15.67 206.26,15.87 206.08,15.98 206.07,16.04 206.1,16.1 206.83,16.84 207.36,17.36 207.36,17.98 207.38,18 207.5,18.12 207.54,18.27 207.22,18.59 206.9,18.27 206.95,18.12 207.06,18 207.09,17.98 207.09,17.47 206.31,16.69 206.19,16.67 206.13,16.76
GND on IN2 (solid shape): 173.6,56.27 173.63,56.23 173.63,54.83 174.11,54.35 174.11,52.7 174.08,52.62 174,52.6 173.97,52.6 173.9,52.59 173.84,52.57 173.77,52.58 173.71,52.63 173.58,52.78 173.39,52.84 173.05,52.5 173.39,52.15 173.46,52.16 173.52,52.18 173.6,52.18 173.65,52.12 173.78,51.97 173.97,51.91 174.15,51.97 174.28,52.11 174.35,52.17 174.44,52.14 175.9,50.69 175.9,49.71 175.83,49.61 175.72,49.63 173.7,51.66 173.37,51.66 173,52.02 173,52.03 172.88,52.2 172.67,52.27 172.6,52.26 172.52,52.24 172.42,52.24 172.38,52.33 172.38,54.89 173.46,55.97 173.46,56.21 173.51,56.24 173.54,56.26
GND on IN2 (solid shape): 120.02,106.84 120.04,106.73 119.94,106.67 119.92,106.67 119.68,106.08 120.26,106.33 120.26,106.35 120.32,106.45 120.43,106.43 121.53,105.34 121.68,105.34 121.77,105.28 121.76,105.17 121.72,105.08 121.7,104.98 121.8,104.73 122.04,104.63 122.22,104.68 122.35,104.82 122.36,104.84 122.95,104.84 123.86,103.93 128.86,103.93 128.88,103.9 129,103.77 129.18,103.72 129.38,103.78 129.51,103.95 129.52,103.98 130.66,103.98 130.67,103.97 130.96,103.97 131.14,103.8 131.14,103.64 131.06,103.56 123.08,103.56 120.52,101.01 120.41,100.99 120.35,101.08 120.35,104.14 117.33,107.16 117.31,107.27 117.4,107.34 119.53,107.34
GND on IN2 (solid shape): 56.24,6.4 56.48,6.55 56.71,6.4 56.76,6.33 56.84,6.31 57.14,6.31 57.23,6.37 57.25,6.4 57.34,6.51 57.48,6.55 57.62,6.51 57.71,6.4 57.75,6.31 57.8,6.31 58.14,6.31 58.23,6.37 58.25,6.4 58.34,6.51 58.48,6.55 58.66,6.48 58.73,6.3 58.7,6.17 58.61,6.08 58.52,5.94 58.58,5.78 59.48,4.88 59.5,4.84 59.5,4.78 56.94,4.78 56.67,5.05 56.64,5.08 56.52,5.05 56.48,5.04 56.3,5.12 56.22,5.3 56.23,5.34 56.26,5.46 56.23,5.49 55.58,6.14 55.56,6.25 55.65,6.31 56.11,6.31 56.19,6.33
GND on IN2 (solid shape): 107.49,82.33 107.56,82.3 107.59,82.23 107.53,82.12 107.5,82 107.52,81.89 107.58,81.79 107.61,81.72 107.58,81.66 107.52,81.56 107.5,81.45 107.54,81.31 107.63,81.2 107.67,81.11 107.62,81.03 107.52,80.91 107.48,80.76 107.49,80.68 107.52,80.61 107.53,80.54 107.49,80.48 107.47,80.46 107.41,80.44 107.34,80.46 107.24,80.52 107.14,80.54 106.91,80.45 106.82,80.22 106.82,80.17 106.83,80.12 106.84,80.09 106.69,79.94 103.74,79.94 103.7,80.01 103.73,80.09 103.95,80.3 106.15,80.3 106.61,80.77 106.61,81.82 106.65,81.9 106.73,81.92 106.84,81.82 106.99,81.78 107.21,81.87 107.31,82.1 107.3,82.18 107.26,82.25 107.3,82.31 107.36,82.33
GND on IN2 (solid shape): 162.96,83.14 163.06,83.14 163.11,83.05 163.11,80.87 163.07,80.86 162.89,80.73 162.82,80.53 162.92,80.28 163.16,80.18 163.3,80.21 163.41,80.29 163.53,80.31 163.59,80.22 163.59,79.56 164.67,78.48 164.67,77.54 164.6,77.44 164.49,77.47 164.37,77.55 164.24,77.58 163.89,77.24 164.24,76.9 164.37,76.92 164.49,77.01 164.6,77.03 164.67,76.94 164.67,74.83 163.74,73.9 163.63,73.88 163.56,73.97 163.56,74.35 163.9,74.69 163.9,76.92 163.16,77.66 163.13,77.75 163.19,77.82 163.33,77.95 163.38,78.14 163.33,78.31 163.2,78.44 163.17,78.45 163.17,79.47 162.44,80.2 162.44,82.22 162.93,82.71 162.93,83.12
GND on IN2 (solid shape): 23.85,24.18 23.87,24.18 31.37,16.69 31.37,13.33 31.43,13.27 31.43,13.22 31.41,13.2 31.33,13.09 31.3,12.95 31.65,12.61 31.99,12.95 31.99,13.01 31.97,13.06 31.96,13.09 32.09,13.21 32.22,13.08 32.21,13.05 32.2,13 32.19,12.95 32.78,12.71 32.54,13.3 32.48,13.29 32.43,13.28 32.4,13.27 32.21,13.47 32.21,16.46 32.26,16.51 33.96,16.51 37.59,12.88 37.59,12.42 37.5,12.33 36.4,12.33 36.32,12.37 36.3,12.45 36.31,12.5 36.2,12.75 35.96,12.85 35.83,12.82 35.71,12.74 35.64,12.71 35.56,12.74 35.45,12.83 35.3,12.86 35.06,12.76 34.96,12.52 34.96,12.49 34.97,12.45 34.95,12.37 34.87,12.33 29.7,12.33 23.92,18.11 23.92,22.76 21.89,24.79 21.89,25.55 21.99,25.65 22.37,25.65
GND on IN2 (solid shape): 165.48,77.01 165.59,77.03 165.66,76.94 165.66,74.23 164.33,72.9 164.33,72.51 164.76,72.08 164.76,70.71 167.56,67.91 167.56,66.55 166.74,65.74 166.74,65.22 167.12,64.84 167.12,64.28 168.68,62.72 168.68,61.99 168.63,61.9 168.53,61.9 168.46,61.93 168.35,61.94 168.01,61.59 168.35,61.25 168.46,61.26 168.53,61.29 168.63,61.28 168.68,61.2 168.68,60.63 167.4,59.35 167.4,58.64 168.08,57.95 168.08,53.14 166.99,52.04 166.91,51.96 166.48,52.39 166.45,52.49 166.53,52.56 166.75,52.67 166.84,52.9 166.74,53.15 166.49,53.25 166.26,53.16 166.15,52.94 166.08,52.86 165.98,52.88 165.92,52.94 165.92,56.46 165.98,56.55 166.09,56.53 166.2,56.47 166.32,56.45 166.57,56.45 167.2,57.09 167.2,58.05 166.61,58.64 166.37,58.64 166,59.01 166,60.01 166.75,60.77 166.75,61.01 166.85,61.1 166.85,64.65 166.23,65.27 166.23,66.18 166.35,66.18 167.09,66.92 167.09,67.88 165.21,69.76 165.03,69.76 165.03,69.96 164.6,70.4 164.6,71.82 163.83,72.59 163.83,73.02 165.35,74.54 165.35,76.88
GND on IN2 (solid shape): outline of 173 points within 84.75,76.56 88.26,83.98
GND on IN2 (solid shape): outline of 183 points within 186.98,70.76 191.54,80.57
GND on IN2 (solid shape): 61.74,9.47 61.83,9.4 61.81,9.29 61.58,8.55 62.09,7.95 62.53,7.55 62.86,8.05 63.09,8.32 63.19,8.66 63.19,8.76 63.12,9.05 62.95,9.29 62.93,9.4 63.02,9.47 66.14,9.47 66.53,9.08 71.55,9.08 71.56,9.07 71.67,9.07 71.83,8.91 71.83,7.97 71.31,7.45 65.24,7.45 64.4,6.61 64.4,5.78 64.1,5.47 63.63,5.47 63.6,5.46 63.56,5.44 63.51,5.43 63.42,5.43 63.34,5.46 63.29,5.47 62.9,5.47 62.87,5.46 62.82,5.44 62.78,5.43 62.69,5.43 62.6,5.46 62.55,5.47 62.16,5.47 62.07,5.44 61.99,5.43 61.8,5.51 61.7,5.69 61.69,5.74 61.68,5.75 61.68,6.13 61.62,6.19 61.6,6.2 61.53,6.25 61.47,6.33 61.46,6.35 61.28,6.54 61.3,6.57 61.21,7.03 60.74,6.97 60.67,6.94 60.59,6.97 60.4,7.09 60.19,7.07 60.09,7.08 60.04,7.16 60.04,7.41 59.47,7.98 59.44,8.07 59.49,8.14 59.56,8.2 59.61,8.27 59.62,8.3 60.18,8.3 61.34,9.47
GND on IN2 (solid shape): 144.75,63.16 144.75,63.12 144.75,61.17 145.46,60.46 145.46,60.11 145.42,60.02 145.33,60.01 145.27,60.03 145.21,60.03 145.08,60 144.97,59.93 144.89,59.9 144.82,59.93 144.71,60 144.58,60.03 144.23,59.69 144.58,59.34 144.71,59.37 144.82,59.45 144.89,59.48 144.97,59.45 145.08,59.37 145.21,59.34 145.27,59.35 145.33,59.36 145.42,59.35 145.46,59.27 145.46,59.02 145.82,58.66 145.82,57.35 146.1,57.07 146.1,56.78 145.76,56.43 145.74,56.43 145.54,56.31 145.46,56.09 145.46,56.04 145.49,55.94 145.54,55.86 145.57,55.79 145.54,55.72 145.48,55.64 145.44,55.55 145.36,55.48 145.27,55.5 144.52,56.25 144.49,56.35 144.56,56.42 144.75,56.54 144.83,56.75 144.82,56.8 144.79,56.9 144.74,56.98 144.71,57.05 144.74,57.12 145.07,57.45 145.07,57.99 144.98,58.08 145.03,58.14 145.08,58.13 145.42,58.48 145.08,58.82 144.95,58.79 144.84,58.72 144.81,58.7 144.73,58.73 144.73,58.8 144.69,58.84 144.09,59.44 144.09,62.63 144.69,63.23
GND on IN2 (solid shape): outline of 214 points within 135.1,78.4 137.34,84.27
GND on IN2 (solid shape): outline of 220 points within 140.6,61.28 142.39,66.21
GND on IN2 (solid shape): 155.86,97.75 160.97,97.75 161.32,97.4 161.32,94.16 162.39,93.08 162.39,92.82 162.35,92.83 162.32,92.85 161.01,94.16 161.01,94.67 161.01,94.82 160.81,95.02 160.53,95.02 160.33,94.82 160.32,94.67 160.32,93.87 161.61,92.59 161.78,92.42 161.78,90.73 161.7,90.72 161.64,90.77 160.63,91.23 159.95,90.35 159.95,90.33 160.02,90.01 160.2,89.74 160.23,89.65 160.17,89.57 160.16,88.95 160.64,89.34 160.67,89.43 160.75,89.47 161.27,89.57 161.64,89.94 161.7,89.99 161.78,89.98 161.78,86.44 161.72,86.43 161.66,86.46 160.38,87.74 160.38,88.45 154.83,93.99 154.81,94.1 154.91,94.17 156.13,94.17 156.23,94.27 156.26,94.26 156.31,94.25 156.36,94.24 156.41,94.25 156.46,94.26 156.54,94.25 156.58,94.19 156.7,93.99 156.92,93.91 157.26,94.26 156.92,94.6 156.87,94.6 156.82,94.59 156.74,94.6 156.7,94.66 156.58,94.86 156.36,94.93 156.12,94.84 155.99,94.54 155.92,94.51 151.09,94.51 148.59,97.01 148.59,98.11 148.82,98.34 153.07,98.34 153.14,98.32 153.21,98.31 153.28,98.32 153.35,98.34 153.86,98.34 154.2,98.68 154.93,98.68
GND on IN2 (solid shape): outline of 82 points within 114.17,16.36 122.8,21.02
GND on IN2 (solid shape): outline of 91 points within 91.78,80.95 99.67,97.23
GND on IN2 (solid shape): outline of 244 points within 209.51,10.66 213.4,25.18
GND on IN2 (solid shape): outline of 251 points within 175.89,43.02 180.1,53.99
GND on IN2 (solid shape): outline of 234 points within 144.98,63.55 147.1,69.91
GND on IN2 (solid shape): outline of 98 points within 153.34,71.12 156.44,74.88
GND on IN2 (solid shape): outline of 267 points within 69.99,63.85 76.27,71.32
GND on IN2 (solid shape): outline of 278 points within 117.47,7.03 128.33,8.38
GND on IN2 (solid shape): outline of 293 points within 85.89,85.33 90.16,98.95
GND on IN2 (solid shape): outline of 296 points within 175.31,84.15 185.21,90.19
GND on IN2 (solid shape): outline of 111 points within 80.14,79.7 87.4,98.77
GND on IN2 (solid shape): outline of 324 points within 143.76,48.08 152.84,56.73
GND on IN2 (solid shape): outline of 123 points within 145.49,83.47 153.5,92.52
GND on IN2 (solid shape): outline of 351 points within 136.78,82.59 144.7,90.29
GND on IN2 (solid shape): outline of 365 points within 104.32,6.08 118.15,7.88
GND on IN2 (solid shape): outline of 381 points within 39.22,13.67 69.87,19.03
GND on IN2 (solid shape): outline of 133 points within 48.2,51.19 68.6,61.67
GND on IN2 (solid shape): outline of 392 points within 19.23,28.4 24.09,51.25
GND on IN2 (solid shape): outline of 152 points within 139.41,70.5 147.82,75.94
GND on IN2 (solid shape): outline of 394 points within 22.61,22.65 28.39,37.08
GND on IN2 (solid shape): outline of 151 points within 203.17,68.94 214.83,87.91
GND on IN2 (solid shape): outline of 510 points within 135.78,84.86 141.68,91.45
GND on IN2 (solid shape): outline of 650 points within 38.17,48.44 57.7,54.5
GND on IN2 (solid shape): outline of 683 points within 137.98,67.77 143.49,72.82
GND on IN2 (solid shape): outline of 1135 points within 197.94,42.37 216.83,68.36
GND on IN2 (solid shape): outline of 1248 points within 135.74,69.98 145.93,83.27
GND on IN2 (solid shape): outline of 2450 points within 79.96,79.98 119.68,109.61
GND on IN2 (solid shape): outline of 8404 points within 0.51,0.51 218.33,119.74
GND on IN2 (solid shape): outline of 21824 points within 23.43,12.56 80.41,98.32
GND on IN2 (solid shape): outline of 22541 points within 38.18,18.93 175.79,73.31
GND on IN3 (solid shape): 92.04,11.47 88.47,11.47 88.39,11.55 88.39,11.84 88.44,11.89 91.62,11.89
GND on IN3 (solid shape): 46.63,5.6 46.63,5.24 46.51,5.12 44.98,5.12 44.88,5.22 44.88,5.58 45,5.7 46.53,5.7
GND on IN3 (solid shape): 50.78,5.63 50.78,5.37 49.98,4.56 49.2,4.56 48.89,4.87 48.89,5.5 49.19,5.8 50.62,5.8
GND on IN3 (solid shape): 196.97,37.98 196.97,36.25 196.87,36.14 196.16,36.14 195.95,36.35 195.95,36.62 196.25,36.92 196.25,38.03 196.38,38.16 196.8,38.16
GND on IN3 (solid shape): 178.1,15.31 178.46,15.31 178.61,15.16 178.61,13.18 178.36,12.93 177.99,12.93 177.95,12.96 173.04,12.96 172.51,13.49 172.51,15.19 172.65,15.33 178.09,15.33
GND on IN3 (solid shape): 189.58,45.95 189.58,41.98 189.38,41.78 189.07,41.78 188.87,41.98 188.87,44.39 188.72,44.53 188.72,45.13 188.23,45.62 188.23,45.99 188.63,46.39 189.14,46.39
GND on IN3 (solid shape): 95.86,10.22 95.88,10.11 95.79,10.05 94.29,10.05 93.74,10.6 93.81,10.67 95.41,10.67
GND on IN3 (solid shape): 145.14,74.18 145.31,74.18 145.41,74.08 145.41,73.79 145.36,73.74 143.06,73.74 142.97,73.8 142.99,73.91 143.34,74.27 145.05,74.27
GND on IN3 (solid shape): 195.9,38.54 196,38.47 195.98,38.36 195.82,38.21 195.82,37.1 195.31,36.59 193.51,36.59 193.1,37 193.1,37.88 193.75,38.54
GND on IN3 (solid shape): 59.58,70.36 59.65,70.33 59.69,70.26 59.69,70.21 59.26,69.78 59.26,68.08 59.21,68.03 59.15,68.02 59.12,68.07 59.12,70.35 59.13,70.36
GND on IN3 (solid shape): 142.68,16.57 142.94,16.57 143.04,16.51 143.02,16.4 142.97,16.35 139.65,16.35 139.27,16.73 139.24,16.79 139.25,16.86 142.39,16.86

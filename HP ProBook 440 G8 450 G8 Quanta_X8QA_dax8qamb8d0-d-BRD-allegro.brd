# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VPCU on SVCC (solid shape): outline of 479 points within 22.3,6.53 213.31,73.86
+3VPCU on IN2 (solid shape): 69.09,60.4 69.09,58.34 68.76,58.02 68.24,58.02 68.22,58.01 68.19,58.02 68.13,58.04 68.05,58.05 67.81,57.95 67.71,57.7 67.73,57.59 67.78,57.49 67.78,55.29 63.69,51.19 60.64,51.19 59.74,52.1 59.74,52.6 59.92,52.78 63.07,52.78 65.83,55.55 65.95,55.47 66.09,55.44 66.33,55.54 66.43,55.78 66.37,55.98 66.2,56.11 66.2,56.23 66.17,56.25 66.16,56.28 66.16,57.47 66.2,57.5 66.2,58.91 68.15,60.86 68.63,60.86
+3VPCU on IN2 (solid shape): outline of 190 points within 152.23,55.14 157.5,70.46
+3VPCU on IN2 (solid shape): outline of 236 points within 205.28,2.77 210.41,10.06
+3VPCU on IN2 (solid shape): outline of 1485 points within 187.31,45.79 198.89,74.61
+3VPCU on IN3 (solid shape): outline of 190 points within 176.76,51.97 182.55,60.65
+3VPCU on IN3 (solid shape): outline of 740 points within 184.07,11.62 202.08,18.19
+3VPCU on IN3 (solid shape): outline of 5436 points within 11.96,6.6 156.64,49.65
+3VPCU_KB on BOTTOM (solid shape): 134.85,13.84 134.85,12.69 134.83,12.67 134.81,12.66 134.65,12.56 134.56,12.39 134.56,12.38 134.46,12.27 134.41,12.28 134.13,12.28 134.1,12.27 134.05,12.26 133.98,12.21 133.93,12.15 133.93,12.14 133.88,12.09 133.88,11.46 133.78,11.36 133.78,11.36 132.84,10.41 131.47,10.41 131.36,10.47 131.24,10.5 131.19,10.49 131.14,10.5 131.03,10.48 130.93,10.43 130.9,10.41 130.86,10.41 130.35,9.9 130.35,9.73 130.29,9.73 130.29,8.41 129.99,8.41 129.99,9.73 129.95,9.73 129.92,9.74 129.86,9.82 129.79,9.84 129.49,9.84 129.42,9.82 129.38,9.76 129.37,9.75 129.35,9.73 129.29,9.73 129.29,8.41 129.03,8.41 128.98,8.46 128.99,8.48 128.99,9.73 128.93,9.73 128.93,10.64 128.96,10.71 128.96,10.8 128.96,10.88 128.93,10.95 128.93,11.07 129.23,11.38 132.54,11.38 132.97,11.81 132.97,12.51 133.01,12.56 133.33,12.78 133.27,13.16 133.27,13.79 133.45,13.97 134.72,13.97
+3VPCU_PD on TOP (solid shape): 193.42,89.41 193.42,88.49 193.27,88.34 190.62,88.34 190.5,88.47 190.5,88.75 190.6,88.85 191.67,88.85 191.79,88.97 191.79,89.13 192.12,89.46 193.37,89.46
+3VPCU_R on TOP (solid shape): 149.91,15.8 150.72,15.8 151.25,15.26 151.25,14.11 151.22,14.1 151.18,14.06 151.16,14 151.16,12.55 150.85,12.24 149.43,12.24 149.27,12.39 149.27,13.18 148.96,13.5 146.52,13.5 146.35,13.66 146.35,15.8 146.51,15.95 149.76,15.95
+3VPCU_R on BOTTOM (solid shape): 152.78,17.03 153.19,16.63 153.19,13.18 153.01,13 149.38,13 149.02,13.36 149.02,15.82 149.71,16.51 151.13,16.51 151.69,17.07 152.75,17.07
+5V on TOP (solid shape): 26.74,47.67 26.74,46.23 26.46,45.95 25.14,45.95 24.92,46.17 24.92,47.06 25.65,47.8 26.62,47.8
+5V on TOP (solid shape): 28.7,68.27 28.7,67.97 28.32,67.59 28.32,65.33 28.19,65.2 27.5,65.2 27.48,65.21 27.46,65.22 27.39,65.28 27.3,65.32 27.3,65.86 27.71,66.27 27.71,67.31 27.51,67.51 26.52,67.51 26.46,67.52 26.41,67.52 26.39,67.52 26.37,67.53 26.31,67.59 26.31,68.02 26.69,68.4 28.57,68.4
+5V on TOP (solid shape): 200.16,31.2 200.2,31.14 200.29,31.07 201.06,31.07 201.1,31.07 201.14,31.07 201.18,31.07 201.22,31.07 201.86,31.07 202.87,30.07 202.87,29.94 202.66,29.73 202.56,29.73 202.01,30.28 200.46,30.28 199.98,30.76 198.92,30.76 198.88,30.81 198.88,31.52 198.93,31.57 199.79,31.57
+5V on TOP (solid shape): 161.48,12.93 161.48,12.66 161.48,12.65 161.48,11.35 161.48,11.33 161.69,11.13 161.69,10.02 160.82,9.15 160.82,9.13 160.82,8.95 160.66,8.79 160.66,8.46 160.9,8.22 161.09,8.22 161.29,8.02 161.29,7.69 161.24,7.64 160.65,7.64 160.63,7.67 160.63,7.92 160.42,8.13 160.42,9.09 160.55,9.22 160.55,10.03 160.2,10.38 160.27,10.5 160.29,10.63 160.19,10.88 159.93,10.99 159.89,10.99 159.82,11.01 159.78,11.08 159.78,12.37 159.76,12.43 159.71,12.47 159.69,12.48 159.69,12.9 159.83,13.04 161.37,13.04
+5V on TOP (solid shape): outline of 359 points within 187.91,44.27 196.67,49.63
+5V on BOTTOM (solid shape): 152.29,11.87 152.29,11.34 152.61,11.02 152.61,9.76 152.45,9.61 150.86,9.61 150.67,9.8 150.67,11.07 150.41,11.33 150.41,11.98 150.57,12.14 152.02,12.14
+5V on BOTTOM (solid shape): 34.77,10.03 34.77,9.17 35,8.94 36.29,8.94 36.4,8.84 36.4,8.05 36.32,7.97 34.76,7.97 34.13,7.34 32.89,7.34 32.69,7.54 32.69,10.23 32.76,10.31 34.49,10.31
+5V on BOTTOM (solid shape): 202.84,30.1 202.84,29.89 202.66,29.72 202.66,29.3 202.38,29.01 202.38,28.77 202.38,28.7 202.33,28.65 201.9,28.65 201.75,28.5 200.97,28.5 200.89,28.58 200.89,28.73 201.29,29.13 201.43,29.13 202.02,29.72 202.02,30.08 202.23,30.3 202.64,30.3
+5V on BOTTOM (solid shape): outline of 1035 points within 170.36,36.09 189.23,50.14
+5V on SVCC (solid shape): outline of 290 points within 21.41,9.19 152.09,47.44
+5V on IN2 (solid shape): outline of 88 points within 192.18,31.62 194.43,34.52
+5V on IN2 (solid shape): outline of 1630 points within 159.69,12.5 179.2,38.76
+5V on SGND1 (solid shape): 158.69,14.65 158.8,14.4 159.05,14.29 159.31,14.4 159.42,14.65 159.71,14.65 159.81,14.4 160.07,14.29 160.33,14.4 160.43,14.65 160.72,14.65 160.83,14.4 161.08,14.29 161.34,14.4 161.45,14.65 161.67,14.65 161.77,14.55 161.77,12.12 161.56,11.91 158.54,11.91 158.45,11.89 158.36,11.84 157.43,10.9 157.37,10.81 157.35,10.72 157.35,10.14 157.17,9.95 149.68,9.95 149.3,10.34 149.3,12.77 149.33,12.8 155.67,12.8 155.77,12.82 155.85,12.87 156.14,13.16 156.25,13.09 156.39,13.06 156.64,13.17 156.75,13.43 156.72,13.56 156.65,13.67 157.27,14.29 157.48,14.4 157.58,14.6 157.63,14.65
+5V_AVDD_R on TOP (solid shape): 197.25,35.9 198.1,35.9 198.87,35.14 198.92,35.14 199.03,35.02 199.03,33.5 199.09,33.44 199.13,33.38 199.2,33.33 199.46,33.07 199.59,33.07 199.82,32.84 199.82,32.18 199.79,32.15 199.24,32.15 198.98,32.41 198.65,32.41 198.55,32.51 198.55,32.66 197.97,33.25 197.97,33.7 197.95,33.72 197.52,34.15 197.52,34.15 197.15,34.52 197.15,34.53 197.06,34.68 196.91,34.77 196.9,34.77 196.84,34.82 196.84,35.86 196.86,35.9 196.9,35.91 197.2,35.91
+5V_CAM on TOP (solid shape): 28.9,48.46 28.9,46.1 28.83,46.02 27.2,46.02 27.05,46.17 27.05,47.7 27.2,47.85 27.53,47.85 27.59,47.83 27.68,47.82 27.94,47.92 28.05,48.18 28.04,48.25 28.02,48.31 28.01,48.34 28.23,48.56 28.8,48.56
+5V_CAM on BOTTOM (solid shape): outline of 281 points within 24.13,38.58 29.04,47.83
+5V_FAN on TOP (solid shape): 27.58,67.25 27.58,66.49 27.57,66.48 27.54,66.38 27.54,66.28 27.54,66.26 27.52,66.24 27.24,65.96 27.05,65.96 27.05,65.35 26.73,65.03 26.73,63.56 26.54,63.37 26.21,63.37 26.03,63.55 26.03,63.94 26.03,64.08 26.03,64.8 26.06,64.83 26.06,65.24 26.42,65.6 26.42,66.63 26.31,66.74 26.31,67.33 26.38,67.4 27.44,67.4
+5V_HDMIC on TOP (solid shape): outline of 127 points within 196.21,45.48 206.44,48.77
+5V_LED_KBLIGHT on BOTTOM (solid shape): 48.68,10.86 50.09,10.86 50.41,10.55 50.41,9.12 50.26,8.97 48.61,8.97 48.33,8.68 47.9,8.68 47.83,8.76 47.83,8.79 47.65,8.97 47.16,8.97 46.71,9.42 46.71,10.57 47.47,11.33 48.21,11.33
+5V_LED_KBLIGHT_C on BOTTOM (solid shape): 50.43,8.42 50.43,6.24 50.07,5.88 49.13,5.88 49.06,5.8 49.02,5.79 48.98,5.76 48.93,5.73 48.89,5.69 48.86,5.65 48.83,5.6 48.82,5.56 48.79,5.53 48.15,5.53 48.13,5.59 48.11,5.64 48.07,5.68 48.03,5.72 47.99,5.75 47.94,5.78 47.94,5.86 48.44,5.86 48.44,6.64 48.24,6.64 48.24,5.86 47.94,5.86 47.94,6.64 47.74,6.64 47.74,5.8 47.68,5.78 47.64,5.77 47.6,5.74 47.56,5.71 47.51,5.66 47.44,5.73 47.44,5.86 47.44,5.86 47.44,6.64 47.44,6.64 47.44,8.34 47.52,8.43 48.37,8.43 48.6,8.66 49.24,8.66 49.24,8.66 50.19,8.66
+5V_R on TOP (solid shape): outline of 101 points within 156.83,7.64 160.48,12.34
+5V_USBP1 on TOP (solid shape): 203.67,84.51 203.67,82.73 203.61,82.67 201.8,82.67 201.67,82.8 201.67,85.03 201.86,85.22 202.95,85.22
+5V_USBP1 on TOP (solid shape): 204.59,69.04 204.59,67.82 204.59,67.78 204.58,67.75 204.58,67.71 203.25,66.38 203.25,64.53 202.76,64.04 201.88,64.04 201.69,64.23 201.66,64.24 201.6,64.31 201.6,64.65 201.6,65.32 201.6,65.55 201.36,65.78 200.93,66.21 200.91,66.22 200.8,66.32 200.8,66.35 200.75,66.4 200.75,67.68 200.82,67.75 201.93,67.75 202.06,67.88 202.08,67.91 202.09,67.93 203.21,69.05 203.65,69.49 204.14,69.49
+5V_USBP1 on BOTTOM (solid shape): 203.2,67.51 203.2,65.57 203.54,65.22 203.54,62.05 203.32,61.83 202.41,61.83 202.38,61.8 201.52,61.8 201.35,61.97 201.35,63.74 201.23,63.86 201.23,67.38 201.65,67.8 202.91,67.8
+5V_USBP1 on IN2 (solid shape): outline of 1179 points within 195.96,64.08 204.33,85.24
+5V_USBP4 on TOP (solid shape): outline of 176 points within 195.27,84.78 204.34,89.17
+5V_USBP4 on BOTTOM (solid shape): outline of 254 points within 200.21,80.87 204.33,89.21
+5V_USBP4 on IN2 (solid shape): outline of 140 points within 196.59,84.22 204.32,89.15
+5VPCU on TOP (solid shape): 200.63,81.73 200.63,81.32 201.16,80.8 201.16,80.46 201.03,80.33 200.43,80.33 199.69,81.07 199.69,81.73 199.92,81.96 200.4,81.96
+5VPCU on TOP (solid shape): 204.88,83.31 207.92,83.31 208.05,83.18 208.05,81.73 207.82,81.51 205.31,81.51 203.44,79.64 203.12,79.64 202.96,79.8 202.96,79.92 203.79,80.74 203.79,83.15 203.81,83.17 203.81,83.82 203.94,83.95 204.24,83.95
+5VPCU on TOP (solid shape): 197.04,82.51 197.04,81.49 197.2,81.33 197.4,81.33 198.27,80.46 198.27,79.98 197.82,79.53 196.73,79.53 196.66,79.6 196.66,80.26 196.53,80.39 196.53,80.64 195.96,81.21 195.96,82.34 196.15,82.54 197.01,82.54
+5VPCU on TOP (solid shape): 176.1,66.8 176.1,65.61 175.26,64.77 175.26,63.8 176.26,62.8 176.26,62.37 177.11,61.52 177.8,61.52 177.9,61.42 177.9,61.15 177.75,61.01 176.27,61.01 174.88,62.4 174.88,62.82 174.09,63.61 174.09,64.6 174.2,64.69 174.26,64.77 175.1,65.61 175.82,66.33 175.82,66.75 175.92,66.85 176.05,66.85
+5VPCU on TOP (solid shape): 90.54,109.23 90.82,109.23 91.45,108.6 91.45,107.82 91.2,107.57 90.67,107.57 90.58,107.66 90.58,107.73 90.58,108.03 90.58,108.09 90.55,108.14 90.54,108.16 90.54,108.24 90.32,108.47 89.98,108.47 89.5,108.94 89.51,108.98 89.51,109.36 89.5,109.41 89.46,109.45 89.46,109.5 89.55,109.6 90.17,109.6
+5VPCU on TOP (solid shape): 161.14,13.59 161.14,13.28 161.03,13.18 160.67,13.18 160.54,13.18 160.02,13.18 159.88,13.18 159.74,13.18 159.54,12.98 159.54,12.75 159.31,12.52 158.16,12.52 157.71,12.07 157.08,12.07 157.01,12.13 157.01,12.91 157.01,12.91 157.01,13.04 157.17,13.2 157.17,13.2 157.69,13.71 161.01,13.71
+5VPCU on TOP (solid shape): 198.12,93.11 198.12,92.12 197.66,91.66 197.66,91.55 197.25,91.14 197.25,91.13 197.2,91.04 197.1,91.04 197.05,91.07 196.8,91.07 196.68,90.99 196.61,90.88 196.61,90.62 196.68,90.51 196.8,90.44 197.05,90.44 197.1,90.46 197.2,90.46 197.25,90.37 197.25,89.91 197.5,89.66 197.5,89.53 197.54,89.49 197.14,89.08 196.77,89.08 196.77,88.82 196.73,88.76 196.67,88.72 196.46,88.72 196.36,88.77 196.29,88.69 196.06,88.69 195.78,88.42 193.75,88.42 193.58,88.58 193.58,89.39 193.94,89.75 193.94,89.91 193.97,89.95 193.99,89.99 193.99,90.25 193.97,90.28 193.94,90.33 193.94,90.46 194.03,90.55 194.85,90.55 195.73,91.43 196.78,91.43 197.51,92.17 197.51,92.56 197.54,92.58 197.54,93.32 197.91,93.32
+5VPCU on TOP (solid shape): 10.6,26.85 11.45,26.85 11.96,26.34 12.68,26.34 12.7,26.32 12.75,26.3 12.81,26.28 12.86,26.27 12.92,26.27 12.98,26.28 13.03,26.3 13.08,26.32 13.1,26.34 14.3,26.34 14.39,26.25 14.39,24.69 14.16,24.46 12.09,24.46 11.99,24.36 11.99,23.72 11.79,23.52 10.47,23.52 10.47,23.53 9.87,23.53 9.86,23.52 9.62,23.52 9.42,23.72 9.42,24.02 9.86,24.02 9.86,23.83 10.47,23.83 10.47,23.83 10.47,24.03 9.87,24.03 9.42,24.02 9.42,24.52 9.86,24.52 9.86,24.33 10.47,24.33 10.47,24.33 10.47,24.53 9.87,24.53 9.42,24.52 9.42,25.02 9.86,25.02 9.86,24.83 10.47,24.83 10.47,24.83 10.47,25.03 9.87,25.03 9.42,25.02 9.42,25.5 9.45,25.52 9.86,25.52 9.86,25.33 10.47,25.33 10.47,25.33 10.47,25.53 9.87,25.53 9.45,25.52 9.62,25.7 9.62,26.02 9.86,26.02 9.86,25.83 10.47,25.83 10.47,25.83 10.47,26.03 9.87,26.03 9.62,26.02 9.62,26.52 9.86,26.52 9.86,26.33 10.47,26.33 10.47,26.33 10.47,26.53 9.87,26.53 9.62,26.52 9.62,26.7 9.77,26.85 10.6,26.85
+5VPCU on BOTTOM (solid shape): 201.02,81.27 201.02,80.44 200.74,80.16 199.46,80.16 198.77,79.47 197.53,79.47 197.23,79.77 197.23,80.28 197.23,80.31 197.23,80.62 197.23,80.65 197.23,81.2 197.38,81.35 197.38,81.79 197.53,81.94 200.35,81.94
+5VPCU on BOTTOM (solid shape): outline of 100 points within 12.01,20.68 18.54,26.24
+5VPCU on BOTTOM (solid shape): outline of 134 points within 175.26,7.95 181.07,12.47
+5VPCU on SVCC (solid shape): outline of 616 points within 157.1,9.6 206.46,92.53
+5VPCU on IN2 (solid shape): outline of 879 points within 142.06,61.47 176.96,106.37
+5VPCU on IN2 (solid shape): outline of 2217 points within 98.42,10.21 159.43,17.68
+5VPCU on IN2 (solid shape): outline of 7030 points within 10.67,8.38 75.39,100.84
+5VPCU on IN3 (solid shape): 132.36,102.61 132.36,102.08 132.2,101.93 131.85,101.93 131.65,102.13 131.66,102.2 131.66,102.39 130.18,103.87 129.62,103.87 129.54,103.91 129.52,103.99 129.52,104.03 129.53,104.06 129.43,104.31 129.18,104.41 129.01,104.36 128.89,104.24 128.81,104.2 128.73,104.23 128.46,104.5 128.46,104.66 128.45,104.66 128.45,105.56 128.67,105.79 129.18,105.79
+5VPCU_R on TOP (solid shape): 175.94,13.36 175.94,13.15 174.93,12.14 174.93,11.38 174.04,10.49 172.67,10.49 171.37,11.78 171.37,13.21 171.57,13.41 175.89,13.41
+5VPCU_R on BOTTOM (solid shape): 177.72,16.25 177.72,12.82 177.52,12.62 176.17,12.62 175.46,11.91 175.46,11.45 174.95,10.95 174.95,8.41 174.83,8.28 173.3,8.28 173.11,8.09 173.11,7.48 172.57,6.93 171.55,6.93 171.42,7.06 171.42,7.81 171.45,7.83 171.67,8.16 171.45,8.49 171.42,8.51 171.42,9.22 171.8,9.6 172.24,9.6 172.36,9.73 172.36,9.81 172.39,9.89 172.39,10.06 172.36,10.13 172.36,10.33 172.38,10.34 172.4,10.38 172.41,10.42 172.41,10.81 172.41,10.84 172.37,10.9 172.37,10.92 172.36,10.92 172.18,11.1 171.96,11.1 171.83,11.22 171.83,11.91 174.42,14.5 175.69,14.5 175.73,14.55 175.84,14.62 175.92,14.73 175.94,14.76 175.96,14.86 175.97,14.92 175.96,14.99 175.94,15.06 175.94,16.13 176.12,16.3 177.67,16.3
+V3.3DX_RT_TCP0 on TOP (solid shape): 176.76,105.43 176.76,104.87 177.07,104.87 177.41,104.53 177.41,104.21 177.31,104.11 176.4,104.11 175.98,104.52 175.37,104.52 175.17,104.32 175.17,103.94 175.64,103.48 175.64,102.97 175.33,102.66 175.33,102.03 175.23,101.92 174.86,101.92 174.76,102.03 174.76,102.99 174.34,103.41 174.34,104.79 174.41,104.86 174.55,104.86 175.23,105.54 176.64,105.54
+VCC0V9_SVR_TCP0 on TOP (solid shape): 187.21,96.99 187.21,95.47 187.18,95.41 187.12,95.37 187.08,95.39 187.05,95.41 186.79,95.41 186.68,95.34 186.61,95.23 186.61,94.97 186.62,94.94 186.59,94.88 186.52,94.86 186.23,94.86 186.05,95.04 186.05,95.32 186.11,95.38 186.13,95.39 186.25,95.46 186.3,95.6 186.3,95.9 186.27,96.01 186.18,96.09 186.18,96.09 185.93,96.34 185.94,96.41 185.93,96.48 185.91,96.54 185.89,96.57 185.91,96.64 185.99,96.67 186.19,96.67 186.2,96.69 186.29,96.69 186.72,97.12 187.08,97.12
+VCC0V9_SVR_TCP0 on TOP (solid shape): outline of 83 points within 182.85,94.51 185.5,97.4
+VCC0V9_SVR_TCP0 on BOTTOM (solid shape): 179.83,102 179.83,99.18 179.7,99.06 178.33,99.06 177.77,99.62 177.37,99.62 177.14,99.85 177.14,102.23 177.24,102.33 178.33,102.33 178.48,102.49 179.35,102.49
+VCC0V9_SVR_TCP0 on IN3 (solid shape): outline of 526 points within 177.61,94.87 187.65,102.26
+VCC0V9_SVR_TCP0_PHASE on BOTTOM (solid shape): 181.73,101.39 181.73,100.44 182.24,99.94 182.94,99.24 182.94,98.14 182.89,98.09 182.47,98.09 182.32,98.24 181.66,98.24 181.45,98.45 181.45,98.65 181.37,98.73 181.24,98.85 180.36,98.85 180.11,99.11 180.11,101.32 180.41,101.62 181.51,101.62
+VCC1.05_OUT_FET on TOP (solid shape): 138.1,98.27 138.1,96.42 137.38,95.7 137.28,95.7 137.2,95.67 137.17,95.59 137.17,95.16 137.2,95.08 137.28,95.05 137.31,95.05 138.02,94.33 138.02,93.9 138.12,93.8 138.22,93.8 138.25,93.79 138.39,93.79 138.44,93.74 138.44,93.36 138.35,93.27 138.35,93.06 138.27,92.98 137.68,92.98 137.65,92.98 137.61,92.96 137.59,92.96 137.54,92.91 137.54,92.28 137.44,92.17 136.22,92.17 136.18,92.21 136.18,93.01 136.17,93.07 136.12,93.11 136.09,93.13 136.09,93.26 136.19,93.36 136.24,93.36 136.36,93.43 136.43,93.54 136.43,93.8 136.36,93.91 136.24,93.99 135.99,93.99 135.93,93.96 135.71,94.18 135.71,95.45 135.84,95.58 135.84,96.37 135.89,96.42 136.76,96.42 136.83,96.49 136.83,97.79 136.92,97.88 136.92,97.89 137.09,98.06 137.09,98.48 137.21,98.6 137.77,98.6
+VCC1.05_OUT_FET on BOTTOM (solid shape): 124.51,91.08 124.51,90.88 123.59,89.96 123.59,88.21 125.19,86.61 125.19,85.52 125.24,85.47 125.24,85.14 125.22,85.12 125.22,84.96 125.25,84.94 125.25,84.91 125.4,84.76 125.75,84.76 125.85,84.66 125.85,84.22 125.8,84.17 125.5,84.17 125.45,84.22 125.39,84.25 125.19,84.25 124.74,84.71 124.74,84.9 124.74,84.9 124.74,84.99 124.75,85.06 124.74,85.14 124.74,86.42 124.74,86.43 124.69,86.48 124.69,86.49 124.65,86.54 124.6,86.58 124.59,86.58 123.54,87.63 123.14,87.63 122.87,87.9 122.86,87.92 122.86,87.98 122.83,88.05 122.83,90.45 123.59,91.21 124.38,91.21
+VCC1.05_OUT_FET on SVCC (solid shape): 125.58,90.95 125.58,89.13 125.49,89.01 125.46,88.87 125.49,88.73 125.58,88.62 125.58,86.13 125.23,86.13 125.11,86.21 124.97,86.24 124.83,86.21 124.71,86.13 123.21,86.13 123.21,90.93 123.57,91.29 125.24,91.29
+VCC1.05_OUT_FET on IN2 (solid shape): 124.48,91.11 124.48,89.54 124.45,89.54 124.41,89.55 124.35,89.54 124.28,89.55 124.23,89.61 124.12,89.79 123.92,89.85 123.7,89.76 123.61,89.53 123.63,89.41 123.69,89.31 123.72,89.24 123.69,89.17 123.63,89.07 123.6,88.95 123.69,88.72 123.92,88.63 124.11,88.69 124.22,88.85 124.27,88.91 124.34,88.92 124.37,88.91 124.41,88.91 124.45,88.91 124.48,88.92 124.48,86.97 124.89,86.56 124.91,86.56 125.47,86 125.47,85.65 125,85.18 124.9,85.18 123.28,86.8 123.28,88.24 122.54,88.97 122.54,89.98 119.38,93.14 119.38,93.72 119.86,94.21 121.38,94.21
+VCC1.05_OUT_FET on IN3 (solid shape): 135.2,98.77 135.25,98.77 135.25,98.71 135.24,98.67 135.21,98.64 135.19,98.61 135.12,98.59 135.05,98.62 134.93,98.69 134.8,98.72 134.46,98.37 134.8,98.03 134.93,98.05 135.05,98.13 135.12,98.16 135.19,98.13 135.3,98.05 135.43,98.03 135.67,98.13 135.77,98.37 135.74,98.52 135.65,98.64 135.62,98.67 135.61,98.71 135.61,98.77 137.64,98.77 137.83,98.46 137.78,98.1 137.78,97.54 137.67,97.43 137.64,97.43 137.13,96.92 135.62,96.92 135.61,96.95 135.49,97.07 135.33,97.12 135.17,97.07 135.05,96.95 135.04,96.92 134.86,96.92 134.85,96.95 134.73,97.07 134.57,97.12 134.41,97.07 134.29,96.95 134.28,96.92 134.19,96.92 133.68,97.43 131.78,97.43 130.61,96.26 126.17,96.26 126.16,96.26 125.55,96.26 122.02,92.73 119.78,92.73 119.68,92.83 119.68,93.77 120.14,94.23 121.94,94.23 124.99,97.28 130.19,97.28 132.66,99.74 134.22,99.74
+VCC3P3_LC_TCP0 on IN2 (solid shape): outline of 420 points within 180.49,88.42 187.93,96.26
+VCC3V3_SX_TCP0 on TOP (solid shape): 178.41,106.14 178.38,105.97 178.35,105.82 178.33,105.58 178.34,104.96 178.4,104.59 178.43,104.47 178.46,104.35 178.46,102.95 177.95,102.44 176.65,102.44 176.53,102.56 176.53,103.05 176.54,103.06 176.81,103.06 176.85,103.06 176.92,103.06 176.92,103.14 176.93,103.17 176.93,103.53 177.49,104.09 177.49,104.12 177.52,104.16 177.52,104.58 177.01,105.09 177.01,105.59 176.9,105.59 176.77,105.72 176.77,106.19 176.91,106.32 178.23,106.32
+VCC3V3_SX_TCP0 on BOTTOM (solid shape): 178.03,106.37 178.05,106.36 178.06,106.35 178.3,106.11 178.3,104.49 178.32,104.48 178.32,104.3 178.42,104.2 178.42,102.7 178.2,102.49 176.63,102.49 176.55,102.56 176.55,102.92 176.68,103.05 176.81,103.05 176.96,103.2 177.42,103.2 177.49,103.27 177.49,104.37 177.5,104.42 177.51,104.47 177.5,104.52 177.49,104.57 177.49,104.7 177.22,104.97 176.59,104.97 176.47,105.1 176.47,105.61 176.51,105.65 176.52,105.66 176.69,105.79 176.76,106 176.75,106.06 176.74,106.12 176.74,106.18 176.92,106.37
+VCC3V3_SX_TCP0 on IN1 (solid shape): outline of 316 points within 176.42,94.83 187.21,103.1
+VCC3V3_SX_TCP0 on IN3 (solid shape): outline of 139 points within 181.71,90.27 185.29,95.37
+VCC_TS on TOP (solid shape): outline of 282 points within 26.82,44.18 33.05,54.68
+VCC_TS_R on BOTTOM (solid shape): 30.71,53.57 30.71,50.42 30.2,49.91 29.59,49.91 29.51,49.98 29.51,50.34 29.36,50.49 29.36,51.84 30.15,52.63 30.15,53.57 30.27,53.69 30.58,53.69
+VCCIN on TOP (solid shape): outline of 2306 points within 89.18,68.38 128.96,103.32
+VCCIN on BOTTOM (solid shape): 105.16,86.4 105.16,85.42 104.98,85.25 103.76,85.25 103.74,85.25 103.73,85.26 103.56,85.42 103.56,85.87 103.91,86.22 103.91,86.53 103.72,86.73 103.72,86.89 103.91,87.08 104.49,87.08
+VCCIN on BOTTOM (solid shape): 98.56,103.15 102.51,103.15 103.11,103.76 103.91,103.76 106.12,101.54 106.12,100.86 105.36,100.1 105.36,99.8 105.31,99.79 105.24,99.75 105.22,99.68 105.22,98.92 105.6,98.53 108.27,98.53 108.38,98.42 108.38,97.48 108.74,97.13 112.22,97.13 112.37,96.98 112.37,96.41 112.86,95.92 113.42,95.92 113.75,95.59 114.93,95.59 115.45,95.07 115.45,93 114.72,92.27 111.75,92.27 111.66,92.36 110.98,92.36 110.89,92.27 105.56,92.27 102.66,95.17 94.51,95.17 94.5,95.18 93.69,95.18 93.43,95.44 93.43,96.77 93.61,96.95 96.03,96.95 96.49,97.41 96.49,98.47 96.58,98.55 99.5,98.55 99.65,98.7 99.65,99.7 99.57,99.7 99.57,101.14 99.41,101.29 97.42,101.29 96.89,101.82 96.89,103.29 97.42,103.82 97.78,103.82 97.9,103.82
+VCCIN on BOTTOM (solid shape): outline of 551 points within 117.94,68.61 126.08,70.01
+VCCIN on BOTTOM (solid shape): outline of 599 points within 99.89,70.89 110.07,77.46
+VCCIN on BOTTOM (solid shape): outline of 1043 points within 118.58,80.62 128.95,82.83
+VCCIN on SVCC (solid shape): outline of 534 points within 91.64,68.91 128.98,103.07
+VCCIN on IN2 (solid shape): outline of 7963 points within 91.4,68.55 128.95,102.51
+VCCIN_AUX on TOP (solid shape): 123.9,101.9 123.9,101.14 124.13,100.91 128.19,100.91 128.26,100.85 128.26,98.59 128.01,98.35 128.01,96.72 127.93,96.63 127.21,96.63 127.12,96.54 121.8,96.54 121.28,97.05 120.34,97.05 120.01,96.72 119.05,96.72 118.74,97.03 118.74,100.86 118.36,101.24 118.36,101.95 118.51,102.11 123.7,102.11
+VCCIN_AUX on TOP (solid shape): outline of 185 points within 125.32,69.16 134.95,82.2
+VCCIN_AUX on TOP (solid shape): outline of 709 points within 110.07,79.91 126.68,89.89
+VCCIN_AUX on BOTTOM (solid shape): 122.62,104.27 122.62,102.65 122.19,102.22 122.19,101.11 122.33,100.97 129.61,100.97 130.02,100.56 130.85,100.56 131.46,99.95 131.57,99.88 131.7,99.85 131.82,99.88 131.93,99.94 131.95,99.95 132.03,99.95 132.07,99.93 132.18,99.85 132.31,99.82 132.34,99.8 132.36,99.76 132.36,96.82 132,96.47 131.51,96.47 130.53,95.49 124.51,95.49 124.51,98.42 124.36,98.58 122.02,98.58 121.45,98 121.45,97.1 121.3,96.96 118.83,96.96 118.34,97.45 118.34,102.07 119.56,103.29 119.58,103.3 119.6,103.31 119.88,103.31 119.96,103.34 119.99,103.42 119.99,103.72 120.65,104.38 120.66,104.39 122.5,104.39
+VCCIN_AUX on BOTTOM (solid shape): 127.39,69.9 127.39,69.52 127.36,69.45 127.29,69.42 127.06,69.19 127.29,68.95 127.36,68.92 127.39,68.85 127.39,68.66 127.21,68.48 127.14,68.48 127.05,68.53 127.04,68.63 127.06,68.67 127.07,68.72 126.83,68.96 126.6,68.72 126.61,68.67 126.62,68.63 126.62,68.53 126.53,68.48 126.44,68.48 126.41,68.49 126.32,68.49 126.2,68.61 126.2,68.86 126.24,68.94 126.32,68.96 126.38,68.95 126.61,69.19 126.38,69.42 126.32,69.41 126.24,69.43 126.2,69.51 126.2,69.96 126.23,69.98 126.24,70.02 126.27,70.03 127.26,70.03
+VCCIN_AUX on BOTTOM (solid shape): 110.32,82.2 110.4,82.15 110.4,82.05 110.38,81.99 110.37,81.93 110.6,81.7 110.84,81.93 110.83,81.99 110.81,82.05 110.81,82.15 110.89,82.2 110.94,82.2 110.95,82.19 111.06,82.16 111.18,82.19 111.19,82.2 111.23,82.2 111.32,82.15 111.32,82.05 111.3,81.99 111.29,81.93 111.29,81.89 111.3,81.85 111.29,81.76 111.21,81.71 110.96,81.71 110.84,81.6 110.84,81.41 110.84,81.34 110.99,81.19 110.99,80.66 110.95,80.62 110.25,80.62 109.99,80.89 109.98,81.26 110.05,81.26 110.1,81.24 110.15,81.24 110.38,81.47 110.15,81.7 110.1,81.7 110.02,81.72 109.98,81.8 109.98,82.05 110.1,82.17 110.15,82.16 110.21,82.17 110.26,82.19 110.27,82.2
+VCCIN_AUX on BOTTOM (solid shape): outline of 192 points within 115.77,80.62 118.2,82.16
+VCCIN_AUX on BOTTOM (solid shape): outline of 457 points within 129.12,80.62 134.98,82.2
+VCCIN_AUX on SVCC (solid shape): 128.01,101.06 128.01,97.39 127.07,96.44 123.34,96.44 123.24,96.42 123.16,96.37 121.95,95.15 121.71,95.05 121.61,94.81 118.33,91.54 117.65,91.54 117.55,91.52 117.47,91.47 116.4,90.4 116.31,90.44 116.2,90.45 115.95,90.35 115.84,90.09 115.85,89.99 115.9,89.89 115.57,89.56 115.51,89.48 115.49,89.38 115.49,86.41 115.51,86.31 115.57,86.23 116.45,85.34 116.54,85.28 116.63,85.27 116.99,85.27 117.37,84.88 117.37,82.42 117.39,82.32 117.45,82.24 118.13,81.55 118.13,80.85 117.8,80.52 111,80.52 110.49,81.03 110.49,88.11 112.55,90.17 113.61,90.17 113.71,90.19 113.79,90.24 114.16,90.61 114.25,90.56 114.36,90.55 114.62,90.65 114.72,90.91 114.71,91.02 114.66,91.11 116.94,93.39 117,93.47 117.02,93.57 117.02,98.06 118.44,99.49 118.5,99.57 118.51,99.67 118.51,100.76 118.95,101.19 127.88,101.19
+VCCIN_AUX on IN2 (solid shape): outline of 3445 points within 120.95,69.16 136.88,101.12
+VCCIO_OUT on TOP (solid shape): 92.79,78.86 92.89,78.76 93.03,78.71 93.04,78.71 94,77.75 94,76.63 93.57,76.2 93.57,75.74 93.56,75.73 93.56,73.11 93.57,73.1 93.57,71.14 94.06,70.65 94.32,70.65 94.35,70.64 94.38,70.64 94.76,70.64 94.79,70.64 94.82,70.65 95.11,70.65 95.14,70.64 95.16,70.64 95.55,70.64 95.57,70.64 95.6,70.65 95.9,70.65 95.94,70.65 96.32,70.65 96.37,70.65 96.64,70.65 96.69,70.64 97.07,70.64 97.12,70.65 97.37,70.65 97.42,70.65 97.8,70.65 97.84,70.65 97.89,70.65 98.02,70.52 98.02,70.1 97.89,69.96 93.13,69.96 92.58,70.5 92.58,74.17 92.63,74.25 92.73,74.26 92.82,74.22 92.91,74.21 93.28,74.57 92.91,74.94 92.82,74.92 92.73,74.89 92.63,74.89 92.58,74.98 92.58,76.5 92.83,76.76 92.83,77 92.86,77.07 92.94,77.1 93.3,77.47 92.94,77.83 92.86,77.82 92.2,78.48 92.2,78.64 92.43,78.86
+VCCIO_OUT on BOTTOM (solid shape): 93.6,76.88 93.6,75.03 93.49,74.92 93.34,74.92 93.34,74.91 93.04,74.91 92.97,74.93 92.91,74.94 92.55,74.57 92.91,74.21 93.16,74.3 93.27,74.54 93.28,74.59 93.37,74.59 93.37,74.58 93.53,74.58 93.6,74.51 93.6,71.09 93.68,71.01 93.68,70.55 93.64,70.51 93.49,70.51 92.89,71.11 92.89,71.93 92.78,72.03 92.78,72.04 92.3,72.51 92.3,74.4 92.33,74.45 92.34,74.48 92.34,74.86 92.33,74.9 92.31,74.93 92.29,74.97 92.58,75.26 92.63,75.3 92.66,75.34 92.77,75.45 92.77,76.04 92.78,76.05 92.8,76.09 92.81,76.13 92.81,76.76 93.03,76.99 93.5,76.99
+VCCIO_OUT on IN3 (solid shape): outline of 253 points within 99.06,74.9 109.78,79.8
+VCCRTC on TOP (solid shape): 159.59,68.33 159.59,67.77 159.66,67.7 159.66,67.69 160,67.36 160,67.36 160.02,67.34 160.39,67.34 160.6,67.13 160.6,66.49 160.58,66.47 159.21,66.47 159.05,66.62 159.05,67.15 159.16,67.15 159.16,67.87 159.05,67.87 159.05,68.26 159.22,68.43 159.5,68.43
+VCCST on TOP (solid shape): 168.12,47.39 168.12,42.72 167.41,42.01 167.41,41.73 167.26,41.58 167,41.58 166.85,41.73 166.85,42.21 167.49,42.85 167.49,45.57 167.55,45.78 167.49,45.99 167.49,47.44 167.61,47.57 167.94,47.57
+VCCST on TOP (solid shape): 201.22,17.17 201.22,16.57 201.44,16.34 201.44,16.29 201.44,15.91 201.44,15.91 200.49,15.91 200.3,16.11 200.27,16.18 200.3,16.25 200.34,16.3 200.37,16.35 200.37,16.61 200.34,16.65 200.32,16.69 200.29,16.75 200.32,16.82 200.34,16.86 200.37,16.9 200.37,17.15 200.29,17.26 200.19,17.33 200.05,17.33 199.97,17.39 199.86,17.42 199.84,17.42 199.66,17.6 199.52,17.6 199.37,17.75 199.22,17.75 199.21,17.77 198.82,17.77 198.82,18.1 198.84,18.11 199.21,18.11 199.25,18.16 200.23,18.16
+VCCST on TOP (solid shape): outline of 167 points within 116.87,88.77 135.18,100.63
+VCCST on TOP (solid shape): outline of 248 points within 78.31,106.3 81.23,111.88
+VCCST on BOTTOM (solid shape): 127.71,90.24 127.71,89.99 127.4,89.68 127.24,89.68 126.92,89.35 126.53,89.35 126.53,89.36 126.28,89.36 126.28,89.35 125.51,89.35 125.28,89.12 125.27,88.38 125.91,87.74 125.89,87.69 125.89,87.45 125.95,87.35 126.05,87.29 126.09,87.29 126.13,87.24 126.07,87.15 126.07,86.9 126.09,86.87 126.1,86.82 126.08,86.77 125.98,86.7 125.91,86.6 125.91,86.36 125.98,86.26 126.07,86.2 126.08,86.18 126.08,85.07 126.06,85.03 126.04,84.99 126.04,84.94 125.98,84.88 125.6,84.88 125.5,84.98 125.5,85.01 125.5,85.02 125.5,85.52 125.38,85.64 125.38,86.61 123.75,88.24 123.75,89.76 124.49,90.5 127.46,90.5
+VCCST on IN1 (solid shape): outline of 160 points within 173.53,33.58 181.31,38.35
+VCCST on IN2 (solid shape): outline of 169 points within 159.46,73.35 161.97,77.85
+VCCST on IN3 (solid shape): outline of 119 points within 195.68,17.27 200.81,23.59
+VCCST on IN3 (solid shape): outline of 169 points within 180.85,24.89 190.43,34.83
+VCCSTG on TOP (solid shape): outline of 275 points within 115.06,86 132.03,96.54
+VCCSTG on BOTTOM (solid shape): 118.06,91.03 120.06,91.03 120.95,90.14 120.95,90.12 121.03,90.04 121.03,89.07 121.03,89.07 121.01,88.96 121.03,88.85 121.03,88.84 121.03,88.66 122.2,87.49 123.55,87.49 124.66,86.38 124.66,86.01 124.66,86 124.63,85.88 124.66,85.75 124.66,85.74 124.66,84.94 124.59,84.86 124.23,84.86 124.15,84.94 124.15,85.16 123.82,85.49 123.82,86.15 123.32,86.65 121.1,86.65 120.29,87.47 120.29,87.53 120.04,87.78 120.04,87.98 120.04,87.99 120.04,88.26 120.04,88.27 120.04,88.48 120.06,88.51 120.07,88.54 120.07,88.85 120,88.96 119.89,89.03 119.8,89.03 119.76,89.08 119.38,89.08 119.02,89.43 119.02,89.79 118.92,89.89 118.81,89.89 118.74,89.92 118.49,89.92 118.46,89.91 118.42,89.89 117.6,89.89 117.6,89.89 117.35,89.89 117.34,89.89 115.95,89.89 115.82,90.02 115.82,90.9 116.03,91.11 117.98,91.11
+VCCSTG on BOTTOM (solid shape): outline of 279 points within 86.18,81.09 92.54,93.98
+VCCSTG on IN3 (solid shape): outline of 575 points within 87.34,92.66 119.67,99.02
+VCCSTG_OUT_FUSE on TOP (solid shape): outline of 172 points within 110.25,79.12 115.34,82.85
+VCCSTG_OUT_FUSE on BOTTOM (solid shape): outline of 171 points within 112.23,81.69 115.4,82.83
+VIN on TOP (solid shape): 114.04,113.43 114.04,110.49 113.84,110.28 109.68,110.28 109.22,109.83 107.87,109.83 107.21,110.49 107.21,112.06 108.8,113.65 113.83,113.65
+VIN on TOP (solid shape): 161.08,100.48 161.52,100.48 161.64,100.35 161.64,99.97 160.93,99.26 157.2,99.26 152.55,103.91 151.51,103.91 151.31,104.11 151.31,107.54 151.43,107.67 153.9,107.67
+VIN on TOP (solid shape): 68.32,112.21 68.32,105.26 68.18,105.12 65.64,105.12 65.56,105.2 65.56,105.79 66.09,106.32 66.09,112.19 66.27,112.37 68.17,112.37
+VIN on TOP (solid shape): 90.63,112.11 90.63,110.36 90.45,110.18 86.94,110.18 86.58,110.55 86.59,110.62 86.59,111.86 86.94,112.21 90.52,112.21
+VIN on TOP (solid shape): 177.26,90.09 179.07,90.09 179.3,89.86 179.3,88.29 178.99,87.98 178.99,86.97 178.81,86.78 178.62,86.69 178.51,86.51 177.01,86.51 176.53,86.99 175.89,86.99 175.69,86.79 170.56,86.79 169.87,87.48 169.87,89.74 170.48,90.34 177.01,90.34
+VIN on TOP (solid shape): 30,87.93 30,86.71 29.64,86.36 28.56,86.36 27.75,85.55 27.01,85.55 26.75,85.3 25.25,85.3 24.92,85.63 24.92,87.25 25.19,87.53 26.16,87.53 26.19,87.5 26.19,87.49 26.28,87.34 26.43,87.25 26.44,87.25 26.74,86.94 27.43,86.94 27.76,87.27 27.76,87.65 27.84,87.73 28.67,87.73 29,88.06 29.87,88.06
+VIN on TOP (solid shape): outline of 1445 points within 31.11,14.7 170.5,55.71
+VIN on BOTTOM (solid shape): 34.73,55.43 34.73,52.83 34.51,52.61 31.33,52.61 30.84,53.11 30.84,55.31 31.27,55.74 34.43,55.74
+VIN on BOTTOM (solid shape): 35,22.55 35,18.82 32.99,16.81 32.99,13.66 32.76,13.43 30.33,13.43 30.25,13.51 30.25,22.59 30.43,22.77 34.78,22.77
+VIN on BOTTOM (solid shape): 179.3,89.2 179.3,87.81 178.66,87.17 176.48,87.17 175.94,87.7 175.49,87.7 175.28,87.91 175.28,88.77 175.87,89.35 179.14,89.35
+VIN on BOTTOM (solid shape): 111.36,112.1 111.36,111.5 111.05,111.19 111.05,110.23 110.81,109.99 109.85,109.99 109.06,109.2 108.52,109.2 108.39,109.33 108.39,109.72 107.91,110.2 107.91,111.92 108.04,112.05 108.52,112.05 108.63,112.16 111.29,112.16
+VIN on BOTTOM (solid shape): 119.26,18.04 119.26,16.77 119.1,16.61 118.23,16.61 118.06,16.79 118.16,16.91 118.19,17.07 117.83,17.43 117.46,17.07 117.47,17.03 117.47,16.99 116.48,16.99 116.3,17.17 116.3,18.11 116.44,18.25 119.06,18.25
+VIN on BOTTOM (solid shape): 134.94,18.5 135.03,18.46 135.04,18.36 135.02,18.3 135.02,18.23 135.38,17.87 135.74,18.23 135.73,18.33 135.69,18.42 135.69,18.47 135.73,18.5 135.81,18.5 135.81,18.5 140.3,18.5 140.38,18.41 140.38,18.01 140.18,17.8 140.1,17.8 140,17.7 139.94,17.7 139.92,17.71 139.86,17.74 139.8,17.75 139.52,17.75 139.44,17.74 139.38,17.7 139.27,17.7 139.09,17.52 139.09,17.15 139.09,17.15 138.67,17.15 138.63,17.15 138.59,17.15 136.93,17.15 136.92,17.16 136.84,17.19 136.76,17.2 136.59,17.15 136.46,17.04 135.68,17.04 135.33,17.4 134.8,17.4 134.64,17.55 134.64,17.97 134.72,18.09 134.75,18.23 134.75,18.3 134.73,18.36 134.74,18.46 134.83,18.5
+VIN on BOTTOM (solid shape): outline of 221 points within 45.01,9.88 66.16,18.51
+VIN on SVCC (solid shape): outline of 1208 points within 19.08,52.65 110.69,112.37
+VIN on IN2 (solid shape): outline of 3427 points within 27.89,98.8 110.49,112.37
+VIN on IN3 (solid shape): outline of 1115 points within 66.09,105 110.08,112.37
+VIN_1.8VPCU on BOTTOM (solid shape): outline of 109 points within 114.65,13 122.35,16.91
+VIN_3VPCU on TOP (solid shape): 138.78,14.04 138.78,13.03 138.34,12.58 137.93,12.58 137.74,12.39 137.74,12.19 137.62,12.06 136.98,12.06 136.85,12.19 136.85,14.04 136.93,14.12 138.71,14.12
+VIN_3VPCU on BOTTOM (solid shape): 136.57,16.47 136.66,16.43 136.76,16.42 136.78,16.42 137.02,16.42 137.31,16.13 137.31,15.72 137.46,15.57 138.8,15.57 138.84,15.61 138.91,15.59 139.72,15.59 139.79,15.62 139.83,15.68 139.83,15.7 140.01,15.88 142.66,15.88 142.77,15.77 142.77,15.36 142.6,15.19 141.38,15.19 140.84,14.65 140.71,14.65 140.68,14.65 140.64,14.63 140.59,14.62 140.53,14.63 140.5,14.65 140.46,14.65 140.26,14.65 140.18,14.62 140.15,14.54 140.15,14.2 140.04,14.1 139.19,14.1 139.02,13.93 139.02,13.93 138.92,13.86 138.85,13.76 138.42,13.76 138.12,13.46 138.12,13.12 137.95,12.94 136.51,12.94 136.22,13.23 136.22,14.7 136.12,14.81 136.12,15.34 135.82,15.63 135.82,16.41 135.89,16.47
+VIN_5VPCU on TOP (solid shape): outline of 93 points within 164.46,14.42 169.87,17.83
+VIN_5VPCU on BOTTOM (solid shape): outline of 126 points within 161.97,12.57 169.89,17.45
+VIN_BLIGHT on TOP (solid shape): outline of 92 points within 24.06,27.96 28.4,33.88
+VIN_BLIGHT on BOTTOM (solid shape): 34.08,50.01 34.08,47.79 34.01,47.72 29.7,47.72 29.55,47.87 29.55,49.64 29.67,49.76 30.4,49.76 30.86,50.21 33.88,50.21
+VIN_BLIGHT on IN3 (solid shape): outline of 819 points within 26.36,30.81 34.48,49.78
+VIN_BLIGHT_L on TOP (solid shape): 28.36,29.58 28.36,28.63 28.34,28.58 28.34,28.54 28.34,28.26 28.34,28.23 28.36,28.18 28.36,27.85 28.34,27.8 28.34,27.76 28.34,27.48 28.34,27.45 28.36,27.4 28.36,27.21 28.55,27.02 28.55,26.45 28.53,26.43 28.53,26.18 28.45,26.11 28.43,26.1 28.37,26.07 28.34,25.99 28.34,25.61 28.35,25.57 28.39,25.52 28.39,25.48 28.51,25.36 28.51,25.18 27.75,24.42 26.75,24.42 26.44,24.72 26.44,25.5 26.45,25.5 26.45,26.38 26.48,26.46 26.56,26.49 26.61,26.48 26.87,26.59 26.98,26.85 26.96,26.94 26.93,27.03 26.91,27.06 26.95,27.1 26.95,27.56 27.05,27.66 27.33,27.66 27.56,27.89 27.56,28.01 27.56,28.29 27.56,28.42 27.46,28.52 26.37,28.52 26.31,28.46 26.23,28.4 26.17,28.32 25.84,27.99 25.24,27.99 25.19,28.04 25.19,29.48 25.3,29.59 25.52,29.59 25.88,29.94 27.99,29.94
+VIN_BLIGHT_L on BOTTOM (solid shape): 29.39,26.16 29.39,25.51 29.38,25.5 29.38,25.4 28.34,24.36 26.85,24.36 26.6,24.61 26.6,24.7 26.59,24.74 26.59,24.79 26.6,24.82 26.6,25.32 26.63,25.38 26.63,25.39 27.15,25.9 28.99,25.9 28.99,26.1 27.69,26.1 27.69,25.9 27.15,25.9 27.63,26.39 29.16,26.39
+VIN_DDR on TOP (solid shape): 95.6,18.18 95.6,17.94 94.99,17.33 94.99,16.3 94.99,16.25 96,15.25 96.45,15.25 96.85,14.85 96.85,12.98 96.47,12.6 93.83,12.6 93.57,12.85 93.57,15.39 93.61,15.42 93.61,15.48 93.61,15.51 93.61,15.81 93.61,15.85 93.61,16.08 93.57,16.12 93.57,17.27 93.72,17.42 94.31,17.42 95.15,18.26 95.53,18.26
+VIN_DDR on BOTTOM (solid shape): 96.62,15.54 96.62,12.98 96.8,12.8 100.81,12.8 101.09,12.52 101.09,11.94 100.84,11.68 100.4,11.68 100.07,11.35 100.07,10.24 100.07,10.2 100.06,10.16 100.07,10.12 100.07,10.07 100.07,9.96 99.95,9.84 98,9.84 97.55,9.39 96.6,9.39 96.44,9.55 96.44,10.21 95.71,10.95 94.36,10.95 93.88,11.43 93.88,15.44 94.28,15.85 96.31,15.85
+VIN_FBVDDQ_MEM on TOP (solid shape): 31.86,91.89 31.86,90.73 31.85,90.69 31.85,90.65 31.85,90.61 31.86,90.57 31.86,90.14 31.84,90.06 31.83,89.99 31.84,89.92 31.86,89.85 31.86,89.81 32.15,89.51 32.15,87.4 32.03,87.27 31.42,87.27 31.24,87.09 30.4,87.09 30.15,87.35 30.15,89.18 29.39,89.94 29.39,90.37 29.5,90.48 29.86,90.48 30.53,89.81 30.99,89.81 31.16,89.99 31.16,90.01 31.18,90.02 31.18,90.9 30.88,91.2 30.88,91.82 31.04,91.97 31.78,91.97
+VIN_FBVDDQ_MEM on BOTTOM (solid shape): 32.26,93.37 32.26,91.17 32.08,90.99 32.07,90.99 31.96,90.91 31.88,90.8 31.88,90.79 31.75,90.66 31.75,89.89 32.06,89.58 32.79,89.58 33.04,89.33 33.04,88.61 32.75,88.31 32.1,88.31 31.95,88.16 31.95,87.93 31.82,87.81 31.47,87.81 31.25,88.02 31.25,88.03 31.03,88.25 31.02,88.25 30.96,88.31 27.66,88.31 27.58,88.39 27.58,88.92 27.51,89 27.41,89 27.41,89.01 27,89.01 26.92,89.04 26.89,89.12 26.9,89.17 26.9,89.24 26.93,89.27 27.41,89.27 27.41,89.28 27.56,89.28 27.58,89.3 27.58,89.48 27.86,89.76 30.35,89.76 30.52,89.93 30.52,90.58 30.73,90.79 30.76,90.79 31.01,90.9 31.12,91.16 31.11,91.24 31.08,91.32 31.07,91.35 31.57,91.85 31.57,92.94 31.37,93.14 30.88,93.14 30.83,93.19 30.83,93.65 30.99,93.8 31.82,93.8
+VIN_GPU on TOP (solid shape): outline of 685 points within 49.91,100.23 77.62,112.37
+VIN_GPU on BOTTOM (solid shape): 72.46,112.19 72.46,109.32 72.21,109.07 66.24,109.07 66.09,109.22 66.09,110.56 66.24,110.72 68.25,110.72 68.53,111 68.53,112.11 68.7,112.29 72.36,112.29
+VIN_GPU on BOTTOM (solid shape): 78.05,112.16 78.05,111.15 77.44,110.54 77.44,105.71 77.32,105.59 76.91,105.59 76.81,105.69 76.81,106.32 77.04,106.55 77.04,108.51 76.81,108.74 76.68,108.74 76.45,108.96 76.45,110.49 76.2,110.74 76.02,110.74 75.84,110.92 75.84,112.21 75.89,112.27 77.95,112.27
+VIN_GPU on BOTTOM (solid shape): 51.64,104.7 51.64,103.96 51.79,103.81 52.17,103.81 52.32,103.66 52.32,103.15 52.53,102.94 56.41,102.94 56.69,103.22 57.3,103.22 57.45,103.07 57.45,102.69 57.38,102.61 54.35,102.61 54.2,102.46 54.2,102.05 54.07,101.93 52.3,101.93 52.04,102.18 49.63,102.18 49.55,102.26 49.55,103.73 49.74,103.92 49.74,104.63 49.88,104.77 51.56,104.77
+VIN_VCC_CORE on TOP (solid shape): outline of 421 points within 94.05,105.43 111.11,111.85
+VIN_VCC_CORE on BOTTOM (solid shape): 102.25,112.05 102.25,106.71 102,106.46 97.66,106.46 97.65,106.46 94.87,106.46 94.77,106.56 94.77,107.53 94.86,107.62 95.51,107.62 96.78,108.89 96.78,109.78 97.08,110.08 98.25,110.08 98.43,110.27 98.43,111.8 98.43,111.81 98.43,112.04 98.69,112.31 102,112.31
+VIN_VCC_CORE on BOTTOM (solid shape): 110.21,107.38 110.99,107.38 111.54,106.83 111.54,106.53 111.54,105.91 111.54,105.87 111.54,105.05 111.38,104.89 109.24,104.89 109.14,105 109.14,105.23 109.12,105.25 109.12,105.28 108.72,105.68 108.72,106.37 108.71,106.38 108.71,106.61 108.51,106.82 107.03,106.82 107.02,106.83 107.02,107.97 107.12,108.07 107.76,108.07 108,108.32 109.27,108.32
+VIN_VCC_CORE_R on TOP (solid shape): outline of 91 points within 90.96,107.31 99.16,112.27
+VIN_VCCIN_AUX on TOP (solid shape): 123.16,109.83 123.16,109.07 123.04,108.94 116.84,108.94 116.63,108.74 116.63,107.11 116.28,106.75 115.42,106.75 115.31,106.86 115.31,109.07 115.14,109.24 114.48,109.24 114.32,109.4 114.32,109.9 114.38,109.96 123.03,109.96
+VIN_VCCIN_AUX on BOTTOM (solid shape): 119.78,111.25 122.56,111.25 123.02,110.79 123.02,110.53 123.02,110.52 123.02,107.83 122.9,107.69 122.85,107.52 122.85,107.46 122.87,107.41 122.87,107.38 122.68,107.19 119.48,107.19 119.3,107.36 119.3,107.64 119.3,108.5 118.37,109.44 118.37,110.51 118.16,110.72 117.19,110.72 117.01,110.54 117.01,109.53 116.87,109.39 116.24,109.39 116.23,109.38 116.07,109.38 115.83,109.14 115.83,107.33 115.83,107.33 115.83,107.14 115.69,107.01 114.85,107.01 114.56,107.29 114.56,109.57 114.1,110.04 112.88,110.04 112.7,110.22 112.7,111.24 112.85,111.4 116.76,111.4 117.06,111.69 119.34,111.69
+VIN_VCCIN_AUX_R on TOP (solid shape): outline of 132 points within 110.23,106.8 114.96,110
AGND on TOP (solid shape): 199.9,34.79 199.9,34.41 200.05,34.26 201.73,34.26 201.81,34.18 201.81,33.56 201.5,33.25 201.04,33.25 200.78,32.99 200.78,32.2 200.73,32.15 200,32.15 199.97,32.18 199.97,32.89 199.65,33.21 199.5,33.21 199.16,33.55 199.16,35.02 199.26,35.13 199.56,35.13
AGND on TOP (solid shape): 204.49,40.09 204.49,40.08 205.02,39.55 204.46,38.68 204.96,37.78 204.96,32.97 204.5,31.84 205.47,31.09 207.74,31.09 207.82,31.01 207.82,30.11 207.64,29.93 205.39,29.93 203.55,31.12 203.87,33.29 203.87,37.99 203.39,38.47 203.52,39.54 204.2,40.39
AGND on BOTTOM (solid shape): 197.08,35.43 197.08,34.31 196.92,34.16 196.67,34.16 196.16,34.67 194.56,34.67 194.31,34.41 194.31,34.23 194.16,34.08 193.93,34.08 193.77,34.24 193.77,35.79 193.85,35.86 196.64,35.86
AGND on BOTTOM (solid shape): 204.46,38.58 204.61,38.12 204.96,37.78 204.96,32.97 204.5,31.84 205.47,31.09 207.46,31.09 207.62,30.93 207.62,30.27 207.28,29.93 205.39,29.93 203.55,31.12 203.87,33.29 203.87,37.42 203.63,37.75 203.47,38.12 203.93,38.58
AGND on SGND (solid shape): outline of 126 points within 193.24,28.37 216.83,43.13
AGND on IN1 (solid shape): 202.89,42.47 206.15,42.47 206.16,41.29 205.39,41.29 205.05,41.26 204.71,41.2 204.63,41.21 204.59,41.29 204.59,41.46 204.21,41.83 203.69,41.83 203.31,41.45 203.3,41.45 202.36,42.39 199.08,42.39 198.78,42.09 198.78,41.83 198.91,41.7 198.91,41.43 198.52,41.04 198.04,41.04 197.05,40.05 196.14,40.05 196.09,40.1 196.09,41.32 196.97,42.21 196.97,42.8 197.28,43.1 202.26,43.1
AGND on IN1 (solid shape): 216.83,39.66 212.61,39.66 212.52,39.71 212.52,39.81 212.58,39.95 212.6,40.11 212.53,40.38 212.34,40.59 212.29,40.71 212.39,40.78 215.82,40.78 215.82,41.86 216.83,41.86
AGND on IN1 (solid shape): 205.55,40.78 205.65,40.71 205.6,40.59 205.41,40.38 205.34,40.11 205.36,39.95 205.42,39.81 205.43,39.71 205.35,39.65 204.48,38.85 204.96,37.78 204.96,32.97 204.5,31.84 205.47,31.09 208.1,31.09 208.19,31.04 208.19,30.93 208.11,30.78 208.09,30.61 208.16,30.33 208.36,30.12 208.4,30.01 208.31,29.93 205.39,29.93 205.06,29.96 204.73,30.04 203.48,31.29 203.44,31.43 203.41,31.57 203.41,32 204.04,32.64 204.04,37.69 203.66,38.08 203.66,38.69 203.77,38.8 203.77,39.97 204.48,40.56 205.39,40.78
AGND on SVCC (solid shape): 213.13,41.93 213.21,41.88 213.31,41.86 215.31,41.86 215.31,41.29 211.52,41.29 211.26,41.69 210.92,42.03 211.38,42.49 212.57,42.49
AGND on SVCC (solid shape): outline of 111 points within 193.24,28.37 212.47,43.13
AGND on IN2 (solid shape): 205.33,40.08 205.33,40.06 205.36,39.93 205.41,39.8 205.42,39.71 205.34,39.65 204.48,38.85 204.96,37.78 204.96,32.97 204.5,31.84 205.47,31.09 207.82,31.09 207.87,31.04 207.87,30.24 207.57,29.93 205.39,29.93 203.55,31.12 203.87,33.29 203.87,37.42 203.55,37.91 203.39,38.46 203.39,38.52 203.38,38.52 203.59,39.68 204.4,40.52 204.47,40.56 204.53,40.59 204.82,40.59
AGND on SGND1 (solid shape): outline of 126 points within 193.24,28.37 216.83,43.13
GND on TOP (solid shape): 92.23,76.07 92.23,72.39 92.08,72.24 91.51,72.24 91.39,72.36 91.39,76.1 91.46,76.17 92.13,76.17
GND on TOP (solid shape): 172.79,102.69 172.79,101.42 172.67,101.29 171.65,101.29 171.52,101.42 171.52,102.69 171.65,102.82 172.67,102.82
GND on TOP (solid shape): 181.84,89.79 181.84,89.1 181.68,88.95 179.68,88.95 179.53,89.1 179.53,89.76 179.73,89.96 181.66,89.96
GND on TOP (solid shape): 28.99,50.4 28.99,48.98 28.88,48.87 28.17,48.87 28.09,48.94 28.09,49.68 28.25,49.84 28.25,50.87 28.52,50.87
GND on TOP (solid shape): 203.36,10.06 203.36,9.76 203.22,9.62 202.29,9.62 201.92,9.99 201.92,10.19 202.13,10.4 203.02,10.4
GND on TOP (solid shape): 188.7,90.44 188.74,90.37 188.8,90.31 188.8,88.77 188.69,88.67 188.31,88.67 188.21,88.77 188.21,90.68 188.7,90.68
GND on TOP (solid shape): 194.6,26.36 194.6,25.81 194.65,25.75 194.65,25.18 194.93,24.9 194.93,24.6 194.87,24.54 194.33,24.54 194.24,24.63 194.24,25.51 193.96,26.19 193.96,26.43 194.06,26.53 194.42,26.53
GND on TOP (solid shape): 86.92,70.89 86.92,68.86 86.59,68.53 86.36,68.53 86.18,68.71 86.18,69.67 86.05,69.8 84.38,69.8 84.28,69.9 84.28,70.33 84.38,70.43 85.85,70.43 86.38,70.97 86.84,70.97
GND on TOP (solid shape): 199.64,46 199.64,45.55 199.4,45.31 198.78,45.31 198.52,45.06 198.52,44.07 198.27,43.81 196.42,43.81 196.24,43.99 196.24,45.19 196.42,45.36 197.19,45.36 197.95,46.12 199.51,46.12
GND on TOP (solid shape): 144.66,74.17 145.41,74.17 145.46,74.12 145.46,73.75 145.36,73.65 143.53,73.65 143.06,74.13 143.03,74.24 143.13,74.3 144.53,74.3
GND on TOP (solid shape): 88.54,75.03 88.54,72.72 88.47,72.64 87.78,72.64 87.75,72.67 87.75,73.66 87.65,73.76 86.81,73.76 86.79,73.78 86.79,73.94 86.82,73.96 87.68,73.96 87.77,74.05 87.77,75.09 87.81,75.13 88.44,75.13
GND on TOP (solid shape): 85,76.78 85,75.77 84.66,75.42 84.66,73.81 85.03,73.43 85.03,72.48 84.86,72.31 83.47,72.31 83.29,72.49 83.29,73 83.65,73.36 83.65,75.78 83.17,76.26 82.78,76.26 82.53,76.5 82.53,76.84 82.65,76.96 84.82,76.96
GND on TOP (solid shape): 82.73,69.97 83.26,69.97 83.75,69.48 83.75,68.51 83.51,68.27 83.31,68.27 83.06,68.02 83.06,67.61 83.01,67.56 82.67,67.56 82.62,67.61 82.62,68.15 83.26,68.78 83.26,69.24 82.95,69.54 82.37,69.54 81.53,70.38 81.53,70.64 81.66,70.76 81.94,70.76
GND on TOP (solid shape): 93.4,17.51 93.5,17.45 93.48,17.34 93.46,17.32 93.46,16.08 93.5,16.04 93.5,15.47 93.42,15.39 93.11,15.39 93,15.5 93,15.97 92.7,16.28 92.7,17.51
GND on TOP (solid shape): 27.26,65.21 27.32,65.19 27.38,65.14 27.43,65.1 27.5,65.09 28.2,65.09 28.32,64.97 28.32,63.8 28.17,63.65 27.02,63.65 26.9,63.78 26.9,65.04 27.08,65.22 27.22,65.22
GND on TOP (solid shape): 150.48,66.05 153.69,66.05 153.7,66.05 153.7,65.91 150.93,65.91 150.72,65.7 150.03,65.7 149.92,65.81 149.97,65.9 149.97,66.15 149.95,66.19 149.99,66.22 150.03,66.23 150.31,66.23
GND on TOP (solid shape): 91.47,15.11 91.47,12.09 91.88,11.68 91.88,10.18 91.82,10.09 91.71,10.11 90.79,11.03 90.79,11.03 90.69,11.13 89.31,11.13 88.99,11.44 88.99,13.25 89.5,13.75 89.5,15.09 89.64,15.23 91.35,15.23
GND on TOP (solid shape): 125.97,79.59 125.97,78.83 125.42,78.27 125.41,78.27 125.33,78.19 125.19,78.19 125.05,78.19 124.37,78.19 123.47,79.1 123.27,79.1 123.13,79.23 123.13,79.68 123.16,79.71 125.86,79.71
GND on TOP (solid shape): 22.45,34.41 22.45,33.12 22.27,32.94 21.97,32.94 21.89,33.02 21.86,33.02 21.86,33.16 21.85,33.19 21.85,33.31 21.82,33.39 21.74,33.42 21.57,33.42 21.06,33.94 21.06,34.28 21.31,34.53 22.34,34.53
GND on TOP (solid shape): 16.2,46.89 16.3,46.83 16.28,46.72 16.27,46.71 16.27,45.36 15.71,44.8 15.71,43.23 15.26,42.79 15.15,42.77 15.09,42.86 15.09,46.49 15.49,46.89
GND on TOP (solid shape): 96.7,12.67 96.81,12.69 96.87,12.59 96.87,9.58 96.7,9.4 93.8,9.4 93.64,9.57 93.64,10.03 93.56,10.1 93.56,12.45 93.62,12.55 93.73,12.53 93.78,12.48 96.51,12.48
GND on TOP (solid shape): 175.97,60.66 176.07,60.6 176.05,60.49 176.01,60.45 176.01,60.12 175.85,59.96 175.56,59.96 175.17,59.57 175.17,59.35 175.08,59.25 174.65,59.25 174.6,59.2 174.55,59.19 174.52,59.24 174.52,59.53 175.65,60.66
GND on TOP (solid shape): 144.67,75.98 146.52,75.98 146.52,75.93 146.52,75.87 143.28,75.87 143.27,75.86 142.94,75.86 142.88,75.87 142.85,75.92 142.85,76.18 142.77,76.28 142.67,76.35 142.6,76.35 142.56,76.43 142.59,76.51 142.91,76.83 143.81,76.83
GND on TOP (solid shape): 129.1,113.89 129.8,113.6 130.09,112.9 130.09,109.9 130.14,109.46 130.29,109.04 130.02,109.04 125.17,113.89
GND on TOP (solid shape): 46.79,69.01 45.74,69.01 45.65,69.11 45.27,69.11 45.25,69.09 45.21,69.08 45.15,69.07 45.07,69.08 45.01,69.12 44.98,69.15 44.91,69.15 44.84,69.18 44.81,69.26 44.82,69.38 46.13,69.38 46.33,69.59 46.79,69.59
GND on TOP (solid shape): 137.72,65.2 137.78,65.19 137.82,65.14 137.81,65.11 137.81,64.92 137.71,64.83 137.71,62.6 137.79,62.52 137.79,61.39 137.61,61.21 137.52,61.3 137.52,64.39 137.15,64.76 137.12,64.83 137.14,64.9 137.19,64.9 137.23,64.92 137.41,65.1 137.42,65.13 137.44,65.2
GND on TOP (solid shape): 148.7,54.57 148.88,54.56 148.94,54.57 149.02,54.56 149.07,54.49 149.07,53.83 148.87,53.83 148.7,53.66 148.47,53.66 147.93,54.2 147.93,54.5 147.98,54.55 148.36,54.55 148.48,54.57 148.59,54.62
GND on TOP (solid shape): 162.35,8.15 162.35,7.46 162.12,7.23 161.15,7.23 161.05,7.22 160.99,7.27 160.98,7.34 160.98,7.41 161.01,7.49 161.08,7.53 161.28,7.53 161.4,7.65 161.4,8.16 161.47,8.23 162.27,8.23
GND on TOP (solid shape): 15.7,33.6 15.7,32.61 15.39,32.31 15.39,27.81 15.7,27.51 17.47,27.51 17.6,27.38 17.6,26.87 17.47,26.74 14.83,26.74 14.82,26.73 14.27,26.73 14.04,26.5 12.01,26.5 11.94,26.58 11.94,26.59 11.55,26.97 11.55,27.38 11.63,27.46 13.26,27.46 13.38,27.58 13.38,31.95 13.14,32.19 12.36,32.19 12.11,32.43 12.11,33.35 12.24,33.47 12.65,33.47 12.95,33.78 15.52,33.78
GND on TOP (solid shape): 200.39,83.05 200.38,83.02 200.37,82.98 200.37,82.95 200.37,82.67 200.38,82.59 200.43,82.52 200.43,82.37 200.14,82.08 199.87,82.08 199.58,81.78 199.58,81.02 199.67,80.92 199.62,80.87 199.56,80.87 198.64,81.79 198.64,82.18 199.11,82.65 199.73,82.65 199.79,82.67 199.83,82.71 199.85,82.74 199.97,82.74 200.33,83.11
GND on TOP (solid shape): 41.57,71.87 41.63,71.88 41.66,71.83 41.66,71.74 42.04,71.36 42.04,71.02 41.52,71.02 41.26,70.94 41.09,70.71 41.02,70.65 40.92,70.68 40.89,70.71 40.89,71.68 41.04,71.84 41.54,71.84
GND on TOP (solid shape): 202.96,7.35 203.21,7.35 203.8,6.76 203.8,6.52 203.96,6.36 203.96,6.19 203.96,6.16 203.98,6.13 204,6.08 203.99,6.02 203.79,5.93 203.68,5.75 200.23,5.75 200.06,5.92 200.06,5.98 200.05,5.99 200.05,6.25 200.13,6.33 200.73,6.33 201.04,6.64 201.04,7.43 201.29,7.68 202.62,7.68
GND on TOP (solid shape): 52.76,71.02 52.82,71.11 52.92,71.11 53,71.08 53.08,71.06 53.15,71.03 53.18,70.96 53.18,67.99 56.6,64.57 56.6,60.6 54.55,58.55 54.14,58.55 53.69,58.1 49.88,58.1 47.3,60.68 47.3,62.32 48.39,63.42 49.02,64.93 50.34,66.25 50.34,66.89 50.34,67.34 52.76,69.76

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R7508  470K_2  [R0201]  16.81 46.84 90 top
R7509  *0_4/S  [S0402]  18.9 31.95 90 top
R7515  *0_4  [R0402]  19.91 30.68 270 top
R7516  *0_2/S  [S0201]  20.69 34.14 270 top
R7518  *0_2/S  [S0201]  19.91 32.26 270 top
R7519  *0_4  [R0402]  23.24 32.87 0 top
R7520  *100K/F_2  [R0201]  21.87 33.12 180 top
R7600  10K/F_2  [R0201]  181.48 39.88 180 top
R7601  100K_2  [R0201]  181.64 48.17 90 top
R7602  *10K/F_2  [R0201]  180.22 44.41 90 top
R7603  33_4  [R0402]  179.42 35.76 180 top
R7604  33_4  [R0402]  177.76 35.13 90 top
R7605  33_4  [R0402]  175.75 35.13 90 top
R7606  *0.01_1%_6/S  [S0603]  180.95 50.74 0 top
R7607  6.2K/F_2  [R0201]  173.3 43.76 270 top
R7608  33_4  [R0402]  174.79 35.13 90 top
R7609  33_4  [R0402]  173.82 36.14 90 top
R7610  *0_4/S  [S0402]  202.69 27.68 90 top
R7611  *0_4/S  [S0402]  202.56 24.76 180 bottom
R7613  *0_2/S  [S0201]  181.2 41.48 270 top
R7614  10K/F_2  [R0201]  180.39 43.02 180 top
R7615  150_1%_2  [R0201]  164.16 102.94 270 top
R7616  270_1%_2  [R0201]  164.51 101.67 270 top
R7617  *0_4/S  [S0402]  12.8 17.24 90 top
R7618  *0_4/S  [S0402]  11.83 17.24 90 top
R7700  0_4  [R0402]  122.68 90.22 0 bottom
R7701  *51_2  [R0201]  50.11 40.08 180 top
R7702  0_4  [R0402]  50.11 49.91 180 top
R7703  1K_1%_2  [R0201]  50.11 41.48 180 top
R7705  1K_1%_2  [R0201]  50.49 49.06 180 top
R7706  0_5%_4  [R0402]  38.87 51.13 180 top
R7707  *0_4  [R0402]  50.11 38.81 180 top
R7710  150_5%_4  [R0402]  51.51 41.48 0 top
R7711  10K_5%_2  [R0201]  209.27 11.22 90 bottom
R7712  *0_5%_2/S  [S0201]  208.94 12.85 180 bottom
R7713  33_5%_4  [R0402]  207.31 13.23 270 bottom
R7714  33_5%_4  [R0402]  208.68 13.74 0 bottom
R7715  33_5%_4  [R0402]  208.56 14.7 0 bottom
R7716  33_5%_4  [R0402]  208.35 15.67 0 bottom
R7717  33_5%_4  [R0402]  207.92 16.63 0 bottom
R7718  *0_5%_2/S  [S0201]  206.57 16.79 180 bottom
R7719  10_1%_2  [R0201]  208.23 18.16 0 bottom
R7722  49.9K_1%_2  [R0201]  207.85 24.38 0 bottom
R7723  49.9K_1%_2  [R0201]  207.85 25.35 0 bottom
R7724  *0_5%_4  [R0402]  38.89 50.11 180 top
R7726  1K_1%_2  [R0201]  147.84 93.12 180 top
R7727  0_5%_6  [R0603]  82.95 74.75 270 top
RR1  *HCB1608KF-121T30  [R0603]  165.2 18.11 270 top
SW5000  T3C2QR  [SW-SOX-154HNT-2P]  31.19 27.56 90 bottom
TP400  *  [TP2050]  108.61 80.03 0 top
TP401  *  [TP2050]  112.62 89.69 0 top
TP402  *  [TP2050]  129.34 81.08 0 top
TP600  *  [TP2050]  104.68 89.3 0 top
TP601  *  [TP2050]  96.34 82.5 180 bottom
TP602  *  [TP2050]  97.78 74.21 180 bottom
TP603  *  [TP2050]  97.78 78.32 180 bottom
TP604  *  [TP2050]  96.34 85.42 180 bottom
TP605  *  [TP2050]  96.34 83.89 180 bottom
TP606  *  [TP2050]  96.34 81.13 180 bottom
TP607  *  [TP2050]  96.62 79.7 180 bottom
TP608  *  [TP2050]  138.12 72.16 0 top
TP609  *  [TP2050]  147.84 71.37 180 bottom
TP800  *  [TP2050]  148.94 74.47 180 bottom
TP1000  *  [TP2050]  149.07 62.3 180 bottom
TP1001  *  [TP2050]  96.82 63.95 180 bottom
TP1002  *  [TP2050]  150.34 62.2 180 bottom
TP1003  *  [TP2050]  96.82 65.22 180 bottom
TP1004  *  [TP2050]  141.4 58.35 180 bottom
TP1005  *  [TP2050]  95.74 90.41 180 bottom
TP1006  *  [TP2050]  97.05 90.39 180 bottom
TP1007  *  [TP2050]  133.81 70.43 0 top
TP1008  *  [TP2050]  135.33 70.69 0 top
TP1009  *  [TP2050]  149.95 85.71 180 bottom
TP1010  *  [TP2050]  149 87.03 180 bottom
TP1011  *  [TP2050]  96.38 86.95 180 bottom
TP1012  *  [TP2050]  96.35 88.9 180 bottom
TP1013  *  [TP2050]  145.07 90.35 180 bottom
TP1014  *  [TP2050]  146.01 91.2 180 bottom
TP1015  *  [TP2050]  148.99 88.33 180 bottom
TP1016  *  [TP2050]  149.04 89.67 180 bottom
TP1017  *  [TP2050]  98.33 90.35 180 bottom
TP1018  *  [TP2050]  98.42 91.82 180 bottom
TP1019  *  [TP2050]  143.72 90.43 180 bottom
TP1020  *  [TP2050]  143.74 91.77 180 bottom
TP1021  *  [TP2050]  114.68 80.92 0 top
TP1022  *  [TP2050]  116.13 81.56 0 top
TP1023  *  [TP2050]  149.5 60.83 180 bottom
TP1024  *  [TP2050]  112.72 81.3 0 top
TP1025  *  [TP2050]  148.68 85.77 180 bottom
TP1026  *  [TP2050]  113.56 80.31 0 top
TP1027  *  [TP2050]  116.13 89.28 180 bottom
TP1028  *  [TP2050]  150.06 64.56 180 bottom
TP1029  *  [TP2050]  151.34 63.98 180 bottom
TP1030  *  [TP2050]  137.57 81.33 0 top
TP1031  *  [TP2050]  92.37 75.56 270 bottom
TP1200  *  [TP2050]  161.11 74.65 0 top
TP1201  *  [TP2050]  140.69 90.09 180 bottom
TP1500  *  [TP2050]  142.6 57.61 180 bottom
TP1602  *  [TP2050]  115.64 79.91 0 top
TP1800  *TP  [TP2050]  201.78 38.89 180 bottom
TP1801  *TP  [TP2050]  194.89 4.6 0 top
TP1802  *TP  [TP2050]  24.41 34.11 180 top
TP1803  *TP  [TP2050]  24.21 25.69 0 top
TP1804  *TP  [TP2050]  205.26 27.51 180 bottom
TP1805  *TP  [TP2050]  141.05 13.04 0 top
TP1806  *TP  [TP2050]  176.24 3.6 0 top
TP1808  *TP  [TP2050]  180.19 29.06 0 top
TP1809  *TP  [TP2050]  16.57 16.92 0 top
TP1901  *TP  [TP2050]  44.85 12.58 0 top
TP1902  *TP  [TP2050]  144.68 11.68 0 top
TP1903  *TP  [TP2050]  110.36 13.05 0 top
TP1904  *TP  [TP2050]  170.66 99.44 0 top
TP1905  *TP  [TP2050]  190.97 54.16 0 top
TP1906  *TP  [TP2050]  157.58 6.3 0 top
TP1907  *TP  [TP2050]  166.6 71.22 0 top
TP1908  *TP  [TP2050]  27.84 56.49 0 top
TP1909  *TP  [TP2050]  24.28 68.33 0 top
TP2000  *TP  [TP2050]  76.27 10.11 0 top
TP2001  *TP  [TP2050]  118.82 93.67 0 top
TP2002  *TP  [TP2050]  20.83 9.77 0 top
TP2004  *TP  [TP2050]  201.75 75.64 180 top
TP2005  *TP  [TP2050]  173.4 53.39 0 top
TP2006  *TP  [TP2050]  174.04 104.8 180 bottom
TP2007  *TP  [TP2050]  144.55 8.1 0 top
TP2008  *TP  [TP2050]  23.43 27.03 0 top
TP2010  *TP  [TP2050]  82.76 111.76 0 top
TP2800  *PAD  [TP2050]  158.8 24.36 0 top
TP2801  *PAD  [TP2050]  159.46 27.91 0 top
TP2900  *PAD  [TP2050]  83.13 23.52 0 top
TP2901  *PAD  [TP2050]  82.57 27.96 0 top
TP3602  *  [TP2050]  198.98 37.95 180 bottom
TP4100  *  [TP2050]  194.2 76.91 180 bottom
TP4101  *  [TP2050]  194 78.36 180 bottom
TP4102  *  [TP2050]  195.22 77.7 180 bottom
TP4104  *  [TP2050]  188.87 81.02 180 bottom
TP4200  *TP  [TP2050]  206.4 2.69 0 top
TP4201  *  [TP2050]  158.44 58.6 180 bottom
TP4203  *  [TP2050]  209.45 18.39 180 bottom
TP4300  *  [TP2050]  10.64 42.06 0 top
TP4700  *  [TP2050]  201.93 14.42 0 top
TP4800  *  [TP2050]  196.37 15.64 180 bottom
TP5101  *  [TP2050]  164.23 67.46 0 top
TP5600  *  [TP2675]  166.93 72.95 90 bottom
TP5601  *  [TP2675]  160.24 84.8 90 bottom
TP5602  *  [TP2675]  163.14 70.61 90 bottom
TP5603  *  [TP2675]  165.53 70.79 90 bottom
TP5610  *TP  [TP2675]  155.22 93.9 180 bottom
TP5611  *TP  [TP2675]  163.19 72.65 180 bottom
TP5612  *TP  [TP2675]  200.71 26.85 270 top
TP5613  *TP  [TP2675]  190.29 29.13 270 top
TP5614  *TP  [TP2675]  201.3 25.22 270 bottom
TP5615  *TP  [TP2675]  199.77 24.08 270 bottom
TP5616  *TP  [TP2675]  202.08 26.97 270 bottom
TP5617  *TP  [TP2675]  200.05 28.67 270 bottom
TP5618  *TP  [TP2675]  200.18 26.77 180 bottom
TP5900  *  [TP2050]  180.53 92.35 180 bottom
TP5901  *  [TP2050]  182.01 92.29 180 bottom
TP5902  *  [TP2050]  183.39 92.22 180 bottom
TP5903  *  [TP2050]  185.62 89.74 180 bottom
TP5904  *  [TP2050]  189.21 99.28 180 bottom
TP5905  *  [TP2675]  187.55 58.42 90 bottom
TP5906  *  [TP2675]  189.96 60.4 90 bottom
TP5907  *  [TP2675]  179.27 64.84 90 bottom
TP5908  *  [TP2675]  189.99 67.94 90 bottom
TP5909  *  [TP2675]  179.35 62.61 90 bottom
TP5910  *  [TP2675]  179.22 60.32 90 bottom
TP5911  *  [TP2675]  190.07 65.66 90 bottom
TP6101  *TP  [TP2050]  188.03 82.88 0 top
TP6102  *TP  [TP2050]  187.65 81.61 180 bottom
TP6600  *  [TP2050]  64.82 59.05 0 top
TP6800  *  [TP2675]  54.07 97.94 0 top
TP6803  *  [TP2675]  55.34 96.26 0 top
TP6805  *  [TP2675]  64.06 93.93 0 top
TP6806  *  [TP2675]  64.06 95.83 0 top
TP6807  *  [TP2675]  55.34 94.31 0 top
TP6809  *  [TP2675]  65.99 96.97 0 top
TP6902  *  [TP2050]  61.03 92.15 0 top
TP6903  *  [TP2050]  63.83 92.15 0 top
TP6904  *  [TP2050]  62.56 92.15 0 top
TP6905  *  [TP2050]  83.71 67.62 180 bottom
TP6906  *  [TP2050]  82.4 68.02 180 bottom
TP6907  *  [TP2050]  82.58 66.63 180 bottom
TP6908  *  [TP2050]  85.19 64.95 180 bottom
TP7000  *  [TP2050]  47.95 88.5 180 bottom
TP7001  *  [TP2050]  47.95 70.43 180 bottom
TP7700  *TP  [TP2050]  39.55 42.67 0 top
TP7701  *TP  [TP2050]  49.65 44.69 0 top
TP7703  *TP  [TP2050]  38.68 47.95 0 top
TP7704  *TP  [TP2050]  38.68 49.22 0 top
TP7705  *TP  [TP2050]  168.68 82.84 180 bottom
TP7706  *TP  [TP2050]  209.04 24.38 270 bottom
TP7707  *TP  [TP2050]  209.03 25.96 270 bottom
TP8200  *TP  [TP2050]  58.09 9.73 180 top
TP8201  *TP  [TP2050]  56.28 2.87 180 top
TP8202  *TP  [TP2050]  57.61 2.74 180 top
TP9800  *TP  [TP2050]  34.22 107.64 0 top
TP9801  *TP  [TP2050]  32 107.54 0 top
U400  *TGL_U_IP_EXT/BGA  [BGA1449-INTEL-TIGERL-U]  122.84 74.5 0 bottom
U1501  *MC74VHC1G08DFT2G  [SOT353-2_1-65-5P]  153.47 46.94 0 top
U1502  *MC74VHC1G08DFT2G  [SOT353-2_1-65-5P]  159.59 73.15 270 bottom
U1600  G5244T11U  [TSOT23-2_8-95-5P-G916-475TOUF]  153.87 71.52 180 bottom
U1800  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  195.15 2.87 0 top
U1801  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  200.2 39.8 90 bottom
U1802  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  25.35 35.89 90 top
U1803  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  25.31 27.51 90 top
U1804  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  141.16 14.89 90 top
U1805  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  202.82 28.37 180 bottom
U1806  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  176.73 5.23 90 top
U1807  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  14.59 16.8 270 top
U1809  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  181.96 28.52 0 top
U1900  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  146.38 10.69 0 top
U1902  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  43.81 14.04 180 top
U1903  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  109.68 15.19 90 top
U1904  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  168.98 97.74 270 top
U1905  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  191.92 55.83 90 top
U1906  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  160.75 7.19 90 top
U1907  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  168.76 71.02 0 top
U1908  *INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  28.65 54.56 0 top
U1909  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  25.85 67.28 0 top
U2000  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  74.24 10.36 180 top
U2001  *INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  120.22 92.15 0 top
U2002  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  19.09 11.35 180 top
U2004  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  200.48 77.29 180 top
U2005  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  176.35 53.41 0 top
U2006  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  176.01 105.12 0 bottom
U2007  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  144.8 6.42 0 top
U2008  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  21.7 27 180 top
U2010  INA231AIYFFR  [BGA12-TEXAS-INA231-0_5S]  84.43 111.07 0 top
U3400  G5245AT11U  [SOT23-5-2_8-95-5P-G708]  31.32 35.02 270 bottom
U3402  *G5245AT11U  [SOT23-5-2_8-95-5P-G708]  21.92 58.37 270 top
U3404  *G5245AT11U  [SOT23-5-2_8-95-5P-G708]  28.78 52.78 270 bottom
U3405  74LVC1G3157GW  [SOT363-2_1-65-6P-74LVC1G98GW]  30.33 39.66 0 top
U3500  *G5250Q1T73U  [SOT23-2_38-95-3P]  195.62 45.03 0 top
U3501  PS8203  [TQFN32-3X6-4-41P-0_8H]  200.06 56.97 270 top
U3600  ALC3247-CG  [QFN40-5X5-4-41P-SMB349NT]  195.15 37.92 270 top
U4100  PJA3415  [SOT23-2-95-3P]  198.37 74.16 180 top
U4102  *NL17SZ08EDFT2G  [SOT353-2_1-65-5P]  180.72 86.15 180 top
U4200  74AUP1G97GM  [SOT363-2_1-65-6P-74LVC1G98GW]  191.31 6.04 180 top
U4400  *74LVC1G3157GW  [SOT363-2_1-65-6P-74LVC1G98GW]  209.7 9.74 90 top
U4700  NPCX797HA1BX  [BGA144-NUVOTON-NPCX797H]  195.44 18.29 0 top
U4701  SN74LVC2G07DCKR  [SOT363-2_1-65-6P]  177.58 58.18 270 top
U5100  NPCT750HABYX  [QFN32-5X5-5-33P-SLB9645VQ]  164.14 62.37 0 top
U5400  G781P8  [MSOP8-4_9-65-G547]  92.4 78.81 270 bottom
U5401  G708T1U  [SOT23-5-2_8-95-5P-G708]  29.72 74.42 270 bottom
U5403  G781-1P8  [MSOP8-4_9-65-G547]  158.7 16.33 90 bottom
U5602  WSON 8X6 BIOS SOCKET  [50950-0084N-001-8P-SOCKET]  162.85 92.86 270 bottom
U5603  *50951-0084N-V01  [50951-0084N-V01-8P-SOCKET]  194.64 27.28 270 bottom
U5604  *W25Q256JVEIQ  [SON8-8X6-1_27-9P]  162.92 92.83 270 bottom
U5605  GD25B256DYIGR  [SON8-8X6-1_27-9P]  194.64 27.28 270 bottom
U5900  JHL8040R SLMN6  [BGA105-INTEL-DELTABRIDGE-0_5S]  185.27 96.09 90 bottom
U5901  *50951-0084N-V01  [50951-0084N-V01-8P-SOCKET]  184.7 64.15 90 bottom
U5902  W25Q80DVSSIG  [SOIC8-7_9-1_27-2_16H]  184.71 64.16 90 bottom
U5904  TPS22908YZTR  [BGA4-TEXAS-TPS22907YZTR]  174.24 104.96 90 top
U6100  CYPD6127-48LQXI  [QFN48-6X6-4-49P-0_6H]  191.21 85.29 0 bottom
U6101  PI3USB221AZUAEX  [QFN10-2X1_5-5-0_65H]  196.8 93.87 180 bottom
U6200  AZ176S-04  [ESD10-2_5X1-5-0_5H]  200.73 69.54 270 top
U6201  AZ176S-04  [ESD10-2_5X1-5-0_5H]  200.61 92.15 270 top
U6202  G517H1T11U  [SOT23-2_8-95-5P-G517]  204.49 81.99 180 top
U6203  TPS2546RTER  [QFN16-3X3-5-17P-TPS2546RTER]  197.64 83.67 0 top
U6600  N18S-G5-A1  [BGA603-NVIDIA-N18S-G5-A1]  67.84 77.3 270 bottom
U6601  NL17SZ08EDFT2G  [SOT353-2_1-65-5P]  79.24 61.16 270 bottom
U6701  NL17SZ32DFT2G  [SOT353-2_1-65-5P]  85.83 97.04 180 bottom
U6801  SPI_FLASH  [WSON8-6X5-1_27-9P-W25Q64FWZPIG]  59.64 95.83 270 top
U6901  NL17SZ32DFT2G  [SOT353-2_1-65-5P]  81.37 99.3 90 bottom
U6902  NL17SZ08EDFT2G  [SOT353-2_1-65-5P]  88.75 97.04 180 bottom
U7500  SLG4E43291VTR  [QFN8-1_2X1-4]  22.05 42.24 90 top
U7600  RTS5237S  [QFN32-4X4-5-33P-RTS5227-GRT]  177.62 39.95 180 top
U7601  AOZ1335DI_2  [DFN8-3X3-65-7P]  84.17 66.75 90 top
VC3500  *TVM0G5R5M220R  [C0402]  202.94 44.47 90 top
VC5001  AVLC 5S 02 200  [C0402]  13.03 40.41 0 top
VC6200  *AVLC5S_4  [C0402]  200.53 86.11 270 top
VC6201  *AVLC5S_4  [C0402]  201.45 65.48 180 top
VC6202  *AVLC5S_4  [C0402]  208.1 83 180 top
VRAM7000  GDDR5  [BGA170-HYNIX-H5GC8H24AJR]  40.34 88.5 270 bottom
VRAM7001  GDDR5  [BGA170-HYNIX-H5GC8H24AJR]  40.34 70.5 270 bottom
Y1400  32.768KHZ/20ppm  [XTL-3_2X1_5-2_5-0_8H]  149.93 51.64 0 top
Y1401  38.4MHZ/10ppm  [XTL-2X1_6-1_35X1_05-0_7H]  141.83 95.3 0 bottom
Y5900  25MHZ +10PPM  [XTL-3_2X2_5-2_2X1_7]  188.6 104.54 180 bottom
Y6800  27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7-0_8H]  72.97 93.95 180 bottom

## Library data of the parts
C500 C800 C1302 C1303 C1401-C1406 C1649 C1650 C1653 C1656 C1800-C1813 C1815 C1816 C1818 C1819 C1900 C1902 C1903 C1905-C1919 C2000-C2002 C2004-C2006 C2008-C2016 C2018 C2019 C2021 C3427 C4105 C4112 C4114 C4400 C4706 C4712 C4713 C4801 C5031 C5109-C5112 C5209 C5210 C5404 C5405 C5604 C5605 C5900 C5901 C5904 C5905 C5908 C5909 C5912 C5913 C5916 C5917 C5925 C5935 C5940 C5941 C6109-C6111 C6212 C6214-C6217 C6306 C6308-C6315 C6600-C6610 C6612-C6617 C6619-C6626 C6628 C6630-C6651 C6653 C6654 C6656 C6657 C6662-C6678 C6680 C6683 C6686-C6689 C6693 C6698-C6719 C6800 C6802 C6803 C6806-C6810 C6900-C6902 C7221 C7222 C7237-C7239 C7618 C7619 C7700 C7701 C7730 C7732 C7734 C7736 C7740 C7742 C7746 C7749 C7760 C7762 C7763 C7765 C7767 C7768 EC1-EC3 EC5 PC8000-PC8006 PC8105-PC8107 PC8206 PC8207 PC8214-PC8216 PC8219 PC8400-PC8410 PC8600 PC8601 PC8615 PC8619 PC8627 PC8634-PC8636 PC8700-PC8708 PC8710-PC8721 PC8724-PC8726 PC8800-PC8806 PC8808-PC8811 PC8813 PC8814 PC8816-PC8819 PC8900 PC8902-PC8905 PC8908-PC8910 PC8920 PC8922-PC8925 PC8927-PC8929 PC9100 PC9103-PC9106 PC9109 PC9119 PC9121-PC9123 PC9201 PC9204-PC9207 PC9209 PC9210 PC9215-PC9218 PC9800-PC9802 PC9804 PC9805 PC9903 PC9906 PC9907 PC9910 PC9914 PC9916 PC9918 PC9921 PC9922 PC10200 PC10201 PC10206-PC10212 PC10215-PC10220 PC10500 PC10503-PC10505 PC10625-PC10637 = CAP_NON-POL_BGM
C700-C770 C773 C1100 C1101 C1300 C1301 C1304-C1313 C1400 C1500-C1504 C1600-C1648 C1651 C1652 C1654 C1655 C1700-C1727 C2800-C2819 C2821-C2828 C2900 C2901 C2903-C2905 C2907-C2929 C3300 C3400 C3401 C3403-C3423 C3425 C3426 C3500-C3508 C3521-C3531 C3600-C3628 C3700-C3702 C4100 C4101 C4103 C4109-C4111 C4113 C4200 C4203-C4219 C4300-C4304 C4306-C4315 C4401-C4406 C4700-C4705 C4707-C4711 C4714-C4722 C4802 C4804 C4806-C4808 C5000 C5001 C5045 C5100 C5107 C5108 C5201 C5204-C5208 C5400-C5403 C5406 C5410-C5413 C5600 C5601 C5606 C5918-C5924 C5926-C5934 C5936-C5939 C6100-C6108 C6112 C6113 C6200-C6209 C6213 C6682 C6684 C6697 C6818 C7000-C7061 C7200-C7210 C7215-C7220 C7223-C7234 C7236 C7600-C7617 C7731 C7733 C7735 C7737-C7739 C7741 C7743-C7745 C7747 C7748 C7750-C7759 C7761 C7764 C7766 EC4 EC2800 EC2802 EC2803 EC2900-EC2903 EC3600-EC3607 EC3700-EC3704 EC4301 PC8100-PC8104 PC8108 PC8109 PC8200 PC8201 PC8203-PC8205 PC8208-PC8213 PC8217 PC8220-PC8227 PC8411 PC8602-PC8614 PC8616-PC8618 PC8620-PC8626 PC8628-PC8633 PC8709 PC8722 PC8723 PC8807 PC8812 PC8815 PC8901 PC8906 PC8907 PC8919 PC8921 PC8926 PC8938 PC9101 PC9102 PC9108 PC9110-PC9114 PC9120 PC9202 PC9203 PC9208 PC9211-PC9214 PC9500-PC9523 PC9526-PC9529 PC9534 PC9536-PC9538 PC9543 PC9601 PC9605 PC9803 PC9900-PC9902 PC9904 PC9911 PC9912 PC9915 PC9917 PC10202-PC10204 PC10213 PC10214 PC10501 PC10502 PC10506-PC10516 PC10624 PC10638-PC10642 VC3500 VC6200-VC6202 = CAP NON-POL_BGM
C4800 C4805 C5029 C5034 VC5001 = Varistor_BGM
C5202 C5203 C6210 C6211 D6313 D6314 = V-PORT_0
CON1900 = 53398-0410_6
CON3400 = GS12401-1011_2
CON3401 = Header_6P_2F_BGM
CON3501 = HDMI_19P_PDMR004019P1-1_BGM
CON3601 CON5400 = Header_4P_R_BGM
CON3700 = AUDIO_6P_M315624G_BGM
CON4100 CON4300 = NGFF CONN_4
CON4202 = NGFF_79P_BKEY_NFSB0_BGM
CON4203 = HEADER_4P_2F_BGM
CON4204 = SIMCARD_7P_4F_V3_BGM
CON4400 CON5200 CON5202 CON7704 = FFCFPC_8P_2F_V1_BGM
CON4402 = FFCFPC_15P_2F_BGM
CON4700 = HEADER_2P_2F_BGM
CON5000 = FFCFPC_42P_BGM
CON5002 = FFCFPC_8P_BGM
CON6201 CON6202 = USB3_9P_4F_V1_BGM
CON6300 = USB3_1_24P_8fix_V3_BGM
CON7600 = CRD_9P_158-1000902616_BGM
CON7602 = FFCFPC_40P_V2_BGM
CON7603 = FFCFPC_6P_BGM
CON7700 = CON30X1_9
CON7701 = CON40A_2
CON7702 = CONN_2
CON7703 = XDP_0
D1400 D7501 PD8205 PD9600-PD9604 = BAT54C_BGM
D1500 D1600 D3600 D4201 D6900 D6902 PD8002 PD8206 PD8700 PD9800 PD9801 PD10500 = Schottky_DIODE_BGM
D3300 D4200 = DIODE
D3500 PD8100 = BAT54A_BGM
D3700-D3703 D4203-D4206 = V-PORT
D5000-D5003 = BAW56DW_1
D5900-D5907 PD8400 PD8401 = TVS_DIODE_BGM
D6300 PD8000 PD8001 PD8200 PD8201 PD8203 PD8402 = ZENER_DIODE_BGM
D6306 D6307 D6309 D6310 = TVS_DIODE_UNI_BGM
D6901 = BAT54S_BGM
F3400 F4200 = FUSE
F3401-F3403 F3405 F3500 F4400 F4401 F5002 F5003 F5202 F5203 F7603 F7605 F7606 = FUSE_BGM
H7900-H7916 H7918-H7924 = HOLE 1
JDIM2800 JDIM2900 = DDR3_1
L3400 L5901 PR8200 PR8215 PR9510 R1616 R3412 R3415 R3604 R4101 R4200 R4300 R5216 R5400 R5622 R5901 R6104 R7606 = R_Current_SEN_BGM
L3401 L3402 L3601 L4700 L5900 PL8202 PL8601 PL8604 PL8701 PL8702 PL8902 PL8903 PL9101 PL9200 PL9900 PL9901 PL10500 = INDUCTOR_BGM
L3403 L6600 L6700 L6701 PL8600 PL8602 PL8603 PL8700 PL8900 PL8901 PL8904 PL8905 PL9100 PL9102 PL9201 PL10200 RR1 = BEAD_BGM
L3600 PR8000-PR8002 PR8006 PR8008 PR8009 PR8011 PR8013-PR8027 PR8100-PR8122 PR8124-PR8127 PR8203-PR8208 PR8210-PR8213 PR8217-PR8220 PR8226 PR8227 PR8230 PR8232 PR8235-PR8241 PR8243 PR8244 PR8400-PR8409 PR8412-PR8420 PR8602 PR8605 PR8608 PR8612-PR8614 PR8616 PR8618-PR8623 PR8702 PR8704 PR8705 PR8707 PR8708 PR8713-PR8715 PR8718 PR8720 PR8722-PR8725 PR8800-PR8809 PR8811-PR8824 PR8828 PR8830 PR8832 PR8834 PR8836-PR8840 PR8842 PR8845 PR8846 PR8900 PR8901 PR8904 PR8907 PR8908 PR8911 PR9100-PR9104 PR9107 PR9108 PR9110-PR9112 PR9115-PR9120 PR9122 PR9203 PR9207 PR9209 PR9210 PR9212-PR9214 PR9513 PR9514 PR9601 PR9603 PR9606 PR9611 PR9612 PR9800 PR9803 PR9805-PR9809 PR9812 PR9815 PR9817 PR9819 PR9821-PR9823 PR9825-PR9829 PR9831-PR9833 PR9901 PR9902 PR10200 PR10201 PR10203 PR10205-PR10207 PR10210-PR10214 PR10501 PR10504 PR10507-PR10511 PR10518-PR10520 PR10613 PR10617-PR10619 PR10623 PR10625 R400-R407 R500 R504 R506 R509-R513 R600 R602-R618 R620 R621 R624-R628 R700 R703-R707 R800-R807 R810-R820 R1000-R1043 R1100-R1112 R1114-R1117 R1119-R1146 R1200-R1249 R1300-R1304 R1306-R1308 R1400-R1429 R1500-R1507 R1509-R1546 R1548-R1550 R1553 R1560-R1562 R1566 R1572-R1576 R1601-R1607 R1609-R1615 R1617 R1900-R1904 R2800-R2821 R2900-R2921 R3300-R3309 R3400-R3403 R3405-R3411 R3413 R3414 R3417 R3419-R3422 R3425 R3428 R3429 R3431-R3435 R3500-R3509 R3514-R3517 R3600-R3603 R3605 R3607-R3614 R3616-R3620 R3622 R3700-R3702 R4102 R4112 R4113 R4117-R4121 R4126-R4137 R4139-R4141 R4144 R4151-R4156 R4201-R4214 R4217-R4221 R4226-R4233 R4301 R4304 R4308 R4309 R4311 R4404-R4417 R4701-R4712 R4714 R4717-R4753 R4800 R4802-R4825 R5000 R5002 R5004 R5005 R5007 R5009-R5011 R5013 R5016-R5019 R5026-R5028 R5100 R5101 R5108 R5110-R5112 R5120-R5130 R5200-R5204 R5208 R5211 R5212 R5217 R5218 R5401-R5408 R5417-R5419 R5601-R5608 R5612 R5613 R5623-R5637 R5900 R5902-R5945 R5947-R5965 R6100-R6103 R6105-R6110 R6112 R6114 R6115 R6117 R6119 R6122-R6125 R6129 R6200-R6203 R6304-R6311 R6314 R6319 R6602 R6611 R6612 R6615-R6617 R6701-R6710 R6712 R6713 R6800 R6804-R6812 R6826 R6828 R6831 R6838 R6839 R6841 R6902-R6911 R6913-R6919 R6923 R6924 R6926-R6929 R6943 R6944 R6946 R6947 R6950-R6954 R6956-R6958 R6960-R6965 R7000-R7018 R7500-R7509 R7515 R7516 R7518-R7520 R7600-R7605 R7607-R7611 R7613-R7618 R7700-R7703 R7705-R7707 R7710-R7719 R7722-R7724 R7726 R7727 = RES_BGM
L6200 L6201 = BW
LED7600 = D-LED_0
PC8202 PC8218 PC8637 PC8638 PC8917 PC8918 PC8937 PC8939 PC9107 PC9118 PC9909 PC9913 PC9920 PC9923-PC9926 PC10221 = CAP_POL_BGM
PCN8000 = Housing_7P_2fix_BGM
PCN8400 = Header_10P_BGM
PD8202 PD8204 PD8207 = DIODE_BGM
PL8000 PL8001 PL8400 PL9902 PL9903 PR8028 PR8029 PR8123 PR8209 PR8214 PR8216 PR8223-PR8225 PR8228 PR8229 PR8231 PR8233 PR8234 PR8242 PR8245 PR8410 PR8411 PR8421 PR8422 PR8600 PR8601 PR8606 PR8609 PR8610 PR8617 PR8701 PR8703 PR8706 PR8716 PR8717 PR8825-PR8827 PR8829 PR8831 PR8833 PR8835 PR8843 PR8844 PR8902 PR8903 PR8909 PR8910 PR8914 PR9105 PR9106 PR9109 PR9114 PR9121 PR9123-PR9125 PR9204-PR9206 PR9208 PR9500-PR9505 PR9507 PR9509 PR9518 PR9520 PR9522 PR9600 PR9613 PR9810 PR9811 PR9813 PR10202 PR10204 PR10208 PR10209 PR10215 PR10502 PR10503 PR10506 PR10512 PR10514-PR10517 PR10611 PR10612 PR10614 PR10615 PR10621 PR10622 R6127 R6128 = SHORTPAD_V01_BGM
PL10201 = INDUCTOR_V02_BGM
PQ8000 PQ8006 PQ8007 PQ8200 = MOS-P_8P_BGM
PQ8001 PQ8203 PQ8204 = MOS-N_8P_V3_BGM
PQ8002 PQ8009 PQ8010 PQ8201 PQ9801 Q1501 Q1502 Q5005 U4100 = MOS-P_3P_BGM
PQ8003 PQ8004 PQ8205 PQ8402 PQ8403 PQ8702 PQ9601 PQ9802 Q500 Q800 Q801 Q1000 Q1400 Q1500 Q3403-Q3406 Q4104 Q4106 Q4200 Q4300 Q4401 Q4800 Q5001 Q5004 Q5006 Q5201 Q5202 Q6100 Q6902 Q6904 Q7000 Q7001 Q7500 Q7502 Q7506-Q7508 = MOS-N_3P_ESD_BGM
PQ8008 PQ8011 PQ8400 PQ8404 PQ8405 = PNP_BGM
PQ8012 PQ8013 PQ8202 = PNP_Dual_6P_BGM_2
PQ8401 Q3600 Q4108 Q4111 Q6800 Q6802 = NPN_BGM
PQ8700 = MOS-N-Dual_9P_BGM
PQ8703 PQ9100 Q1100 Q4400 Q4703 Q5101 Q5401 Q5404 Q6901 Q6903 = MOS-N_Dual_6P_ESD_BGM
PQ9800 PQ10200 PQ10500 PQ10501 PQ10603 = MOS-N_Dual_6P_PJT7828_V2_BGM
PR8201 PR8202 PR8221 PR8222 PR8607 PR8615 PR8700 PR8709-PR8712 PR8719 PR8721 PR8905 PR8906 PR8912 PR8913 PR9801 PR9802 PR9804 PR9814 PR9816 PR9820 PR9830 PR9900 PR10505 R5214 R5215 = SHORTPAD_BGM
PR8810 PR8841 = Thermistor_BGM
PU8100 = AS393MTR-G1_BGM
PU8101 = G1363U61U_BGM
PU8102 U1502 = MC74VHC1G08DFT2G_5P_BGM
PU8200 = MAX8731EEI_1
PU8201 = G753T11U_BGM
PU8601 = SYV127FTMC_13P_V2_BGM
PU8602 = NB680AGD-Z_BGM
PU8700 = RT8231BGQW_BGM
PU8701 PU10500 = G2822CTB1U_6P_BGM
PU8800 = ISL95860HRTZ-T_32P_V2_BGM
PU8900 PU8901 = AOZ5507QI_22P_V2_BGM_0
PU9100 = MP2491GL-Z_19P_BGM
PU9200 = NB691GG-Z_11P_BGM
PU9500-PU9502 PU10501 PU10601 = G923_3
PU9600 PU9601 PU10602-PU10606 = 74LVC1G32GW_5P_BGM
PU9800 = MP2958_1
PU9900 PU9901 = MP86903-CGLT-Z_BGM
PU10200 = AOZ2260QI-18_BGM
Q501 Q5403 = NPN_0
Q4112 Q7600 = 2N7002
Q5000 = 2N7002DW
Q6600 Q6601 Q6801 = DTC144EU_BGM
Q6900 = 2N7002_3
R5014 = R
R5015 = RP-8
R6618 R6619 R6912 = RES_BGM: tolerance: 5 %
SW5000 = SW_2P_BGM
TP400-TP402 TP600-TP609 TP800 TP1000-TP1031 TP1200 TP1201 TP1500 TP1602 TP1800-TP1806 TP1808 TP1809 TP1901-TP1909 TP2000-TP2002 TP2004-TP2008 TP2010 TP4200 TP4300 TP5610-TP5618 TP5900-TP5911 TP6101 TP6102 TP6600 TP6800 TP6803 TP6805-TP6807 TP6809 TP6902-TP6908 TP7000 TP7001 TP7700 TP7701 TP7703-TP7707 TP8200-TP8202 TP9800 TP9801 = TP_BGM
TP2800 TP2801 TP2900 TP2901 = PAD_3
TP3602 TP4100-TP4102 TP4104 TP4201 TP4203 TP4700 TP4800 TP5101 TP5600-TP5603 = PAD_2
U400 = TGL_U_IP_EXT/BGA_1
U1501 = 7SH08_1
U1600 = G5245AT11U_BGM_0
U1800-U1807 U1809 U1900 U1902-U1909 U2000-U2002 U2004-U2008 U2010 = INA231AIYFFR_12P_BGM
U3400 U3402 = IMISM530_0
U3404 = G5245AT11U_BGM
U3405 U4400 = 74LVC1G3157GW_6P_BGM
U3500 = G5250Q1T73U_BGM
U3501 = PS8338B_3
U3600 = PS8339A_1
U4102 U6601 U6902 = NL17SZ08DFT2G_5P_BGM
U4200 U6202 = BD82047FVJ-GE2_BGM_0
U4700 = NPCX797HA0BX_144P_BGM
U4701 = BU4S66_0
U5100 = SLD9630_1
U5400 = LM86
U5401 = LM86_0
U5403 = G781_BGM
U5602 = W25Q256JVEIQ_8P_BGM_1
U5603 U5901 = Socket_8P_V2_BGM
U5604 U5605 = W25Q256JVEIQ_8P_BGM
U5900 = Burnside_Bridge_105P_BGM
U5902 = W25Q80BWSSIG_BGM
U5904 = TPS22924CYZPR_6P_BGM_0
U6100 = CYPD6127-48LQXI_48P_V5_BGM
U6101 = PI3USB221AZUAEX_10P_BGM
U6200 U6201 = G995_2
U6203 = TPS2546RTER_BGM
U6600 = GPU_N18S-G5-A1_603P_BGM
U6701 U6901 = NL17SZ32DFT2G_BGM
U6801 = IC_0
U7500 = SLG4E43291VTR_8P_V2_BGM
U7600 = RTS5138_1
U7601 = AOZ1335DI_8P_BGM
VRAM7000 VRAM7001 = GDDR5_170P_BGM
Y1400 = CRYSTAL_2P_BGM
Y1401 Y6800 = CRYSTAL_4P_BGM
Y5900 = CRYSTAL2_4

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-8X8-S
  round 0.991 smd: 1(7,-4)
10P8R
  rect 0.305x1.092 smd: 1(-1.27,-0.85) 2(-0.635,-0.85) 3(0,-0.85) 4(0.635,-0.85) 5(1.27,-0.85) 6(1.27,0.85) 7(0.635,0.85) 8(0,0.85) 9(-0.635,0.85) 10(-1.27,0.85)
50224-00701-001-7P-L
  rect 0.61x1.549 smd: 1(-3,3.875) 2(-2,3.875) 3(-1,3.875) 4(0,3.875) 5(1,3.875) 6(2,3.875) 7(3,3.875)
  rect 1.194x1.803 smd: 8(-4.3,0) 9(4.3,0)
50271-00201-001-2P-L
  rect 0.787x1.6 smd: 1(-0.625,2.9) 2(0.625,2.9)
  rect 2.108x2.997 smd: 3(-3.175,0) 4(3.175,0)
50376-00601-V01-6P-L
  rect 0.406x0.61 smd: 1(-1.5,1.375) 2(-0.9,1.375) 3(-0.3,1.375) 4(0.3,1.375) 5(0.9,1.375) 6(1.5,1.375)
  rect 0.711x1.041 smd: 7(-2.45,0) 8(2.45,0)
50950-0084N-001-8P-SOCKET
  round 0.838 hole 0.838 unplated: (2.5,-2)
  round 1.041 hole 1.041 unplated: (2.5,2)
  rect 0.838x1.397 smd: 1(-1.905,-4.8) 2(-0.635,-4.8) 3(0.635,-4.8) 4(1.905,-4.8) 5(1.905,4.8) 6(0.635,4.8) 7(-0.635,4.8) 8(-1.905,4.8)
50951-0084N-V01-8P-SOCKET
  rect 0.66x1.346 smd: 1(-1.905,-3.825) 2(-0.635,-3.825) 3(0.635,-3.825) 4(1.905,-3.825) 5(1.905,3.825) 6(0.635,3.825) 7(-0.635,3.825) 8(-1.905,3.825)
51273-00401-V01-4P-L
  rect 0.61x0.838 smd: 1(-1.8,3.825) 2(-0.6,3.825) 3(0.6,3.825) 4(1.8,3.825)
  rect 1.092x0.711 smd: 5(-3.395,0) 6(3.395,0)
51536-01541-V01-15P-L
  rect 0.305x0.66 smd: 1(-3.5,2.075) 2(-3,2.075) 3(-2.5,2.075) 4(-2,2.075) 5(-1.5,2.075) 6(-1,2.075) 7(-0.5,2.075) 8(0,2.075) 9(0.5,2.075) 10(1,2.075) 11(1.5,2.075) 12(2,2.075) 13(2.5,2.075) 14(3,2.075) 15(3.5,2.075)
  rect 0.559x0.787 smd: 16(-4.425,0) 17(4.425,0)
51614-00801-V01-8P-L
  rect 0.305x0.787 smd: 1(-1.75,2.9) 2(-1.25,2.9) 3(-0.75,2.9) 4(-0.25,2.9) 5(0.25,2.9) 6(0.75,2.9) 7(1.25,2.9) 8(1.75,2.9)
  rect 0.406x0.787 smd: 9(-2.75,0.4) 10(2.75,0.4)
51693-0400T-V01-40P-L
  rect 0.305x1.295 smd: 1(-9.75,5.65) 2(-9.25,5.65) 3(-8.75,5.65) 4(-8.25,5.65) 5(-7.75,5.65) 6(-7.25,5.65) 7(-6.75,5.65) 8(-6.25,5.65) 9(-5.75,5.65) 10(-5.25,5.65) 11(-4.75,5.65) 12(-4.25,5.65) 13(-3.75,5.65) 14(-3.25,5.65) 15(-2.75,5.65) 16(-2.25,5.65) 17(-1.75,5.65) 18(-1.25,5.65) 19(-0.75,5.65) 20(-0.25,5.65) 21(0.25,5.65) 22(0.75,5.65) 23(1.25,5.65) 24(1.75,5.65) 25(2.25,5.65) 26(2.75,5.65) 27(3.25,5.65) 28(3.75,5.65) 29(4.25,5.65) 30(4.75,5.65) 31(5.25,5.65) 32(5.75,5.65) 33(6.25,5.65) 34(6.75,5.65) 35(7.25,5.65) 36(7.75,5.65) 37(8.25,5.65) 38(8.75,5.65) 39(9.25,5.65) 40(9.75,5.65)
  rect 1.803x2.21 smd: 41(-11.9,0) 42(11.9,0)
88511-180N-18P-L
  rect 0.305x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
AUDIO-2SJ3095-239251F-6P
  oval 0.991x1.905 hole 0.61x1.499: 1(-4.8,7.15) 2(4.7,1.65) 3(-4.8,1.95) 4(-4.8,-0.65) 5(4.7,7.15) 6(4.7,4.4)
BGA4-TEXAS-TPS22907YZTR
  round 0.254 smd: A1(-0.25,-0.25) A2(-0.25,0.25) B1(0.25,-0.25) B2(0.25,0.25)
BGA12-TEXAS-INA231-0_5S
  round 0.254 smd: A1(-0.6,-0.4) A2(-0.6,0) A3(-0.6,0.4) B1(-0.2,-0.4) B2(-0.2,0) B3(-0.2,0.4) C1(0.2,-0.4) C2(0.2,0) C3(0.2,0.4) D1(0.6,-0.4) D2(0.6,0) D3(0.6,0.4)
BGA105-INTEL-DELTABRIDGE-0_5S
  oval 0.178x0.33 smd: A1(-2.53,-2.53) A12(-2.53,2.53) B1(-2.07,-2.53) B12(-2.07,2.53) C1(-1.61,-2.53) C12(-1.61,2.53) D1(-1.15,-2.53) D12(-1.15,2.53) E1(-0.69,-2.53) E12(-0.69,2.53) F1(-0.23,-2.53) F12(-0.23,2.53) G1(0.23,-2.53) G12(0.23,2.53) H1(0.69,-2.53) H12(0.69,2.53) J1(1.15,-2.53) J12(1.15,2.53) K1(1.61,-2.53) K12(1.61,2.53) L1(2.07,-2.53) L12(2.07,2.53) M1(2.53,-2.53) M12(2.53,2.53)
  oval 0.33x0.178 smd: A2(-2.53,-2.07) A3(-2.53,-1.61) A4(-2.53,-1.15) A5(-2.53,-0.69) A6(-2.53,-0.23) A7(-2.53,0.23) A8(-2.53,0.69) A9(-2.53,1.15) A10(-2.53,1.61) A11(-2.53,2.07) M2(2.53,-2.07) M3(2.53,-1.61) M4(2.53,-1.15) M5(2.53,-0.69) M6(2.53,-0.23) M7(2.53,0.23) M8(2.53,0.69) M9(2.53,1.15) M10(2.53,1.61) M11(2.53,2.07)
  round 0.229 smd: B2(-2.07,-2.07) B3(-2.07,-1.61) B4(-2.07,-1.15) B5(-2.07,-0.69) B6(-2.07,-0.23) B7(-2.07,0.23) B8(-2.07,0.69) B9(-2.07,1.15) B10(-2.07,1.61) B11(-2.07,2.07) C2(-1.61,-2.07) C3(-1.3,-1.3) C5(-1.3,-0.65) C6(-1.3,0) C7(-1.3,0.65) C9(-1.3,1.3) C11(-1.61,2.07) D2(-1.15,-2.07) D11(-1.15,2.07) E2(-0.69,-2.07) E3(-0.65,-1.3) E5(-0.65,-0.65) E6(-0.65,0) E7(-0.65,0.65) E9(-0.65,1.3) E11(-0.69,2.07) F2(-0.23,-2.07) F3(0,-1.3) F5(0,-0.65) F6(0,0) F7(0,0.65) F9(0,1.3) F11(-0.23,2.07) G2(0.23,-2.07) G3(0.65,-1.3) G5(0.65,-0.65) G6(0.65,0) G7(0.65,0.65) G9(0.65,1.3) G11(0.23,2.07) H2(0.69,-2.07) H11(0.69,2.07) J2(1.15,-2.07) J3(1.3,-1.3) J5(1.3,-0.65) J6(1.3,0) J7(1.3,0.65) J9(1.3,1.3) J11(1.15,2.07) K2(1.61,-2.07) K11(1.61,2.07) L2(2.07,-2.07) L3(2.07,-1.61) L4(2.07,-1.15) L5(2.07,-0.69) L6(2.07,-0.23) L7(2.07,0.23) L8(2.07,0.69) L9(2.07,1.15) L10(2.07,1.61) L11(2.07,2.07)
BGA144-NUVOTON-NPCX797H
  round 0.356 smd: A1(-3.575,-3.575) A2(-3.575,-2.925) A3(-3.575,-2.275) A4(-3.575,-1.625) A5(-3.575,-0.975) A6(-3.575,-0.325) A7(-3.575,0.325) A8(-3.575,0.975) A9(-3.575,1.625) A10(-3.575,2.275) A11(-3.575,2.925) A12(-3.575,3.575) B1(-2.925,-3.575) B2(-2.925,-2.925) B3(-2.925,-2.275) B4(-2.925,-1.625) B5(-2.925,-0.975) B6(-2.925,-0.325) B7(-2.925,0.325) B8(-2.925,0.975) B9(-2.925,1.625) B10(-2.925,2.275) B11(-2.925,2.925) B12(-2.925,3.575) C1(-2.275,-3.575) C2(-2.275,-2.925) C3(-2.275,-2.275) C4(-2.275,-1.625) C5(-2.275,-0.975) C6(-2.275,-0.325) C7(-2.275,0.325) C8(-2.275,0.975) C9(-2.275,1.625) C10(-2.275,2.275) C11(-2.275,2.925) C12(-2.275,3.575) D1(-1.625,-3.575) D2(-1.625,-2.925) D3(-1.625,-2.275) D4(-1.625,-1.625) D5(-1.625,-0.975) D6(-1.625,-0.325) D7(-1.625,0.325) D8(-1.625,0.975) D9(-1.625,1.625) D10(-1.625,2.275) D11(-1.625,2.925) D12(-1.625,3.575) E1(-0.975,-3.575) E2(-0.975,-2.925) E3(-0.975,-2.275) E4(-0.975,-1.625) E5(-0.975,-0.975) E6(-0.975,-0.325) E7(-0.975,0.325) E8(-0.975,0.975) E9(-0.975,1.625) E10(-0.975,2.275) E11(-0.975,2.925) E12(-0.975,3.575) F1(-0.325,-3.575) F2(-0.325,-2.925) F3(-0.325,-2.275) F4(-0.325,-1.625) F5(-0.325,-0.975) F6(-0.325,-0.325) F7(-0.325,0.325) F8(-0.325,0.975) F9(-0.325,1.625) F10(-0.325,2.275) F11(-0.325,2.925) F12(-0.325,3.575) G1(0.325,-3.575) G2(0.325,-2.925) G3(0.325,-2.275) G4(0.325,-1.625) G5(0.325,-0.975) G6(0.325,-0.325) G7(0.325,0.325) G8(0.325,0.975) G9(0.325,1.625) G10(0.325,2.275) G11(0.325,2.925) G12(0.325,3.575) H1(0.975,-3.575) H2(0.975,-2.925) H3(0.975,-2.275) H4(0.975,-1.625) H5(0.975,-0.975) H6(0.975,-0.325) H7(0.975,0.325) H8(0.975,0.975) H9(0.975,1.625) H10(0.975,2.275) H11(0.975,2.925) H12(0.975,3.575) J1(1.625,-3.575) J2(1.625,-2.925) J3(1.625,-2.275) J4(1.625,-1.625) J5(1.625,-0.975) J6(1.625,-0.325) J7(1.625,0.325) J8(1.625,0.975) J9(1.625,1.625) J10(1.625,2.275) J11(1.625,2.925) J12(1.625,3.575) K1(2.275,-3.575) K2(2.275,-2.925) K3(2.275,-2.275) K4(2.275,-1.625) K5(2.275,-0.975) K6(2.275,-0.325) K7(2.275,0.325) K8(2.275,0.975) K9(2.275,1.625) K10(2.275,2.275) K11(2.275,2.925) K12(2.275,3.575) L1(2.925,-3.575) L2(2.925,-2.925) L3(2.925,-2.275) L4(2.925,-1.625) L5(2.925,-0.975) L6(2.925,-0.325) L7(2.925,0.325) L8(2.925,0.975) L9(2.925,1.625) L10(2.925,2.275) L11(2.925,2.925) L12(2.925,3.575) M1(3.575,-3.575) M2(3.575,-2.925) M3(3.575,-2.275) M4(3.575,-1.625) M5(3.575,-0.975) M6(3.575,-0.325) M7(3.575,0.325) M8(3.575,0.975) M9(3.575,1.625) M10(3.575,2.275) M11(3.575,2.925) M12(3.575,3.575)
BGA170-HYNIX-H5GC8H24AJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA603-NVIDIA-N18S-G5-A1
  round 0.38 smd: A2(-10.7,-9.9) A3(-10.7,-9.1) A4(-10.7,-8.3) A6(-10.7,-6.6) A7(-10.7,-5.8) A9(-10.7,-4.12) A10(-10.7,-3.32) A12(-10.7,-1.64) A13(-10.7,-0.84) A14(-10.7,0) A15(-10.7,0.84) A16(-10.7,1.64) A17(-10.7,2.48) A18(-10.7,3.32) A19(-10.7,4.12) A20(-10.7,4.96) A21(-10.7,5.8) A22(-10.7,6.6) A23(-10.7,7.45) A24(-10.7,8.3) A25(-10.7,9.1) A26(-10.7,9.9) AA1(5.8,-10.7) AA2(5.8,-9.9) AA3(5.8,-9.1) AA4(5.8,-8.3) AA5(5.8,-7.5) AA6(5.8,-6.66) AA7(5.8,-5.8) AA8(5.8,-4.96) AA9(5.86,-4.12) AA10(5.86,-3.32) AA12(5.86,-1.64) AA13(5.86,-0.84) AA14(5.86,0) AA15(5.86,0.84) AA16(5.86,1.64) AA18(5.86,3.32) AA19(5.86,4.12) AA20(5.8,4.96) AA21(5.8,5.8) AA22(5.8,6.66) AA23(5.8,7.5) AA24(5.8,8.3) AA25(5.8,9.1) AA26(5.8,9.9) AA27(5.8,10.7) AB1(6.6,-10.7) AB2(6.6,-9.9) AB3(6.6,-9.1) AB4(6.6,-8.3) AB5(6.6,-7.5) AB6(6.6,-6.6) AB7(6.66,-5.8) AB8(6.66,-4.96) AB9(6.66,-4.12) AB10(6.66,-3.32) AB11(6.66,-2.48) AB12(6.66,-1.64) AB13(6.66,-0.84) AB14(6.66,0) AB15(6.66,0.84) AB16(6.66,1.64) AB17(6.66,2.48) AB18(6.66,3.32) AB19(6.66,4.12) AB20(6.66,4.96) AB21(6.66,5.8) AB22(6.6,6.6) AB23(6.6,7.5) AB24(6.6,8.3) AB25(6.6,9.1) AB26(6.6,9.9) AB27(6.6,10.7) AC2(7.45,-9.9) AC3(7.45,-9.1) AC4(7.45,-8.3) AC5(7.45,-7.45) AC6(7.5,-6.6) AC7(7.5,-5.8) AC8(7.5,-4.96) AC9(7.5,-4.12) AC10(7.5,-3.32) AC11(7.5,-2.48) AC12(7.5,-1.64) AC13(7.5,-0.84) AC14(7.5,0) AC15(7.5,0.84) AC16(7.5,1.64) AC17(7.5,2.48) AC18(7.5,3.32) AC19(7.5,4.12) AC20(7.5,4.96) AC21(7.5,5.8) AC22(7.5,6.6) AC23(7.45,7.45) AC24(7.45,8.3) AC25(7.45,9.1) AC26(7.45,9.9) AC27(7.45,10.7) AD1(8.3,-10.7) AD2(8.3,-9.9) AD3(8.3,-9.1) AD4(8.3,-8.3) AD5(8.3,-7.45) AD6(8.3,-6.6) AD7(8.3,-5.8) AD8(8.3,-4.96) AD9(8.3,-4.12) AD10(8.3,-3.32) AD11(8.3,-2.48) AD12(8.3,-1.64) AD13(8.3,-0.84) AD14(8.3,0) AD15(8.3,0.84) AD16(8.3,1.64) AD17(8.3,2.48) AD18(8.3,3.32) AD19(8.3,4.12) AD20(8.3,4.96) AD21(8.3,5.8) AD22(8.3,6.6) AD23(8.3,7.45) AD24(8.3,8.3) AD25(8.3,9.1) AD26(8.3,9.9) AD27(8.3,10.7) AE1(9.1,-10.7) AE2(9.1,-9.9) AE3(9.1,-9.1) AE4(9.1,-8.3) AE5(9.1,-7.45) AE6(9.1,-6.6) AE7(9.1,-5.8) AE8(9.1,-4.96) AE9(9.1,-4.12) AE10(9.1,-3.32) AE11(9.1,-2.48) AE12(9.1,-1.64) AE13(9.1,-0.84) AE14(9.1,0) AE15(9.1,0.84) AE16(9.1,1.64) AE17(9.1,2.48) AE18(9.1,3.32) AE19(9.1,4.12) AE20(9.1,4.96) AE21(9.1,5.8) AE22(9.1,6.6) AE23(9.1,7.45) AE24(9.1,8.3) AE25(9.1,9.1) AE26(9.1,9.9) AE27(9.1,10.7) AF1(9.9,-10.7) AF2(9.9,-9.9) AF3(9.9,-9.1) AF4(9.9,-8.3) AF5(9.9,-7.45) AF6(9.9,-6.6) AF7(9.9,-5.8) AF8(9.9,-4.96) AF9(9.9,-4.12) AF10(9.9,-3.32) AF11(9.9,-2.48) AF12(9.9,-1.64) AF13(9.9,-0.84) AF14(9.9,0) AF15(9.9,0.84) AF16(9.9,1.64) AF17(9.9,2.48) AF18(9.9,3.32) AF19(9.9,4.12) AF20(9.9,4.96) AF21(9.9,5.8) AF22(9.9,6.6) AF23(9.9,7.45) AF24(9.9,8.3) AF25(9.9,9.1) AF26(9.9,9.9) AF27(9.9,10.7) AG2(10.7,-9.9) AG3(10.7,-9.1) AG4(10.7,-8.3) AG6(10.7,-6.6) AG7(10.7,-5.8) AG9(10.7,-4.12) AG10(10.7,-3.32) AG12(10.7,-1.64) AG13(10.7,-0.84) AG15(10.7,0.84) AG16(10.7,1.64) AG18(10.7,3.32) AG19(10.7,4.12) AG21(10.7,5.8) AG22(10.7,6.6) AG24(10.7,8.3) AG25(10.7,9.1) AG26(10.7,9.9) B1(-9.9,-10.7) B2(-9.9,-9.9) B3(-9.9,-9.1) B4(-9.9,-8.3) B5(-9.9,-7.45) B6(-9.9,-6.6) B7(-9.9,-5.8) B8(-9.9,-4.96) B9(-9.9,-4.12) B10(-9.9,-3.32) B11(-9.9,-2.48) B12(-9.9,-1.64) B13(-9.9,-0.84) B14(-9.9,0) B15(-9.9,0.84) B16(-9.9,1.64) B17(-9.9,2.48) B18(-9.9,3.32) B19(-9.9,4.12) B20(-9.9,4.96) B21(-9.9,5.8) B22(-9.9,6.6) B23(-9.9,7.45) B24(-9.9,8.3) B25(-9.9,9.1) B26(-9.9,9.9) B27(-9.9,10.7) C1(-9.1,-10.7) C2(-9.1,-9.9) C3(-9.1,-9.1) C4(-9.1,-8.3) C5(-9.1,-7.45) C6(-9.1,-6.6) C7(-9.1,-5.8) C8(-9.1,-4.96) C9(-9.1,-4.12) C10(-9.1,-3.32) C11(-9.1,-2.48) C12(-9.1,-1.64) C13(-9.1,-0.84) C14(-9.1,0) C15(-9.1,0.84) C16(-9.1,1.64) C17(-9.1,2.48) C18(-9.1,3.32) C19(-9.1,4.12) C20(-9.1,4.96) C21(-9.1,5.8) C22(-9.1,6.6) C23(-9.1,7.45) C24(-9.1,8.3) C25(-9.1,9.1) C26(-9.1,9.9) C27(-9.1,10.7) D1(-8.3,-10.7) D2(-8.3,-9.9) D3(-8.3,-9.1) D4(-8.3,-8.3) D5(-8.3,-7.45) D6(-8.3,-6.6) D7(-8.3,-5.8) D8(-8.3,-4.96) D9(-8.3,-4.12) D10(-8.3,-3.32) D11(-8.3,-2.48) D12(-8.3,-1.64) D13(-8.3,-0.84) D14(-8.3,0) D15(-8.3,0.84) D16(-8.3,1.64) D17(-8.3,2.48) D18(-8.3,3.32) D19(-8.3,4.12) D20(-8.3,4.96) D21(-8.3,5.8) D22(-8.3,6.6) D23(-8.3,7.45) D24(-8.3,8.3) D25(-8.3,9.1) D26(-8.3,9.9) D27(-8.3,10.7) E2(-7.45,-9.9) E3(-7.45,-9.1) E4(-7.45,-8.3) E5(-7.45,-7.45) E6(-7.5,-6.6) E7(-7.5,-5.8) E8(-7.5,-4.96) E9(-7.5,-4.12) E10(-7.5,-3.32) E11(-7.5,-2.48) E12(-7.5,-1.64) E13(-7.5,-0.84) E14(-7.5,0) E15(-7.5,0.84) E16(-7.5,1.64) E17(-7.5,2.48) E18(-7.5,3.32) E19(-7.5,4.12) E20(-7.5,4.96) E21(-7.5,5.8) E22(-7.5,6.6) E23(-7.45,7.45) E24(-7.45,8.3) E25(-7.45,9.1) E26(-7.45,9.9) F1(-6.6,-10.7) F2(-6.6,-9.9) F3(-6.6,-9.1) F4(-6.6,-8.3) F5(-6.6,-7.5) F6(-6.6,-6.6) F7(-6.66,-5.8) F8(-6.66,-4.96) F9(-6.66,-4.12) F10(-6.66,-3.32) F11(-6.66,-2.48) F12(-6.66,-1.64) F13(-6.66,-0.84) F14(-6.66,0) F15(-6.66,0.84) F16(-6.66,1.64) F17(-6.66,2.48) F18(-6.66,3.32) F19(-6.66,4.12) F20(-6.66,4.96) F21(-6.66,5.8) F22(-6.6,6.6) F23(-6.6,7.5) F24(-6.6,8.3) F25(-6.6,9.1) F26(-6.6,9.9) F27(-6.6,10.7) G1(-5.8,-10.7) G2(-5.8,-9.9) G3(-5.8,-9.1) G4(-5.8,-8.3) G5(-5.8,-7.5) G6(-5.8,-6.66) G7(-5.8,-5.8) G8(-5.8,-4.96) G9(-5.86,-4.12) G10(-5.86,-3.32) G12(-5.86,-1.64) G13(-5.86,-0.84) G14(-5.86,0) G15(-5.86,0.84) G16(-5.86,1.64) G18(-5.86,3.32) G19(-5.86,4.12) G20(-5.8,4.96) G21(-5.8,5.8) G22(-5.8,6.66) G23(-5.8,7.5) G24(-5.8,8.3) G25(-5.8,9.1) G26(-5.8,9.9) G27(-5.8,10.7) H2(-4.96,-9.9) H3(-4.96,-9.1) H4(-4.96,-8.3) H5(-4.96,-7.5) H6(-4.96,-6.66) H22(-4.96,6.66) H23(-4.96,7.5) H24(-4.96,8.3) H25(-4.96,9.1) H26(-4.96,9.9) J1(-4.12,-10.7) J2(-4.12,-9.9) J3(-4.12,-9.1) J4(-4.12,-8.3) J5(-4.12,-7.5) J6(-4.12,-6.66) J7(-4.12,-5.86) J21(-4.12,5.86) J22(-4.12,6.66) J23(-4.12,7.5) J24(-4.12,8.3) J25(-4.12,9.1) J26(-4.12,9.9) J27(-4.12,10.7) K1(-3.32,-10.7) K2(-3.32,-9.9) K3(-3.32,-9.1) K4(-3.32,-8.3) K5(-3.32,-7.5) K6(-3.32,-6.66) K7(-3.32,-5.86) K21(-3.32,5.86) K22(-3.32,6.66) K23(-3.32,7.5) K24(-3.32,8.3) K25(-3.32,9.1) K26(-3.32,9.9) K27(-3.32,10.7) L2(-2.48,-9.9) L3(-2.48,-9.1) L4(-2.48,-8.3) L5(-2.48,-7.5) L6(-2.48,-6.66) L22(-2.48,6.66) L23(-2.48,7.5) L24(-2.48,8.3) L25(-2.48,9.1) L26(-2.48,9.9) M1(-1.64,-10.7) M2(-1.64,-9.9) M3(-1.64,-9.1) M4(-1.64,-8.3) M5(-1.64,-7.5) M6(-1.64,-6.66) M7(-1.64,-5.86) M21(-1.64,5.86) M22(-1.64,6.66) M23(-1.64,7.5) M24(-1.64,8.3) M25(-1.64,9.1) M26(-1.64,9.9) M27(-1.64,10.7) N1(-0.84,-10.7) N2(-0.84,-9.9) N3(-0.84,-9.1) N4(-0.84,-8.3) N5(-0.84,-7.5) N6(-0.84,-6.66) N7(-0.84,-5.86) N21(-0.84,5.86) N22(-0.84,6.66) N23(-0.84,7.5) N24(-0.84,8.3) N25(-0.84,9.1) N26(-0.84,9.9) N27(-0.84,10.7) P2(0,-9.9) P3(0,-9.1) P4(0,-8.3) P5(0,-7.5) P6(0,-6.66) P22(0,6.66) P23(0,7.5) P24(0,8.3) P25(0,9.1) P26(0,9.9) P27(0,10.7) R1(0.84,-10.7) R2(0.84,-9.9) R3(0.84,-9.1) R4(0.84,-8.3) R5(0.84,-7.5) R6(0.84,-6.66) R7(0.84,-5.86) R21(0.84,5.86) R22(0.84,6.66) R23(0.84,7.5) R24(0.84,8.3) R25(0.84,9.1) R26(0.84,9.9) R27(0.84,10.7) T1(1.64,-10.7) T2(1.64,-9.9) T3(1.64,-9.1) T4(1.64,-8.3) T5(1.64,-7.5) T6(1.64,-6.66) T7(1.64,-5.86) T21(1.64,5.86) T22(1.64,6.66) T23(1.64,7.5) T24(1.64,8.3) T25(1.64,9.1) T26(1.64,9.9) T27(1.64,10.7) U2(2.48,-9.9) U3(2.48,-9.1) U4(2.48,-8.3) U5(2.48,-7.5) U6(2.48,-6.66) U22(2.48,6.66) U23(2.48,7.5) U24(2.48,8.3) U25(2.48,9.1) U26(2.48,9.9) U27(2.48,10.7) V1(3.32,-10.7) V2(3.32,-9.9) V3(3.32,-9.1) V4(3.32,-8.3) V5(3.32,-7.5) V6(3.32,-6.66) V7(3.32,-5.86) V21(3.32,5.86) V22(3.32,6.66) V23(3.32,7.5) V24(3.32,8.3) V25(3.32,9.1) V26(3.32,9.9) V27(3.32,10.7) W1(4.12,-10.7) W2(4.12,-9.9) W3(4.12,-9.1) W4(4.12,-8.3) W5(4.12,-7.5) W6(4.12,-6.66) W7(4.12,-5.86) W21(4.12,5.86) W22(4.12,6.66) W23(4.12,7.5) W24(4.12,8.3) W25(4.12,9.1) W26(4.12,9.9) W27(4.12,10.7) Y2(4.96,-9.9) Y3(4.96,-9.1) Y4(4.96,-8.3) Y5(4.96,-7.5) Y6(4.96,-6.66) Y22(4.96,6.66) Y23(4.96,7.5) Y24(4.96,8.3) Y25(4.96,9.1) Y26(4.96,9.9) Y27(4.96,10.7)
  round 0.4 smd: K10(-4,-4) K11(-4,-3) K12(-4,-2) K13(-4,-1) K14(-4,0) K15(-4,1) K16(-4,2) K17(-4,3) K18(-4,4) L10(-3,-4) L11(-3,-3) L12(-3,-2) L13(-3,-1) L14(-3,0) L15(-3,1) L16(-3,2) L17(-3,3) L18(-3,4) M10(-2,-4) M11(-2,-3) M12(-2,-2) M13(-2,-1) M14(-2,0) M15(-2,1) M16(-2,2) M17(-2,3) M18(-2,4) N10(-1,-4) N11(-1,-3) N12(-1,-2) N13(-1,-1) N14(-1,0) N15(-1,1) N16(-1,2) N17(-1,3) N18(-1,4) P10(0,-4) P11(0,-3) P12(0,-2) P13(0,-1) P14(0,0) P15(0,1) P16(0,2) P17(0,3) P18(0,4) R10(1,-4) R11(1,-3) R12(1,-2) R13(1,-1) R14(1,0) R15(1,1) R16(1,2) R17(1,3) R18(1,4) T10(2,-4) T11(2,-3) T12(2,-2) T13(2,-1) T14(2,0) T15(2,1) T16(2,2) T17(2,3) T18(2,4) U10(3,-4) U11(3,-3) U12(3,-2) U13(3,-1) U14(3,0) U15(3,1) U16(3,2) U17(3,3) U18(3,4) V10(4,-4) V11(4,-3) V12(4,-2) V13(4,-1) V14(4,0) V15(4,1) V16(4,2) V17(4,3) V18(4,4)
BGA1449-INTEL-TIGERL-U
  round 0.356 smd: A3(-22.115,-10.877) A24(-22.115,-1.135) A26(-22.115,-0.485) A27(-22.115,0.165) A29(-22.115,0.815) A30(-22.115,1.465) A32(-22.115,2.115) A33(-22.115,2.765) A35(-22.115,3.415) A52(-22.115,11.405) B2(-21.565,-11.389) B24(-21.465,-1.135) B26(-21.465,-0.485) B27(-21.465,0.165) B29(-21.465,0.815) B30(-21.465,1.465) B32(-21.465,2.115) B33(-21.465,2.765) B35(-21.465,3.415) B53(-21.655,11.865) C1(-21.105,-11.865) D24(-20.815,-1.135) D26(-20.815,-0.485) D27(-20.815,0.165) D29(-20.815,0.815) D30(-20.815,1.465) D32(-20.815,2.115) D33(-20.815,2.765) D35(-20.815,3.415) DV1(21.656,-11.865) DV53(21.695,11.865) DW2(22.115,-11.381) DW52(22.115,11.365) E24(-20.165,-1.135) E26(-20.165,-0.485) E27(-20.165,0.165) E29(-20.165,0.815) E30(-20.165,1.465) E32(-20.165,2.115) E33(-20.165,2.765) E35(-20.165,3.415) G22(-19.439,-2.281) G24(-19.439,-1.366) G26(-19.439,-0.451) G28(-19.439,0.429) G30(-19.439,1.344) G32(-19.439,2.259) G34(-19.327,3.173) H22(-18.788,-2.28) H24(-18.788,-1.366) H26(-18.788,-0.451) H28(-18.788,0.429) H30(-18.788,1.344) H32(-18.788,2.259) H34(-18.677,3.173) K22(-18.138,-2.28) K24(-18.138,-1.366) K26(-18.138,-0.451) K28(-18.138,0.429) K30(-18.138,1.344) K32(-18.138,2.259) K34(-18.027,3.173) L22(-17.488,-2.28) L24(-17.488,-1.366) L26(-17.488,-0.451) L28(-17.488,0.429) L30(-17.488,1.344) L32(-17.488,2.259) L34(-17.377,3.173) N22(-16.838,-2.28) N24(-16.838,-1.366) N26(-16.838,-0.451) N28(-16.838,0.429) N30(-16.838,1.344) N32(-16.838,2.259) N34(-16.727,3.173) P22(-16.126,-2.316) P24(-16.126,-1.401) P26(-16.126,-0.451) P28(-16.126,0.429) P30(-16.126,1.344) P32(-16.126,2.259) T15(-15.493,-5.272) T17(-15.493,-4.357) T19(-15.493,-3.707) T21(-15.493,-2.791) T23(-15.493,-1.875) T25(-15.493,-0.96) T27(-15.493,-0.045) T29(-15.493,0.87) T31(-15.493,1.785) T33(-15.493,2.7) T35(-15.493,3.615) U15(-14.844,-5.272) U17(-14.844,-4.357) U19(-14.844,-3.707) U21(-14.844,-2.791) U23(-14.844,-1.875) U25(-14.844,-0.96) U27(-14.844,-0.045) U29(-14.844,0.87) U31(-14.844,1.785) U33(-14.844,2.7) U35(-14.844,3.615) V15(-14.194,-5.272) V17(-14.194,-4.357) V19(-14.194,-3.707) V21(-14.194,-2.791) V23(-14.194,-1.875) V25(-14.194,-0.96) V27(-14.194,-0.045) V29(-14.194,0.87) V31(-14.194,1.785) V33(-14.194,2.7) V35(-14.194,3.615) W16(-13.73,-4.815) W20(-13.73,-3.248) W22(-13.73,-2.333) W24(-13.73,-1.419) W26(-13.73,-0.503) W28(-13.73,0.411) W30(-13.73,1.326) W32(-13.73,2.242) W34(-13.73,3.156)
  round 0.33 smd: A4(-22.115,-10.227) A51(-22.115,10.755) B3(-21.473,-10.745) B52(-21.487,11.237) C53(-21.005,11.865) CY15(13.483,-5.499) CY17(13.483,-4.669) CY18(13.483,-3.838) CY20(13.483,-3.008) CY22(13.483,-2.179) CY24(13.483,-1.348) CY26(13.483,-0.518) CY28(13.483,0.311) CY30(13.483,1.141) CY31(13.483,1.972) CY33(13.483,2.802) CY35(13.483,3.631) D2(-20.917,-11.218) DA15(14.133,-5.499) DA17(14.133,-4.669) DA18(14.133,-3.838) DA20(14.133,-3.008) DA22(14.133,-2.179) DA24(14.133,-1.348) DA26(14.133,-0.518) DA28(14.133,0.311) DA30(14.133,1.141) DA31(14.133,1.972) DA33(14.133,2.802) DA35(14.133,3.631) DC15(14.783,-5.499) DC17(14.783,-4.669) DC18(14.783,-3.838) DC20(14.783,-3.008) DC22(14.783,-2.179) DC24(14.783,-1.348) DC26(14.783,-0.518) DC28(14.783,0.311) DC30(14.783,1.141) DC31(14.783,1.972) DC33(14.783,2.802) DC35(14.783,3.631) DD15(15.433,-5.499) DD17(15.433,-4.669) DD18(15.433,-3.838) DD20(15.433,-3.008) DD22(15.433,-2.179) DD24(15.433,-1.348) DD26(15.433,-0.518) DD28(15.433,0.311) DD30(15.433,1.141) DD31(15.433,1.972) DD33(15.433,2.802) DD35(15.433,3.631) DU1(21.005,-11.865) DU53(21.045,11.865) DV2(21.487,-11.213) DV52(21.477,11.237) DW3(22.115,-10.731) DW51(22.115,10.715) E1(-20.455,-11.865)
  round 0.305 smd: A6(-22.115,-9.577) A48(-22.115,9.455) A49(-22.115,10.105) AA39(-12.932,5.314) AA41(-12.933,6.24) AA42(-12.933,6.89) AA44(-12.933,7.54) AA45(-12.933,8.19) AA47(-12.933,8.84) AA48(-12.872,9.59) AB4(-12.692,-10.493) AB5(-12.692,-9.843) AB7(-12.692,-9.193) AB8(-12.692,-8.543) AB9(-12.692,-7.893) AB12(-12.692,-6.968) AB40(-12.475,5.776) AC10(-12.235,-7.43) AC39(-12.018,5.314) AC41(-12.018,6.24) AC42(-12.018,6.89) AC44(-12.018,7.54) AC45(-12.018,8.19) AC47(-12.018,8.84) AC49(-12.234,9.91) AC50(-12.234,10.56) AD4(-11.776,-10.493) AD5(-11.776,-9.843) AD7(-11.776,-9.193) AD8(-11.776,-8.543) AD9(-11.776,-7.893) AD12(-11.777,-6.968) AD40(-11.56,5.776) AD48(-11.599,9.59) AD51(-11.599,10.701) AE10(-11.32,-7.43) AE39(-11.103,5.314) AE41(-11.103,6.24) AE42(-11.103,6.89) AE44(-11.103,7.54) AE45(-11.103,8.19) AE47(-11.103,8.84) AF4(-10.862,-10.493) AF5(-10.862,-9.843) AF7(-10.862,-9.193) AF8(-10.862,-8.543) AF9(-10.862,-7.893) AF12(-10.863,-6.968) AF40(-10.645,5.776) AF49(-10.9,9.915) AF50(-10.9,10.565) AG10(-10.405,-7.43) AG39(-10.187,5.314) AG41(-10.188,6.24) AG42(-10.188,6.89) AG44(-10.188,7.54) AG45(-10.188,8.19) AG47(-10.188,8.84) AG48(-10.327,9.59) AG50(-10.327,10.24) AH4(-9.946,-10.493) AH5(-9.946,-9.843) AH7(-9.946,-9.193) AH8(-9.946,-8.543) AH9(-9.946,-7.893) AH12(-9.947,-6.968) AH40(-9.73,5.776) AH49(-9.685,9.915) AH50(-9.685,10.565) AJ10(-9.49,-7.43) AJ39(-9.273,5.314) AJ41(-9.273,6.24) AJ42(-9.273,6.89) AJ44(-9.273,7.54) AJ45(-9.273,8.19) AJ47(-9.273,8.84) AK4(-9.031,-10.493) AK5(-9.031,-9.843) AK7(-9.031,-9.193) AK8(-9.031,-8.543) AK9(-9.031,-7.893) AK12(-9.032,-6.968) AK40(-8.815,5.776) AK48(-9.046,9.59) AK51(-9.046,10.701) AL10(-8.575,-7.43) AL39(-8.358,5.314) AL41(-8.358,6.24) AL42(-8.358,6.89) AL44(-8.358,7.54) AL45(-8.358,8.19) AL47(-8.358,8.84) AL49(-8.347,9.915) AL50(-8.347,10.565) AM4(-8.117,-10.493) AM5(-8.117,-9.843) AM7(-8.117,-9.193) AM8(-8.117,-8.543) AM9(-8.117,-7.893) AM12(-8.118,-6.968) AM40(-7.9,5.776) AN10(-7.66,-7.43) AN39(-7.442,5.314) AN41(-7.443,6.24) AN42(-7.443,6.89) AN44(-7.443,7.54) AN45(-7.443,8.19) AN47(-7.443,8.84) AN48(-7.774,9.59) AN50(-7.774,10.24) AP4(-7.201,-10.493) AP5(-7.201,-9.843) AP7(-7.201,-9.193) AP8(-7.201,-8.543) AP9(-7.201,-7.893) AP12(-7.202,-6.968) AP40(-6.985,5.776) AP49(-7.131,9.915) AP50(-7.131,10.565) AR10(-6.745,-7.43) AR39(-6.528,5.314) AR41(-6.528,6.24) AR42(-6.528,6.89) AR44(-6.528,7.54) AR45(-6.528,8.19) AR47(-6.528,8.84) AT4(-6.287,-10.493) AT5(-6.287,-9.843) AT7(-6.287,-9.193) AT8(-6.287,-8.543) AT9(-6.287,-7.893) AT12(-6.288,-6.968) AT48(-6.492,9.59) AT51(-6.492,10.701) AU10(-5.83,-7.43) AU40(-6.07,5.776) AU49(-5.793,9.915) AU50(-5.793,10.565) AV4(-5.372,-10.493) AV5(-5.372,-9.843) AV7(-5.372,-9.193) AV8(-5.372,-8.543) AV9(-5.372,-7.893) AV12(-5.373,-6.968) AV39(-5.612,5.314) AV41(-5.613,6.24) AV42(-5.613,6.89) AV44(-5.613,7.54) AV45(-5.613,8.19) AV47(-5.613,8.84) AW10(-4.915,-7.43) AW40(-5.155,5.776) AW48(-5.155,9.59) AW51(-5.155,10.701) AY4(-4.456,-10.493) AY5(-4.456,-9.843) AY7(-4.456,-9.193) AY8(-4.456,-8.543) AY9(-4.456,-7.893) AY12(-4.457,-6.968) AY39(-4.697,5.314) AY41(-4.698,6.24) AY42(-4.698,6.89) AY44(-4.698,7.54) AY45(-4.698,8.19) AY47(-4.698,8.84) AY49(-4.455,9.915) AY50(-4.455,10.565) B5(-21.473,-10.095) B6(-21.422,-9.439) B51(-21.487,10.587) BA10(-4,-7.43) BA40(-4.24,5.776) BA48(-3.882,9.59) BA50(-3.882,10.24) BB4(-3.542,-10.493) BB5(-3.542,-9.843) BB7(-3.542,-9.193) BB8(-3.542,-8.543) BB9(-3.542,-7.893) BB12(-3.543,-6.968) BB39(-3.783,5.314) BB41(-3.783,6.24) BB42(-3.783,6.89) BB44(-3.783,7.54) BB45(-3.783,8.19) BB47(-3.783,8.84) BC10(-3.085,-7.43) BC40(-3.325,5.776) BC49(-3.239,9.915) BC50(-3.239,10.565) BD4(-2.627,-10.493) BD5(-2.627,-9.843) BD7(-2.627,-9.193) BD8(-2.627,-8.543) BD9(-2.627,-7.893) BD12(-2.627,-6.968) BD39(-2.867,5.314) BD41(-2.868,6.24) BD42(-2.868,6.89) BD44(-2.868,7.54) BD45(-2.868,8.19) BD47(-2.868,8.84) BD48(-2.601,9.59) BD51(-2.601,10.701) BE10(-2.17,-7.43) BE40(-2.41,5.776) BF4(-1.711,-10.493) BF5(-1.711,-9.843) BF7(-1.711,-9.193) BF8(-1.711,-8.543) BF9(-1.711,-7.893) BF12(-1.712,-6.968) BF39(-1.952,5.314) BF41(-1.953,6.24) BF42(-1.953,6.89) BF44(-1.953,7.54) BF45(-1.953,8.19) BF47(-1.953,8.84) BF49(-1.901,9.915) BF50(-1.901,10.565) BG10(-1.255,-7.43) BG40(-1.495,5.776) BG48(-1.328,9.59) BG50(-1.328,10.24) BH4(-0.797,-10.493) BH5(-0.797,-9.843) BH7(-0.797,-9.193) BH8(-0.797,-8.543) BH9(-0.797,-7.893) BH12(-0.798,-6.968) BH39(-1.038,5.314) BH41(-1.038,6.24) BH42(-1.038,6.89) BH44(-1.038,7.54) BH45(-1.038,8.19) BH47(-1.038,8.84) BH49(-0.685,9.915) BH50(-0.685,10.565) BJ10(-0.34,-7.43) BJ40(-0.58,5.776) BK4(0.119,-10.493) BK5(0.119,-9.843) BK7(0.119,-9.193) BK8(0.119,-8.543) BK9(0.119,-7.893) BK12(0.118,-6.968) BK39(-0.122,5.314) BK41(-0.123,6.24) BK42(-0.123,6.89) BK44(-0.123,7.54) BK45(-0.123,8.19) BK47(-0.123,8.84) BK48(-0.047,9.59) BK51(-0.047,10.701) BL10(0.575,-7.43) BL40(0.335,5.776) BL49(0.592,9.91) BL50(0.592,10.56) BM4(1.034,-10.493) BM5(1.034,-9.843) BM7(1.034,-9.193) BM8(1.034,-8.543) BM9(1.034,-7.893) BM12(1.033,-6.968) BM39(0.792,5.314) BM41(0.792,6.24) BM42(0.792,6.89) BM44(0.792,7.54) BM45(0.792,8.19) BM47(0.792,8.84) BN10(1.49,-7.43) BN40(1.25,5.776) BN48(1.23,9.59) BN50(1.23,10.24) BP4(1.681,-10.565) BP5(1.681,-9.915) BP7(1.948,-9.193) BP8(1.948,-8.543) BP9(1.948,-7.893) BP12(1.947,-6.968) BP39(1.707,5.314) BP41(1.707,6.24) BP42(1.707,6.89) BP44(1.707,7.54) BP45(1.707,8.19) BP47(1.707,8.84) BP49(1.868,9.91) BP50(1.868,10.56) BR3(2.244,-10.89) BR4(2.244,-10.24) BR10(2.405,-7.43) BR40(2.165,5.776) BT4(2.807,-10.565) BT5(2.807,-9.915) BT7(2.864,-9.193) BT8(2.864,-8.543) BT9(2.864,-7.893) BT12(2.863,-6.968) BT39(2.623,5.314) BT41(2.622,6.24) BT42(2.622,6.89) BT44(2.622,7.54) BT45(2.622,8.19) BT47(2.622,8.84) BT48(2.506,9.59) BU10(3.32,-7.43) BU40(3.08,5.776) BU49(3.144,9.91) BU50(3.144,10.56) BV3(3.481,-10.893) BV5(3.481,-9.891) BV7(3.779,-9.193) BV8(3.779,-8.543) BV9(3.779,-7.893) BV12(3.777,-6.968) BV39(3.537,5.314) BV41(3.537,6.24) BV42(3.537,6.89) BV44(3.537,7.54) BV45(3.537,8.19) BV47(3.537,8.84) BV48(3.779,9.59) BV51(3.779,10.701) BW4(4.155,-10.565) BW5(4.155,-9.915) BW10(4.235,-7.43) BW40(3.995,5.776) BY3(4.718,-10.89) BY4(4.718,-10.24) BY7(4.693,-9.193) BY8(4.693,-8.543) BY9(4.693,-7.893) BY12(4.692,-6.968) BY39(4.453,5.314) BY41(4.452,6.24) BY42(4.452,6.89) BY44(4.452,7.54) BY45(4.452,8.19) BY47(4.452,8.84) BY49(4.418,9.91) BY50(4.418,10.56) C11(-21.14,-7.358) C13(-21.143,-6.103) C16(-21.14,-4.831) C19(-21.143,-3.594) C23(-21.143,-1.734) C49(-21.297,9.962) CA10(5.15,-7.43) CA40(4.91,5.776) CA48(5.056,9.59) CA50(5.056,10.24) CB4(5.281,-10.565) CB5(5.281,-9.915) CB7(5.609,-9.193) CB8(5.609,-8.543) CB9(5.609,-7.893) CB12(5.608,-6.968) CB39(5.368,5.314) CB41(5.367,6.24) CB42(5.367,6.89) CB44(5.367,7.54) CB45(5.367,8.19) CB47(5.367,8.84) CC3(5.955,-10.893) CC5(5.955,-9.908) CC10(6.065,-7.43) CC40(5.825,5.776) CC49(5.693,9.91) CC50(5.693,10.56) CD7(6.523,-9.193) CD8(6.523,-8.543) CD9(6.523,-7.893) CD12(6.522,-6.968) CD39(6.282,5.314) CD41(6.282,6.24) CD42(6.282,6.89) CD44(6.282,7.54) CD45(6.282,8.19) CD47(6.282,8.84) CD48(6.331,9.59) CE4(6.629,-10.565) CE5(6.629,-9.915) CE40(6.74,5.776) CE49(6.97,9.91) CE50(6.97,10.56) CF3(7.192,-10.89) CF4(7.192,-10.24) CF10(6.98,-7.43) CF39(7.198,5.314) CF41(7.197,6.24) CF42(7.197,6.89) CF44(7.197,7.54) CF45(7.197,8.19) CF47(7.197,8.84) CG4(7.755,-10.565) CG5(7.755,-9.915) CG7(7.438,-9.193) CG8(7.438,-8.543) CG9(7.438,-7.893) CG12(7.437,-6.968) CG40(7.655,5.776) CG48(7.604,9.59) CG51(7.604,10.701) CH10(7.895,-7.43) CH39(8.113,5.314) CH41(8.112,6.24) CH42(8.112,6.89) CH44(8.112,7.54) CH45(8.112,8.19) CH47(8.112,8.84) CH49(8.304,9.915) CH50(8.304,10.565) CJ3(8.429,-10.893) CJ5(8.429,-9.888) CJ7(8.354,-9.193) CJ8(8.354,-8.543) CJ9(8.354,-7.893) CJ12(8.353,-6.968) CJ40(8.57,5.776) CK4(9.103,-10.565) CK5(9.103,-9.915) CK10(8.81,-7.43) CK39(9.027,5.314) CK41(9.027,6.24) CK42(9.027,6.89) CK44(9.027,7.54) CK45(9.027,8.19) CK47(9.027,8.84) CK48(8.877,9.59) CK50(8.877,10.24) CL3(9.666,-10.89) CL4(9.666,-10.24) CL7(9.268,-9.193) CL8(9.268,-8.543) CL9(9.268,-7.893) CL12(9.267,-6.968) CL40(9.485,5.776) CL49(9.52,9.915) CL50(9.52,10.565) CM10(9.725,-7.43) CM39(9.943,5.314) CM41(9.942,6.24) CM42(9.942,6.89) CM44(9.942,7.54) CM45(9.942,8.19) CM47(9.942,8.84) CN4(10.229,-10.565) CN5(10.229,-9.915) CN7(10.184,-9.193) CN8(10.184,-8.543) CN9(10.184,-7.893) CN12(10.183,-6.968) CN40(10.4,5.776) CN48(10.158,9.59) CN51(10.158,10.701) CP3(10.903,-10.893) CP5(10.903,-9.888) CP10(10.64,-7.43) CP39(10.857,5.314) CP41(10.857,6.24) CP42(10.857,6.89) CP44(10.857,7.54) CP45(10.857,8.19) CP47(10.857,8.84) CP49(10.858,9.915) CP50(10.858,10.565) CR7(11.099,-9.193) CR8(11.099,-8.543) CR9(11.099,-7.893) CR12(11.098,-6.968) CR40(11.315,5.776) CR48(11.431,9.59) CR50(11.431,10.24) CT4(11.577,-10.565) CT5(11.577,-9.915) CT10(11.555,-7.43) CT39(11.772,5.314) CT41(11.772,6.24) CT42(11.772,6.89) CT44(11.772,7.54) CT45(11.772,8.19) CT47(11.772,8.84) CU3(12.14,-10.89) CU4(12.14,-10.24) CU7(12.013,-9.193) CU8(12.013,-8.543) CU9(12.013,-7.893) CU12(12.012,-6.968) CU40(12.23,5.776) CU49(12.074,9.915) CU50(12.074,10.565) CV4(12.703,-10.565) CV5(12.703,-9.915) CV10(12.47,-7.43) CV39(12.688,5.314) CV41(12.687,6.24) CV42(12.687,6.89) CV44(12.687,7.54) CV45(12.687,8.19) CV47(12.687,8.84) CV48(12.712,9.59) CV51(12.712,10.701) CW7(12.929,-9.193) CW8(12.929,-8.543) CW9(12.929,-7.893) CW12(12.928,-6.968) CW40(13.145,5.776) CY3(13.377,-10.893) CY5(13.4,-9.963) CY39(13.602,5.314) CY41(13.602,6.24) CY42(13.602,6.89) CY44(13.602,7.54) CY45(13.602,8.19) CY47(13.602,8.84) CY49(13.473,9.915) CY50(13.473,10.565) D4(-20.83,-10.571) D5(-20.841,-9.915) D8(-20.815,-8.771) D9(-20.815,-7.931) D11(-20.49,-7.358) D12(-20.815,-6.755) D15(-20.815,-5.394) D16(-20.49,-4.831) D18(-20.815,-4.268) D20(-20.815,-3) D22(-20.767,-2.273) D36(-20.913,4.075) D38(-20.812,4.748) D39(-20.487,5.34) D40(-20.812,5.908) D42(-20.913,6.622) D43(-20.821,7.28) D45(-20.55,8.008) D46(-20.811,8.606) D49(-20.695,9.713) D50(-20.836,10.479) D52(-20.836,11.234) DA4(14.051,-10.565) DA5(14.051,-9.915) DA7(13.844,-9.193) DA8(13.844,-8.543) DA9(13.844,-7.893) DA11(13.844,-7.243) DA12(13.844,-6.593) DA50(14.046,10.24) DB3(14.614,-10.89) DB4(14.614,-10.24) DB37(14.517,4.29) DB38(14.517,4.94) DB39(14.517,5.59) DB41(14.517,6.24) DB42(14.517,6.89) DB44(14.517,7.54) DB45(14.517,8.19) DB47(14.517,8.84) DC7(14.758,-9.193) DC8(14.758,-8.543) DC9(14.758,-7.893) DC11(14.758,-7.243) DC12(14.758,-6.593) DC49(14.689,9.91) DC50(14.689,10.56) DD4(15.177,-10.565) DD5(15.177,-9.915) DD6(15.433,-9.265) DD8(15.433,-8.351) DD10(15.433,-7.436) DD13(15.433,-6.52) DD37(15.432,4.29) DD38(15.432,4.94) DD39(15.432,5.59) DD41(15.432,6.24) DD42(15.432,6.89) DD44(15.432,7.54) DD45(15.432,8.19) DD47(15.432,8.84) DD51(15.327,10.701) DE3(15.851,-10.893) DE5(15.826,-9.872) DF4(16.42,-10.562) DF6(16.083,-9.265) DF8(16.083,-8.351) DF10(16.083,-7.436) DF13(16.083,-6.52) DF15(16.083,-5.606) DF17(16.083,-4.696) DF19(16.083,-3.787) DF21(16.083,-2.879) DF23(16.083,-1.97) DF25(16.083,-1.06) DF27(16.083,-0.151) DF29(16.083,0.757) DF31(16.083,1.666) DF33(16.083,2.576) DF35(16.083,3.485) DF37(16.083,4.393) DF39(16.083,5.303) DF41(16.083,6.212) DF43(16.083,7.12) DF45(16.083,8.029) DF47(16.083,8.939) DF49(16.088,9.915) DF50(16.088,10.565) DG5(16.476,-9.908) DG6(16.733,-9.265) DG8(16.733,-8.351) DG10(16.733,-7.436) DG13(16.733,-6.52) DG15(16.733,-5.606) DG17(16.733,-4.696) DG19(16.733,-3.787) DG21(16.733,-2.879) DG23(16.733,-1.97) DG25(16.733,-1.06) DG27(16.733,-0.151) DG29(16.733,0.757) DG31(16.733,1.666) DG33(16.733,2.576) DG35(16.733,3.485) DG37(16.733,4.393) DG39(16.733,5.303) DG41(16.733,6.212) DG43(16.733,7.12) DG45(16.733,8.029) DG47(16.733,8.939) DG50(16.661,10.24) DH3(17.038,-10.886) DH4(17.038,-10.236) DH49(17.305,9.91) DH50(17.305,10.56) DJ4(17.601,-10.562) DJ5(17.601,-9.912) DJ6(17.383,-9.265) DJ8(17.383,-8.351) DJ10(17.383,-7.436) DJ13(17.383,-6.52) DJ15(17.383,-5.606) DJ17(17.383,-4.696) DJ19(17.383,-3.787) DJ21(17.383,-2.879) DJ23(17.383,-1.97) DJ25(17.383,-1.06) DJ27(17.383,-0.151) DJ29(17.383,0.757) DJ31(17.383,1.666) DJ33(17.383,2.576) DJ35(17.383,3.485) DJ37(17.383,4.393) DJ39(17.383,5.303) DJ41(17.383,6.212) DJ43(17.383,7.12) DJ45(17.383,8.029) DJ47(17.383,8.939) DK6(18.033,-9.265) DK8(18.033,-8.351) DK10(18.033,-7.436) DK13(18.033,-6.52) DK15(18.033,-5.606) DK17(18.033,-4.696) DK19(18.033,-3.787) DK21(18.033,-2.879) DK23(18.033,-1.97) DK25(18.033,-1.06) DK27(18.033,-0.151) DK29(18.033,0.757) DK31(18.033,1.666) DK33(18.033,2.576) DK35(18.033,3.485) DK37(18.033,4.393) DK39(18.033,5.303) DK41(18.033,6.212) DK43(18.033,7.12) DK45(18.033,8.029) DK47(18.033,8.939) DK51(17.942,10.701) DL3(18.274,-10.888) DL5(18.255,-9.877) DL49(18.513,9.905) DL50(18.583,10.555) DM4(18.844,-10.153) DM6(18.683,-9.265) DM8(18.683,-8.351) DM10(18.683,-7.436) DM13(18.683,-6.52) DM15(18.683,-5.606) DM17(18.683,-4.696) DM19(18.683,-3.787) DM21(18.683,-2.879) DM23(18.683,-1.97) DM25(18.683,-1.06) DM27(18.683,-0.151) DM29(18.683,0.757) DM31(18.683,1.666) DM33(18.683,2.576) DM35(18.683,3.485) DM37(18.683,4.393) DM39(18.683,5.303) DM41(18.683,6.212) DM43(18.683,7.12) DM45(18.683,8.029) DM47(18.683,8.939) DN1(19.473,-11.862) DN4(19.363,-10.562) DN5(19.457,-9.916) DN6(19.333,-9.265) DN8(19.333,-8.351) DN10(19.333,-7.436) DN13(19.333,-6.52) DN15(19.333,-5.606) DN17(19.333,-4.696) DN19(19.333,-3.787) DN21(19.333,-2.879) DN23(19.333,-1.97) DN25(19.333,-1.06) DN27(19.333,-0.151) DN29(19.333,0.757) DN31(19.333,1.666) DN33(19.333,2.576) DN35(19.333,3.485) DN37(19.333,4.393) DN39(19.333,5.303) DN41(19.333,6.212) DN43(19.333,7.12) DN45(19.333,8.029) DN47(19.333,8.939) DN49(19.244,9.77) DN51(19.157,10.875) DN53(19.152,11.536) DP4(20.019,-10.496) DP50(19.705,10.515) DP52(19.745,11.165) DP53(19.745,11.815) DR1(20.355,-11.865) DR2(20.124,-11.257) DR5(20.101,-9.826) DR7(20.12,-9.173) DR9(20.165,-8.017) DR11(20.149,-7.36) DR12(20.165,-6.703) DR15(20.165,-5.397) DR16(20.149,-4.74) DR18(20.165,-4.083) DR21(20.165,-2.777) DR22(20.149,-2.12) DR24(20.165,-1.463) DR27(20.165,-0.157) DR28(20.149,0.5) DR30(20.165,1.157) DR32(20.165,2.463) DR34(20.149,3.12) DR35(20.165,3.777) DR38(20.165,5.083) DR40(20.149,5.74) DR41(20.165,6.397) DR44(20.165,7.703) DR46(20.149,8.36) DR47(20.154,9.026) DR49(20.222,9.678) DR51(20.295,10.814) DR53(20.395,11.865) DT2(20.837,-11.213) DT4(20.837,-10.563) DT6(20.737,-9.435) DT8(20.49,-8.59) DT14(20.49,-6.05) DT19(20.49,-3.43) DT25(20.49,-0.81) DT31(20.49,1.81) DT37(20.49,4.43) DT43(20.49,7.05) DT47(20.804,9.026) DT49(20.875,9.676) DT50(20.832,10.438) DT52(20.822,11.226) DU5(21.225,-9.942) DU11(21.14,-7.36) DU16(21.14,-4.74) DU22(21.14,-2.12) DU28(21.14,0.5) DU34(21.14,3.12) DU40(21.14,5.74) DU46(21.14,8.36) DV4(21.487,-10.563) DV6(21.455,-9.315) DV47(21.454,9.026) DV49(21.473,9.936) DV51(21.474,10.586) DW5(22.115,-10.081) DW6(22.115,-9.431) DW47(22.115,9.031) DW49(22.115,10.065) E2(-20.256,-11.221) E3(-20.125,-10.58) E6(-20.119,-9.605) E7(-20.176,-8.952) E9(-20.165,-7.931) E12(-20.165,-6.755) E13(-20.15,-6.103) E15(-20.165,-5.394) E18(-20.165,-4.268) E19(-20.15,-3.594) E22(-20.109,-2.325) E38(-20.162,4.748) E41(-20.202,6.134) E44(-20.18,7.425) E47(-20.175,8.792) E48(-20.067,9.548) E51(-20.187,10.578) E52(-20.186,11.23) E53(-20.355,11.865) F1(-19.798,-11.865) F49(-19.73,10.109) F53(-19.7,11.865) G14(-19.439,-5.945) G16(-19.439,-5.029) G18(-19.439,-4.114) G20(-19.439,-3.198) G36(-19.327,4.056) G38(-19.327,4.939) G39(-19.338,5.59) G41(-19.338,6.24) G42(-19.338,6.89) G44(-19.338,7.54) G45(-19.338,8.19) G47(-19.338,8.84) G48(-19.251,9.59) G51(-19.251,10.701) H4(-19.106,-10.493) H5(-19.096,-9.843) H7(-19.096,-9.193) H8(-19.096,-8.543) H9(-19.096,-7.893) H11(-19.096,-7.243) H12(-19.096,-6.593) H14(-18.788,-5.941) H16(-18.788,-5.025) H18(-18.788,-4.109) H20(-18.788,-3.194) H36(-18.677,4.056) H38(-18.677,4.939) J39(-18.423,5.59) J41(-18.423,6.24) J42(-18.423,6.89) J44(-18.423,7.54) J45(-18.423,8.19) J47(-18.423,8.84) J49(-18.612,9.91) J50(-18.612,10.56) K4(-18.191,-10.493) K5(-18.182,-9.843) K7(-18.182,-9.193) K8(-18.182,-8.543) K9(-18.182,-7.893) K11(-18.182,-7.243) K12(-18.182,-6.593) K14(-18.138,-5.941) K16(-18.138,-5.025) K18(-18.138,-4.109) K20(-18.138,-3.194) K36(-18.027,4.056) K38(-18.027,4.939) K48(-17.945,9.59) K50(-17.915,10.24) L14(-17.488,-5.941) L16(-17.488,-5.025) L18(-17.488,-4.109) L20(-17.488,-3.194) L36(-17.377,4.056) L38(-17.377,4.939) L39(-17.508,5.59) L41(-17.508,6.24) L42(-17.508,6.89) L44(-17.508,7.54) L45(-17.508,8.19) L47(-17.508,8.84) L49(-17.336,9.91) M4(-17.266,-10.493) M5(-17.266,-9.843) M7(-17.266,-9.193) M8(-17.266,-8.543) M9(-17.266,-7.893) M11(-17.266,-7.243) M12(-17.266,-6.593) M50(-17.321,10.56) N14(-16.838,-5.941) N16(-16.838,-5.025) N18(-16.838,-4.109) N20(-16.838,-3.194) N36(-16.727,4.056) N38(-16.727,4.939) N39(-16.593,5.59) N41(-16.593,6.24) N42(-16.593,6.89) N44(-16.593,7.54) N45(-16.593,8.19) N47(-16.593,8.84) N48(-16.67,9.59) P4(-16.352,-10.493) P5(-16.352,-9.843) P7(-16.352,-9.193) P8(-16.352,-8.543) P9(-16.352,-7.893) P11(-16.352,-7.243) P12(-16.352,-6.593) P14(-16.126,-5.941) P16(-16.126,-5.061) P18(-16.126,-4.146) P20(-16.126,-3.231) P33(-16.126,2.911) P35(-16.144,3.615) P49(-16.06,9.91) P50(-16.06,10.56) R37(-15.678,4.29) R38(-15.678,4.94) R39(-15.678,5.59) R41(-15.678,6.24) R42(-15.678,6.89) R44(-15.678,7.54) R45(-15.678,8.19) R47(-15.678,8.84) T4(-15.437,-10.493) T5(-15.437,-9.843) T7(-15.437,-9.193) T8(-15.437,-8.543) T9(-15.437,-7.893) T11(-15.437,-7.243) T12(-15.437,-6.593) T48(-15.425,9.59) T51(-15.425,10.701) U37(-14.763,4.29) U38(-14.763,4.94) U39(-14.763,5.59) U41(-14.763,6.24) U42(-14.763,6.89) U44(-14.763,7.54) U45(-14.763,8.19) U47(-14.763,8.84) U49(-14.786,9.91) U50(-14.786,10.56) V4(-14.521,-10.493) V5(-14.521,-9.843) V7(-14.521,-9.193) V8(-14.521,-8.543) V9(-14.521,-7.893) V11(-14.521,-7.243) V12(-14.521,-6.593) W37(-13.848,4.29) W38(-13.848,4.94) W39(-13.848,5.59) W41(-13.848,6.24) W42(-13.848,6.89) W44(-13.848,7.54) W45(-13.848,8.19) W47(-13.848,8.84) W48(-14.148,9.59) W50(-14.148,10.24) Y4(-13.607,-10.493) Y5(-13.607,-9.843) Y7(-13.607,-9.193) Y8(-13.607,-8.543) Y9(-13.607,-7.893) Y11(-13.607,-7.243) Y12(-13.607,-6.593) Y49(-13.51,9.91) Y50(-13.51,10.56)
  oval 0.356x0.254 smd: A7(-22.115,-8.796) A9(-22.115,-7.931) A12(-22.115,-6.735) A15(-22.115,-5.394) A40(-22.115,5.979) A43(-22.115,7.413) A45(-21.85,8.008) A46(-22.115,8.701) B8(-21.465,-8.771) B9(-21.465,-7.931) B12(-21.465,-6.735) B13(-21.793,-6.103) B15(-21.465,-5.394) B40(-21.462,5.979) B42(-21.563,6.622) B43(-21.467,7.36) B46(-21.461,8.681) B48(-21.474,9.333) C45(-21.2,8.008) DT9(20.815,-8.017) DT12(20.815,-6.703) DT15(20.815,-5.397) DT18(20.815,-4.083) DT21(20.815,-2.777) DT24(20.815,-1.463) DT27(20.815,-0.157) DT30(20.815,1.157) DT32(20.815,2.463) DT35(20.815,3.777) DT38(20.815,5.083) DT41(20.815,6.397) DT44(20.815,7.703) DU8(21.14,-8.67) DU14(21.14,-6.05) DU43(21.14,7.05) DV8(21.8,-8.761) DV9(21.465,-8.017) DV11(21.79,-7.36) DV12(21.465,-6.703) DV14(21.79,-6.05) DV15(21.465,-5.397) DV38(21.465,5.083) DV40(21.79,5.74) DV41(21.465,6.397) DV43(21.79,7.05) DV44(21.465,7.703) DV46(21.79,8.36) DW9(22.115,-8.017) DW12(22.115,-6.703) DW15(22.115,-5.397) DW38(22.115,5.083) DW41(22.115,6.397) DW44(22.115,7.703)
  oval 0.305x0.203 smd: A18(-22.115,-4.268) A20(-22.115,-3) A38(-22.112,4.748) B18(-21.465,-4.268) B19(-21.793,-3.594) B20(-21.465,-3) B22(-21.47,-2.298) B23(-21.793,-1.734) B36(-21.563,4.06) B38(-21.462,4.748) B39(-21.787,5.32) C39(-21.137,5.34) DU19(21.14,-3.43) DU25(21.14,-0.81) DU31(21.14,1.81) DU37(21.14,4.43) DV16(21.79,-4.74) DV18(21.465,-4.083) DV19(21.79,-3.43) DV21(21.465,-2.777) DV22(21.79,-2.12) DV24(21.465,-1.463) DV25(21.79,-0.81) DV27(21.465,-0.157) DV28(21.79,0.5) DV30(21.465,1.157) DV31(21.79,1.81) DV32(21.465,2.463) DV34(21.79,3.12) DV35(21.465,3.777) DV37(21.79,4.43) DW18(22.115,-4.083) DW21(22.115,-2.777) DW24(22.115,-1.463) DW27(22.115,-0.157) DW30(22.115,1.157) DW32(22.115,2.463) DW35(22.115,3.777)
  oval 0.203x0.305 smd: AA51(-12.872,10.89) AA53(-12.872,11.54) AB1(-12.812,-11.865) AB2(-12.812,-11.215) AC1(-12.162,-11.865) AC2(-12.162,-11.215) AC52(-12.234,11.21) AC53(-12.234,11.86) AD1(-11.512,-11.865) AD2(-11.512,-11.215) AD52(-11.599,11.351) AF1(-10.862,-11.865) AF2(-10.862,-11.215) AF52(-10.9,11.215) AF53(-10.9,11.865) AG1(-10.212,-11.865) AG2(-10.212,-11.215) AG51(-10.327,10.89) AG53(-10.327,11.54) AH52(-9.685,11.215) AH53(-9.685,11.865) AJ1(-9.562,-11.865) AJ2(-9.562,-11.215) AK1(-8.912,-11.865) AK2(-8.912,-11.215) AK52(-9.046,11.351) AL52(-8.347,11.215) AL53(-8.347,11.865) AM1(-8.262,-11.865) AM2(-8.262,-11.215) AN1(-7.612,-11.865) AN2(-7.612,-11.215) AN51(-7.774,10.89) AN53(-7.774,11.54) AP52(-7.131,11.215) AP53(-7.131,11.865) AR1(-6.961,-11.865) AR2(-6.961,-11.215) AT1(-6.311,-11.865) AT2(-6.311,-11.215) AT52(-6.492,11.351) AU1(-5.661,-11.865) AU2(-5.661,-11.215) AU52(-5.793,11.215) AU53(-5.793,11.865) AW1(-5.011,-11.865) AW2(-5.011,-11.215) AW52(-5.155,11.351) AY1(-4.361,-11.865) AY2(-4.361,-11.215) AY52(-4.455,11.215) AY53(-4.455,11.865) BA51(-3.882,10.89) BA53(-3.882,11.54) BB1(-3.711,-11.865) BB2(-3.711,-11.215) BC1(-3.061,-11.865) BC2(-3.061,-11.215) BC52(-3.239,11.215) BC53(-3.239,11.865) BD52(-2.601,11.351) BE1(-2.411,-11.865) BE2(-2.411,-11.215) BF1(-1.761,-11.865) BF2(-1.761,-11.215) BF52(-1.901,11.215) BF53(-1.901,11.865) BG51(-1.328,10.89) BG53(-1.328,11.54) BH1(-1.112,-11.865) BH2(-1.112,-11.215) BH52(-0.685,11.215) BH53(-0.685,11.865) BJ1(-0.462,-11.865) BJ2(-0.462,-11.215) BK1(0.188,-11.865) BK2(0.188,-11.215) BK52(-0.047,11.351) BL52(0.592,11.21) BL53(0.592,11.86) BM1(0.761,-11.543) BN51(1.23,10.89) BN53(1.23,11.54) BP1(1.681,-11.865) BP2(1.681,-11.215) BP52(1.868,11.21) BP53(1.868,11.86) BT1(2.807,-11.865) BT2(2.807,-11.215) BT51(2.506,10.89) BT53(2.506,11.54) BU52(3.144,11.21) BU53(3.144,11.86) BV1(3.481,-11.543) BV52(3.779,11.351) BW1(4.155,-11.865) BW2(4.155,-11.215) BY52(4.418,11.21) BY53(4.418,11.86) CA51(5.056,10.89) CA53(5.056,11.54) CB1(5.281,-11.865) CB2(5.281,-11.215) CC1(5.955,-11.543) CC52(5.693,11.21) CC53(5.693,11.86) CD51(6.331,10.89) CD53(6.331,11.54) CE1(6.629,-11.865) CE2(6.629,-11.215) CE52(6.97,11.21) CE53(6.97,11.86) CG1(7.755,-11.865) CG2(7.755,-11.215) CG52(7.604,11.351) CH52(8.304,11.215) CH53(8.304,11.865) CJ1(8.429,-11.543) CK1(9.103,-11.865) CK2(9.103,-11.215) CK51(8.877,10.89) CK53(8.877,11.54) CL52(9.52,11.215) CL53(9.52,11.865) CN1(10.229,-11.865) CN2(10.229,-11.215) CN52(10.158,11.351) CP1(10.903,-11.543) CP52(10.858,11.215) CP53(10.858,11.865) CR51(11.431,10.89) CR53(11.431,11.54) CT1(11.577,-11.865) CT2(11.577,-11.215) CU52(12.074,11.215) CU53(12.074,11.865) CV1(12.703,-11.865) CV2(12.703,-11.215) CV52(12.712,11.351) CY1(13.377,-11.543) CY52(13.473,11.215) CY53(13.473,11.865) DA1(14.051,-11.865) DA2(14.051,-11.215) DA51(14.046,10.89) DA53(14.126,11.54) DC52(14.689,11.21) DC53(14.779,11.865) DD52(15.327,11.351) DF52(16.088,11.215) DG51(16.661,10.89) N1(-16.548,-11.864) N2(-16.548,-11.214) R1(-15.898,-11.864) R2(-15.898,-11.214) T1(-15.248,-11.864) T2(-15.248,-11.214) V1(-14.597,-11.864) V2(-14.597,-11.214) W1(-14.028,-11.545) W51(-14.148,10.89) W53(-14.148,11.54) Y1(-13.461,-11.865) Y2(-13.461,-11.215) Y52(-13.51,11.21) Y53(-13.51,11.86)
  oval 0.254x0.356 smd: DD1(15.177,-11.865) DD2(15.177,-11.215) DE1(15.851,-11.543) DF1(16.42,-11.862) DF2(16.42,-11.212) DF53(16.088,11.865) DG53(16.741,11.54) DH52(17.305,11.21) DJ1(17.601,-11.862) DJ2(17.601,-11.212) DJ53(17.394,11.865) DK52(17.942,11.351) DL1(18.247,-11.543) DL52(18.583,11.205) DL53(18.583,11.855) DM1(18.903,-11.534) DN2(19.473,-11.212) G1(-19.148,-11.864) G2(-19.148,-11.214) G52(-19.249,11.363) J1(-18.498,-11.864) J2(-18.498,-11.214) J52(-18.607,11.21) J53(-18.607,11.86) K1(-17.848,-11.864) K2(-17.848,-11.214) K51(-17.915,10.89) K53(-17.915,11.54) M1(-17.198,-11.864) M2(-17.198,-11.214) M52(-17.321,11.21) M53(-17.321,11.86) N51(-16.628,10.89) N53(-16.628,11.54) P52(-16.06,11.21) P53(-16.06,11.86) T52(-15.425,11.351) U52(-14.786,11.21) U53(-14.786,11.86)

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_SSTX1_P_C: length 25.3
  TOP w0.109: C6310.2 207.68,112.37 arc(207.59,112.31) 207.48,112.29 207.4,112.29 arc(207.27,112.32) 207.16,112.39 207,112.56 D5904.1 206.8,112.37 arc(206.69,112.29) 206.56,112.24 206.55,112.23 arc(206.5,112.22) 206.45,112.22 206.44,112.22 arc(206.2,112.16) 205.99,112.02 205.86,111.89 arc(205.49,111.34) 205.36,110.68 205.36,110.43 arc(205.35,110.38) 205.32,110.33 arc(205.31,110.33) 205.31,110.33 205.21,110.23 arc(205.02,109.94) 204.96,109.61 204.96,108.88 arc(204.95,108.79) 204.92,108.71 arc(204.89,108.66) 204.86,108.61 201.45,105.21 arc(201.41,105.17) 201.37,105.14 arc(197.67,102.99) 193.47,102.2 arc(193.19,102.18) 192.92,102.1 arc(192.69,102.01) 192.46,101.89 arc(192.39,101.84) 192.33,101.79 191.38,100.84 arc(191.22,100.59) 191.16,100.3 191.16,100.15 arc(191.17,100.02) 191.21,99.89 191.47,99.27 arc(191.48,99.22) 191.49,99.16 191.49,98.56 arc(191.47,98.48) 191.43,98.41 191.36,98.34 v2(191.33,98.34)
  BOTTOM w0.109: v2(191.33,98.34) 191.37,98.38 arc(191.41,98.43) 191.44,98.47 arc(191.55,98.67) R5949.2
TBTA_SSTX2_N: length 4.2
  BOTTOM w0.079: 188.54,95.33 188.52,95.33 188.51,95.34 arc(188.49,95.36) 188.46,95.36 188.29,95.36 arc(188.18,95.34) 188.09,95.28 188.07,95.27 arc(187.98,95.2) 187.87,95.18 187.7,95.18 arc(187.57,95.2) 187.46,95.27 arc(187.45,95.28) 187.45,95.28 U5900.E11
  BOTTOM w0.109: R5908.1 190.88,94.69 arc(190.67,94.73) 190.49,94.85 190.3,95.04 arc(190.13,95.16) 189.92,95.2 189.6,95.2 arc(189.48,95.23) 189.37,95.3 arc(189.34,95.32) 189.3,95.33 188.54,95.33
TBTA_SSTX2_N_C: length 21.3
  TOP w0.109: v2(191.26,95.25) 191.37,95.37 arc(191.44,95.48) 191.47,95.6 191.47,95.64 arc(191.5,95.79) 191.58,95.91 191.86,96.19 arc(192.04,96.31) 192.25,96.35 193.04,96.35 arc(193.1,96.36) 193.15,96.37 193.4,96.48 arc(193.45,96.51) 193.49,96.54 194.75,97.79 arc(194.82,97.9) 194.84,98.02 194.84,98.43 arc(194.98,99.11) 195.37,99.7 196.28,100.61 arc(196.71,100.91) 197.21,101.06 arc(197.63,101.15) 198.01,101.35 arc(198.32,101.55) 198.63,101.73 arc(199.6,102.25) 200.59,102.7 201.2,102.95 arc(201.86,103.25) 202.5,103.61 203.42,104.19 arc(203.5,104.24) 203.57,104.31 204.99,105.73 arc(205.28,105.92) 205.61,105.99 205.67,105.99 arc(205.79,106.01) 205.89,106.08 D5901.1 206.16,106.16 arc(206.25,106.1) 206.36,106.08 206.75,106.08 arc(206.84,106.1) 206.91,106.15 C6315.2
  BOTTOM w0.109: R5959.2 191.61,94.81 arc(191.59,94.9) 191.54,94.97 v2(191.26,95.25)
TBTA_SSTX2_P: length 4.2
  BOTTOM w0.079: U5900.E12 187.69,95.4 arc(187.59,95.44) 187.55,95.53 arc(187.56,95.56) 187.57,95.58 187.57,95.58 arc(187.62,95.61) 187.68,95.63 187.88,95.63 arc(187.94,95.61) 187.99,95.58 188,95.57 arc(188.06,95.53) 188.12,95.52 188.46,95.52 arc(188.49,95.53) 188.51,95.54 188.52,95.55 188.54,95.55
  BOTTOM w0.109: R5907.1 190.92,95.83 arc(190.72,95.79) 190.55,95.68 190.45,95.59 arc(190.28,95.47) 190.07,95.43 189.6,95.43 arc(189.56,95.43) 189.53,95.46 arc(189.42,95.53) 189.3,95.55 188.54,95.55
TBTA_SSTX2_P_C: length 21.3
  TOP w0.109: v2(191.9,95.27) 191.76,95.4 arc(191.71,95.49) 191.69,95.58 191.69,95.64 arc(191.7,95.7) 191.73,95.75 192.02,96.03 arc(192.13,96.1) 192.25,96.13 193.04,96.13 arc(193.14,96.14) 193.24,96.17 193.49,96.27 arc(193.57,96.32) 193.65,96.38 194.91,97.64 arc(195.02,97.81) 195.06,98.02 195.06,98.43 arc(195.18,99.03) 195.53,99.54 196.44,100.46 arc(196.81,100.71) 197.23,100.83 arc(197.71,100.94) 198.14,101.16 arc(198.37,101.31) 198.61,101.46 arc(198.67,101.5) 198.74,101.54 arc(199.7,102.04) 200.68,102.49 201.29,102.74 arc(201.96,103.06) 202.61,103.42 203.54,104 arc(203.64,104.07) 203.73,104.15 205.15,105.57 arc(205.36,105.71) 205.61,105.76 205.67,105.76 arc(205.72,105.75) 205.77,105.72 D5900.1 206.47,105.82 arc(206.51,105.85) 206.56,105.86 206.89,105.86 arc(206.93,105.85) 206.97,105.83 206.98,105.81 arc(207,105.78) 207.01,105.73 C6314.2
  BOTTOM w0.109: v2(191.9,95.27) 191.79,95.38 arc(191.66,95.59) R5957.2
TCP0_AUX_DN: length 102.2
  IN1 w0.079: v2(196.79,96.37) 197.01,96.59 197.15,96.59 197.55,96.99 197.55,97.77 197.75,97.97 197.75,99.5 195.05,102.2 190.08,102.2 187.64,99.75 187.64,94.5 186.92,93.77 182.95,93.77 181.84,92.66 180.64,92.66 179.03,91.05 175.76,91.05 175.07,90.36 169.23,90.36 167.58,92.01 156.66,92.01 154.95,93.72 150.21,93.72 148.11,92.85 146.68,91.42 145.75,91.42 145.42,91.75 138.4,91.75 137.03,92.32 132.62,92.32 132.13,92.81 130.78,92.81 130.29,92.32 125.8,92.32 124.52,91.78 arc(123.96,91.49) 123.47,91.09 121.82,89.43 121.82,88.86 121.34,88.39 121.34,87.85 119.25,85.76 119.06,85.76 118.46,85.16 118.08,85.16 117.08,84.16 116.33,84.16 v2(116.1,84.39)
  BOTTOM w0.109: U400.AP5 116.05,84.34 v2(116.1,84.39) ; C6111.2 196.53,96.64 v2(196.79,96.37)
TCP0_AUX_DN_R: length 24.4
  IN1 w0.079: v1(198.15,98.77) 198.45,98.47 198.54,98.47 198.6,98.53 198.6,99.56 195.57,102.59 192.01,102.59 191.45,103.15 190.23,103.15 187.99,100.91 186.89,100.91 185.93,101.88 185.93,102.09 v1(185.66,102.36)
  BOTTOM w0.079: U5900.M8 185.96,99.05 185.88,99.13 185.88,100.96 185.85,100.99 185.85,101.01
  BOTTOM w0.109: v1(185.66,102.36) 185.85,102.17 185.85,101.01 ; R5912.1 196.42,97.25 196.42,97.71 196.94,98.24 197.34,98.24 197.49,98.39 197.76,98.39 v1(198.15,98.77)
TCP0_AUX_DP: length 101.8
  IN1 w0.079: v2(196.79,96.95) 196.98,96.76 197.08,96.76 197.38,97.06 197.38,97.84 197.58,98.04 197.58,99.43 194.99,102.03 190.15,102.03 187.81,99.68 187.81,94.43 186.99,93.61 183.02,93.61 181.91,92.49 180.71,92.49 179.1,90.88 175.83,90.88 175.14,90.19 169.16,90.19 167.51,91.84 156.59,91.84 154.88,93.56 150.24,93.56 148.2,92.71 146.75,91.25 145.68,91.25 145.35,91.59 138.36,91.59 137,92.15 132.55,92.15 132.06,92.64 130.85,92.64 130.36,92.15 125.83,92.15 124.58,91.63 arc(124.05,91.35) 123.59,90.97 121.98,89.36 121.98,88.79 121.51,88.32 121.51,87.78 119.32,85.59 119.13,85.59 118.53,84.99 118.15,84.99 117.15,84 116.36,84 v2(116.1,83.74)
  BOTTOM w0.109: C6110.2 197.1,96.64 v2(196.79,96.95) ; U400.AP7 116.05,83.69 v2(116.1,83.74)
TCP0_AUX_DP_R: length 24.7
  IN1 w0.079: v1(186.36,102.36) 186.09,102.09 186.09,101.95 186.96,101.08 187.92,101.08 190.16,103.31 191.52,103.31 192.08,102.76 195.64,102.76 198.77,99.63 198.77,98.46 198.61,98.31 198.45,98.31 v1(198.15,98.01)
  BOTTOM w0.079: 186.07,101.01 186.07,100.99 186.04,100.96 186.04,99.19 186.18,99.05 186.18,98.38 U5900.L8
  BOTTOM w0.109: v1(198.15,98.01) 197.99,98.16 197.58,98.16 197.43,98.02 197.13,98.02 197.08,97.97 197.08,97.84 197.23,97.69 197.23,97.25 R5911.1 ; v1(186.36,102.36) 186.07,102.07 186.07,101.01
TCP0_DIRECT_TX0_R_DN: length 29.5
  TOP w0.109: R5950.1 arc(176.12,99.7) 175.91,99.61 arc(175.77,99.53) 175.65,99.44 175.51,99.33 arc(175.47,99.3) 175.42,99.28 arc(175.36,99.26) 175.3,99.25 arc(175.12,99.16) 174.99,99 174.99,99 arc(174.92,98.69) 174.97,98.38 174.97,98.38 arc(175.02,98.29) 175.08,98.21 175.26,98.05 arc(175.33,97.99) 175.41,97.94 arc(175.51,97.9) 175.61,97.87 arc(175.7,97.85) 175.78,97.84 177.91,97.84 arc(178.04,97.82) 178.14,97.75 178.45,97.44 arc(178.68,97.29) 178.95,97.23 179.9,97.23 arc(179.97,97.24) 180.05,97.25 arc(180.21,97.29) 180.36,97.35 arc(180.44,97.39) 180.5,97.45 180.64,97.58 arc(180.77,97.76) 180.82,97.97 180.82,99.01 arc(180.87,99.27) 181.01,99.49 181.64,100.11 arc(181.98,100.34) 182.37,100.42 185.65,100.42 arc(185.78,100.39) 185.88,100.32 186.14,100.06 arc(186.44,99.86) 186.79,99.79 188.46,99.79 arc(188.51,99.78) 188.56,99.75 189.34,98.97 arc(189.36,98.94) 189.38,98.91 arc(189.38,98.89) 189.39,98.86 189.39,98.86 189.39,98.17 arc(189.47,97.75) 189.71,97.4 189.95,97.16 arc(190.3,96.93) 190.71,96.84 192.5,96.84 arc(192.86,96.92) 193.17,97.12 193.6,97.55 arc(193.75,97.77) 193.8,98.04 193.8,98.24 arc(193.81,98.3) 193.84,98.34 arc(193.92,98.41) 194.03,98.43 194.07,98.43 arc(194.21,98.4) v2(194.34,98.32)
  BOTTOM w0.109: R5951.1 192.12,97.75 arc(192.43,97.81) 192.7,97.96 arc(192.73,97.99) 192.76,98.01 192.94,98.18 arc(193.04,98.25) 193.16,98.28 193.22,98.28 arc(193.35,98.29) 193.47,98.35 arc(193.58,98.4) 193.71,98.42 194.08,98.42 arc(194.22,98.39) v2(194.34,98.32)
TCP0_DIRECT_TX0_R_DP: length 29.5
  TOP w0.109: R5947.1 176.06,98.62 arc(176.01,98.62) 175.97,98.64 175.92,98.66 arc(175.79,98.72) 175.68,98.82 175.52,98.98 arc(175.44,99.02) 175.35,99.03 arc(175.26,98.99) 175.2,98.91 175.2,98.91 arc(175.15,98.68) 175.18,98.46 175.18,98.46 arc(175.21,98.41) 175.24,98.38 175.41,98.21 arc(175.45,98.17) 175.5,98.15 arc(175.59,98.11) 175.67,98.08 arc(175.73,98.07) 175.78,98.07 177.91,98.07 arc(178.12,98.03) 178.3,97.91 178.61,97.6 arc(178.76,97.49) 178.95,97.46 179.9,97.46 arc(179.95,97.46) 180.01,97.47 arc(180.14,97.5) 180.26,97.55 arc(180.31,97.58) 180.35,97.61 180.49,97.74 arc(180.55,97.82) 180.58,97.91 arc(180.59,97.94) 180.59,97.98 180.59,98.09 arc(180.56,98.16) 180.48,98.2 arc(180.38,98.24) 180.34,98.34 180.34,98.52 arc(180.38,98.6) 180.45,98.63 arc(180.55,98.67) 180.59,98.77 180.59,99.01 arc(180.66,99.35) 180.86,99.64 181.48,100.27 arc(181.89,100.54) 182.37,100.64 185.65,100.64 arc(185.86,100.6) 186.04,100.48 186.3,100.22 arc(186.52,100.07) 186.79,100.02 187.2,100.02 arc(187.28,100.05) 187.31,100.13 arc(187.35,100.22) 187.43,100.25 187.63,100.25 arc(187.71,100.22) 187.75,100.13 arc(187.78,100.05) 187.87,100.02 188.46,100.02 arc(188.6,99.99) 188.72,99.91 189.5,99.13 arc(189.58,99) 189.61,98.86 189.61,98.17 arc(189.68,97.84) 189.87,97.55 190.11,97.32 arc(190.38,97.13) 190.71,97.07 192.5,97.07 arc(192.78,97.12) 193.01,97.28 193.44,97.71 arc(193.54,97.86) 193.58,98.04 193.58,98.24 arc(193.6,98.37) 193.67,98.49 arc(193.83,98.61) 194.03,98.65 194.07,98.65 arc(194.16,98.67) 194.23,98.73 arc(194.28,98.79) 194.3,98.87 v1(194.3,98.95)
  BOTTOM w0.109: v1(194.3,98.95) 194.02,98.68 arc(193.99,98.65) 193.95,98.65 193.71,98.65 arc(193.52,98.62) 193.34,98.53 arc(193.29,98.51) 193.22,98.5 192.94,98.5 arc(192.9,98.5) 192.87,98.52 192.7,98.65 arc(192.39,98.82) R5949.1
TCP0_DIRECT_TX1_R_DN: length 24.7
  TOP w0.109: v2(193.83,94.88) arc(193.75,95.04) 193.59,95.12 193.44,95.12 arc(193.24,95.08) 193.07,94.96 192.81,94.71 arc(192.43,94.45) 191.98,94.36 191.83,94.36 arc(191.42,94.28) 191.07,94.05 190.1,93.08 arc(190.07,93) 190.1,92.91 arc(190.14,92.83) 190.1,92.75 189.96,92.61 arc(189.88,92.57) 189.79,92.61 arc(189.71,92.64) 189.63,92.61 189.3,92.28 189.29,92.28 arc(188.82,92.04) 188.3,91.95 182.92,91.95 arc(182.42,92.05) 181.99,92.34 181.89,92.44 arc(180.96,93.06) 179.86,93.28 179.65,93.28 arc(179.59,93.26) 179.57,93.2 arc(179.54,93.12) 179.46,93.09 179.24,93.09 arc(179.16,93.12) 179.13,93.2 arc(179.11,93.26) 179.05,93.28 175.91,93.28 arc(175.7,93.24) 175.51,93.11 175.33,92.93 arc(175.26,92.82) 175.23,92.7 175.23,92.7 175.23,92.34 arc(175.27,92.25) 175.35,92.22 175.36,92.22 arc(175.43,92.23) 175.48,92.27 175.65,92.44 arc(175.69,92.48) 175.74,92.51 175.83,92.59 arc(176.08,92.72) R5958.1
  BOTTOM w0.109: v2(193.83,94.88) 193.66,95.05 arc(193.62,95.08) 193.58,95.11 192.97,95.11 arc(192.93,95.1) 192.89,95.07 192.76,94.95 arc(192.73,94.92) 192.7,94.9 arc(192.43,94.74) 192.12,94.69 R5959.1
TCP0_DIRECT_TX1_R_DP: length 24.7
  TOP w0.109: R5956.1 176.18,91.63 arc(175.9,91.69) 175.66,91.85 175.63,91.88 arc(175.5,91.97) 175.35,92 arc(175.11,92.1) 175.01,92.34 175.01,92.7 arc(175.05,92.91) 175.17,93.09 175.35,93.27 arc(175.61,93.44) 175.91,93.5 179.86,93.5 arc(181.05,93.27) 182.05,92.6 182.15,92.49 arc(182.5,92.26) 182.92,92.18 188.3,92.18 arc(188.75,92.25) 189.16,92.46 190.91,94.21 arc(191.33,94.49) 191.83,94.59 191.98,94.59 arc(192.34,94.66) 192.65,94.87 192.91,95.12 arc(193.15,95.29) 193.44,95.34 193.52,95.34 arc(193.62,95.36) 193.71,95.42 v2(193.81,95.52)
  BOTTOM w0.109: v2(193.81,95.52) 193.78,95.49 arc(193.68,95.41) 193.56,95.35 193.48,95.33 193.23,95.33 arc(192.98,95.38) 192.77,95.52 192.73,95.56 arc(192.72,95.57) 192.7,95.59 arc(192.39,95.76) R5957.1
TCP0_DIRECT_TXRX0_R_DN: length 30.7
  TOP w0.109: R5954.1 175.78,97.35 arc(175.56,97.31) 175.38,97.19 175.22,97.03 arc(175.05,96.91) 174.84,96.87 174.72,96.87 arc(174.5,96.96) 174.41,97.19 174.41,97.34 arc(174.44,97.4) 174.5,97.43 arc(174.57,97.46) 174.6,97.52 174.6,97.77 arc(174.57,97.84) 174.5,97.87 arc(174.44,97.89) 174.41,97.96 174.41,98.95 arc(174.46,99.22) 174.62,99.45 174.87,99.7 arc(176.08,100.51) 177.5,100.79 177.88,100.79 arc(177.93,100.77) 177.96,100.71 arc(177.99,100.64) 178.06,100.61 178.29,100.61 arc(178.36,100.64) 178.39,100.71 arc(178.42,100.77) 178.47,100.79 178.75,100.79 arc(178.81,100.77) 178.83,100.71 arc(178.86,100.64) 178.93,100.61 179.16,100.61 arc(179.24,100.64) 179.27,100.71 arc(179.29,100.77) 179.35,100.79 179.96,100.79 arc(180.17,100.82) 180.37,100.91 180.46,100.96 arc(180.75,101.1) 181.07,101.14 186.38,101.14 arc(186.49,101.12) 186.58,101.06 arc(186.82,100.9) 187.1,100.84 187.65,100.84 187.84,100.84 arc(188.44,100.78) 189.01,100.58 arc(189.06,100.55) 189.1,100.52 189.74,99.88 arc(189.99,99.55) 190.14,99.16 arc(190.14,99.11) 190.15,99.05 190.15,98.23 arc(190.17,98.08) 190.24,97.93 190.33,97.82 arc(190.52,97.65) 190.77,97.59 192.32,97.59 arc(192.6,97.65) 192.84,97.81 192.92,97.89 arc(193.04,98.07) 193.08,98.28 193.08,98.41 arc(193.19,98.93) 193.49,99.38 194.17,100.06 arc(194.17,100.06) 194.17,100.06 arc(194.18,100.07) 194.19,100.07 arc(194.21,100.08) 194.22,100.08 194.26,100.08 arc(194.32,100.09) 194.38,100.1 arc(194.4,100.1) 194.41,100.1 arc(194.46,100.09) 194.5,100.07 v2(194.67,99.9)
  BOTTOM w0.109: R5955.1 193.35,99.74 arc(193.52,99.77) 193.67,99.87 193.8,99.99 arc(193.97,100.11) 194.17,100.15 194.37,100.15 arc(194.41,100.14) 194.45,100.12 v2(194.67,99.9)
TCP0_DIRECT_TXRX0_R_DP: length 30.8
  TOP w0.109: v1(194.68,100.59) 194.53,100.44 arc(194.4,100.35) 194.24,100.31 194.21,100.3 194.19,100.3 arc(194.16,100.29) 194.12,100.28 arc(194.1,100.27) 194.08,100.27 arc(194.06,100.25) 194.04,100.24 arc(194.03,100.23) 194.02,100.23 193.33,99.54 arc(192.98,99.02) 192.86,98.41 192.86,98.28 arc(192.84,98.15) 192.77,98.05 192.68,97.97 arc(192.52,97.85) 192.32,97.82 190.77,97.82 arc(190.63,97.85) 190.51,97.95 190.43,98.06 arc(190.38,98.14) 190.37,98.23 190.37,99.05 arc(190.37,99.13) 190.35,99.21 arc(190.18,99.66) 189.89,100.04 189.26,100.68 arc(189.19,100.74) 189.11,100.78 arc(188.49,101) 187.84,101.07 187.1,101.07 arc(186.9,101.11) 186.74,101.22 arc(186.58,101.33) 186.38,101.36 181.07,101.36 arc(180.69,101.31) 180.34,101.15 180.25,101.1 arc(180.11,101.03) 179.96,101.01 177.5,101.01 arc(175.99,100.71) 174.71,99.86 174.46,99.6 arc(174.26,99.3) 174.19,98.95 174.19,97.19 arc(174.35,96.81) 174.72,96.65 174.82,96.65 arc(175.03,96.61) 175.21,96.49 175.28,96.41 arc(175.4,96.32) 175.53,96.25 arc(175.62,96.22) 175.72,96.21 R5952.1
  BOTTOM w0.109: R5953.1 193.35,100.88 arc(193.54,100.84) 193.7,100.73 193.96,100.47 arc(194.01,100.43) 194.05,100.41 arc(194.14,100.38) 194.24,100.37 arc(194.45,100.42) 194.62,100.53 v1(194.68,100.59)
TCP0_DIRECT_TXRX1_R_DN: length 26.5
  TOP w0.109: R5962.1 176.17,95.19 arc(175.93,95.14) 175.73,95.01 175.62,94.9 arc(175.47,94.79) 175.3,94.74 175.24,94.73 arc(174.97,94.67) 174.74,94.52 174.43,94.21 arc(174.33,94.05) 174.29,93.86 174.29,92.19 arc(174.36,91.84) 174.56,91.54 174.84,91.26 arc(175.23,91) 175.7,90.9 179.05,90.9 arc(179.34,90.96) 179.57,91.12 179.6,91.15 arc(179.7,91.21) 179.83,91.24 189.16,91.24 arc(189.44,91.27) 189.71,91.35 189.71,91.35 arc(189.96,91.48) 190.17,91.66 190.47,91.96 arc(190.92,92.26) 191.46,92.37 192.4,92.37 arc(192.65,92.42) 192.87,92.56 192.98,92.66 arc(193.01,92.7) 193.05,92.75 arc(193.15,92.86) 193.28,92.93 arc(193.36,92.94) 193.42,92.9 v2(193.51,92.81)
  BOTTOM w0.109: R5963.1 192.12,92.52 arc(192.47,92.59) 192.76,92.79 192.8,92.83 arc(192.85,92.87) 192.89,92.89 arc(193,92.93) 193.11,92.94 193.21,92.94 arc(193.37,92.9) v2(193.51,92.81)
TCP0_DIRECT_TXRX1_R_DP: length 26.4
  TOP w0.109: v2(193.51,93.52) 193.51,93.4 arc(193.49,93.31) 193.44,93.24 arc(193.37,93.19) 193.29,93.17 arc(193.29,93.16) 193.29,93.16 arc(193.25,93.15) 193.21,93.14 arc(193.01,93.03) 192.86,92.87 192.86,92.87 arc(192.84,92.84) 192.82,92.82 192.72,92.72 arc(192.57,92.62) 192.4,92.59 191.46,92.59 arc(190.84,92.47) 190.31,92.11 190.31,92.11 190.01,91.82 arc(189.83,91.67) 189.63,91.56 189.62,91.56 arc(189.4,91.49) 189.16,91.46 179.83,91.46 arc(179.62,91.42) 179.44,91.3 179.42,91.28 arc(179.25,91.17) 179.05,91.13 175.7,91.13 arc(175.32,91.2) 175,91.42 174.8,91.61 174.72,91.69 arc(174.57,91.92) 174.52,92.19 174.52,92.97 arc(174.53,93.06) 174.58,93.13 174.59,93.14 arc(174.68,93.35) 174.59,93.55 174.55,93.59 arc(174.52,93.63) 174.52,93.67 174.52,93.86 arc(174.54,93.96) 174.59,94.05 174.9,94.36 arc(175.06,94.47) 175.25,94.51 175.34,94.52 arc(175.47,94.5) 175.57,94.43 175.88,94.12 arc(175.92,94.09) 175.97,94.07 arc(176.04,94.05) 176.11,94.05 R5960.1
  BOTTOM w0.109: R5961.1 192.38,93.66 arc(192.46,93.65) 192.52,93.61 192.93,93.2 arc(192.97,93.17) 193.02,93.16 193.21,93.16 arc(193.27,93.16) 193.32,93.18 193.38,93.19 arc(193.4,93.2) 193.41,93.21 193.46,93.24 arc(193.5,93.29) 193.51,93.34 v2(193.51,93.52)
TCP0_FLASH_CLK: length 53.5
  IN2 w0.089: v1(184.21,68.4) 183.84,68.77 183.84,69.32 183.49,69.67 183.49,71.44 182.92,72 182.92,74.28 182.07,75.14 182.07,77.04 177.44,81.67 177.44,84.25 175.76,85.93 175.76,86.67 175.17,87.26 175.17,89.81 175.82,90.46 179.49,90.46 180.06,91.03 183.13,91.03 184.02,90.14 184.48,90.14 184.74,90.4 184.81,90.57 184.81,91.95 185.62,92.76 185.62,93.79 v2(186.29,94.46)
  BOTTOM w0.109: v1(184.21,68.4) 185.16,67.45 186.61,67.45 187.23,66.83 188.01,66.83 189.63,68.45 190.42,68.45 190.57,68.3 190.57,67.64 189.9,66.97 189.9,66.49 190.07,66.32 TP5911.1 189.2,64.79 U5901.6 ; U5900.C7 185.95,94.79 v2(186.29,94.46)
TCP0_FLASH_CS#: length 53.6
  IN2 w0.089: v1(180.43,61.31) 180.43,62.93 179.29,64.07 179.29,64.3 179.65,64.67 180.26,64.67 183.19,67.59 183.19,69.22 182.95,69.45 182.95,71.21 182.39,71.78 182.39,73.14 181.53,74 181.53,76.82 176.9,81.45 176.9,84.03 175.23,85.71 175.23,86.45 174.64,87.04 174.64,90.03 175.6,90.99 179.18,90.99 179.81,91.63 181.92,91.63 183.11,92.81 183.11,92.91 183.67,93.47 184.38,93.47 v2(184.81,93.04)
  BOTTOM w0.109: U5900.B6 184.8,93.78 184.8,93.05 v2(184.81,93.04) ; v1(180.43,61.31) 179.44,60.32 TP5910.1 179.22,60.37 R5942.1 179.17,61.31 180.1,62.25 U5901.1
TCP0_FLASH_DI: length 51.8
  IN2 w0.089: v2(185.63,94.43) 185.3,94.77 184.91,94.77 184.87,94.75 184.66,94.54 184.66,94.05 185.24,93.47 185.24,92.94 184.78,92.48 183.62,92.48 182.37,91.23 179.97,91.23 179.38,90.64 175.75,90.64 175,89.88 175,87.19 175.59,86.6 175.59,85.85 177.26,84.18 177.26,81.59 181.89,76.97 181.89,75.05 182.74,74.2 182.74,71.93 183.31,71.36 183.31,69.6 183.54,69.36 183.54,66.81 v1(183.61,66.75)
  BOTTOM w0.109: U5901.5 188.66,66.06 189.99,67.38 TP5908.1 189.52,67.94 188.18,66.6 187.14,66.6 186.51,67.22 184.08,67.22 v1(183.61,66.75) ; v2(185.63,94.43) 185.65,94.46 185.65,94.47 185.33,94.79 U5900.C6
TCP0_FLASH_DO: length 47.9
  IN2 w0.089: v2(183.78,93.03) 183.39,92.65 183.34,92.65 182.14,91.45 179.89,91.45 179.25,90.82 175.68,90.82 174.82,89.96 174.82,87.11 175.41,86.52 175.41,85.78 177.08,84.11 177.08,81.52 181.71,76.89 181.71,74.07 182.57,73.21 182.57,71.85 183.13,71.29 183.13,69.53 183.37,69.29 183.37,67.52 180.01,64.16 v1(179.75,64.16)
  BOTTOM w0.109: v2(183.78,93.03) 183.88,93.14 183.88,93.78 U5900.B4 ; v1(179.75,64.16) 179.75,63.76 178.83,62.85 178.54,62.85 178.28,62.58 R5944.1 179.19,62.46 TP5909.1 180.26,63.52 U5901.2
TCP0_FLASH_HOLD#: length 6.7
  BOTTOM w0.109: R5940.1 188.46,58.9 TP5906.1 189.61,60.75 189.61,63.37 189.46,63.52 U5901.7
TCP0_FLASH_MSTR_SLV: length 2.6
  BOTTOM w0.079: U5900.A5 184.53,93.51 184.53,93.32 184.48,93.27 184.48,92.81 184.52,92.76
  BOTTOM w0.109: R5933.1 183.43,91.52 184.52,92.62 184.52,92.76
TCP0_FLASH_SHARE_EN: length 4
  BOTTOM w0.109: U5900.A4 184.12,92.84 183.99,92.72 183.85,92.66 183.03,92.66 182.22,91.84 181.72,91.84 R5932.1
TCP0_FLASH_WP#: length 3.1
  BOTTOM w0.109: R5945.1 178.95,63.65 179.14,63.84 179.14,64.72 TP5907.1 180.82,64.84 U5901.3
TCP0_GPIO_5: length 3.7
  BOTTOM w0.079: 187.08,92.59 187.08,92.67 186.81,92.94 186.81,93.25 186.63,93.43 186.63,93.8 U5900.B9
  BOTTOM w0.109: R5924.1 188.25,91.79 187.68,91.79 v1(187.22,92.25) 187.08,92.39 187.08,92.59
TCP0_GPIO_6: length 3.2
  BOTTOM w0.109: R5926.1 186.95,91.07 186.5,91.52 R5925.2 185.95,91.88 v1(185.95,92.2) 185.95,92.76 185.82,92.89 185.82,93.42 U5900.A8
TCP0_GPIO_12: length 5.1
  BOTTOM w0.109: U5900.A6 185.04,93.35 185.22,93.16 185.22,92.92 184.68,92.38 v1(184.68,92.18) 183.77,91.27 183.77,90.8 183.68,90.72 R5935.1 183.55,90.05 183.1,89.6 R5934.1
TCP0_JTAG_TCK: length 3.6
  BOTTOM w0.079: 184.31,92.73 184.31,93.36 184.34,93.4 184.34,93.78 U5900.B5
  BOTTOM w0.109: 184.31,92.73 184.15,92.58 183.95,92.44 TP5902.1 183.15,92.22 182.67,91.73 R5941.1
TCP0_JTAG_TDI: length 4.8
  BOTTOM w0.079: U5900.A3 183.66,93.42 183.25,93.01 182.84,93.01
  BOTTOM w0.109: 182.84,93.01 181.19,93.01 TP5900.1 179.86,91.69 R5937.1
TCP0_JTAG_TDO: length 7
  IN2 w0.089: v2(184.3,90.51) 184.48,90.68 184.48,91.89 185.42,92.83 185.42,93.67 185.04,94.05 v2(185.04,94.41)
  BOTTOM w0.109: v2(184.3,90.51) 184.3,90.19 R5943.1 184.81,90.07 184.96,89.91 185.44,89.91 TP5903.1 ; U5900.C5 184.76,94.79 185.04,94.51 v2(185.04,94.41)
TCP0_JTAG_TMS: length 5.5
  IN2 w0.089: v2(183.65,94.49) 183.65,94.36 v2(181.4,92.11)
  BOTTOM w0.079: v2(183.65,94.49) 183.95,94.79 U5900.C3
  BOTTOM w0.109: R5939.1 180.81,91.52 v2(181.4,92.11) 181.58,92.29 TP5901.1
TCP0_RESET#: length 4.6
  TOP w0.109: R5927.1 189.75,95.78 189.75,95.79 R5928.1 189.75,96.3 188.77,97.28 188.77,97.94 v2(188.83,98)
  BOTTOM w0.079: v2(188.83,98) 188.73,98.1 188.12,98.1 187.95,97.93 187.56,97.93 U5900.L11
TCP0_TEST_PWRGD: length 2.9
  BOTTOM w0.079: 182.94,93.22 183.23,93.22 183.42,93.42 183.42,93.79 U5900.B3
  BOTTOM w0.109: R5922.1 182.34,93.4 182.52,93.22 182.94,93.22
TCP0_THERMDA: length 2.1
  BOTTOM w0.109: U5900.M11 187.68,98.96 188.89,98.96 TP5904.1
TCP0_TX_N0: length 74.3
  TOP w0.109: v2(176.5,99.19) 176.62,99.31 arc(176.75,99.5) 176.8,99.73 R5950.2
  IN1 w0.079: v2(117.47,89.02) 117.47,88.92 arc(117.46,88.88) 117.44,88.84 117.43,88.83 arc(117.39,88.8) 117.35,88.8 117.27,88.8 arc(117.18,88.81) 117.11,88.86 117.08,88.89 arc(117.06,88.91) 117.06,88.94 117.06,89.66 arc(117.06,89.7) 117.07,89.74 arc(117.09,89.79) 117.12,89.84 arc(117.14,89.87) 117.16,89.9 117.9,90.64 arc(118.03,90.73) 118.18,90.78 118.7,90.88 arc(118.81,90.91) 118.91,90.98 119.96,92.04 arc(124.42,95.02) 129.67,96.06 132.73,96.06 arc(132.98,96.09) 133.22,96.2 133.3,96.25 arc(133.36,96.27) 133.42,96.28 135.39,96.28 arc(135.61,96.33) 135.79,96.45 135.91,96.57 arc(136.65,97.05) 137.51,97.23 arc(137.82,97.29) 138.08,97.47 138.89,98.27 arc(139.1,98.44) 139.34,98.55 arc(139.54,98.59) 139.74,98.61 140.91,98.61 arc(141.07,98.64) 141.21,98.74 141.39,98.91 arc(141.58,99.03) 141.8,99.08 147.3,99.08 arc(147.67,99.01) 147.99,98.8 149.93,96.85 arc(149.99,96.8) 150.07,96.77 arc(150.22,96.73) 150.37,96.72 152.72,96.72 arc(153.13,96.8) 153.49,97.04 154.02,97.57 arc(154.79,98.09) 155.71,98.27 157.99,98.27 arc(158.27,98.21) 158.51,98.05 158.72,97.84 158.79,97.77 arc(158.9,97.7) 159.03,97.67 160.68,97.67 arc(160.83,97.7) 160.96,97.79 161.35,98.18 arc(161.42,98.23) 161.51,98.24 164.52,98.24 arc(164.61,98.23) 164.68,98.18 165.07,97.79 arc(165.2,97.7) 165.35,97.67 166.99,97.67 arc(167.14,97.7) 167.26,97.79 167.68,98.2 arc(167.76,98.25) 167.84,98.27 172.65,98.27 arc(173.23,98.39) 173.72,98.71 174.1,99.09 arc(174.83,99.58) 175.69,99.75 176.35,99.75 arc(176.5,99.72) 176.63,99.64 176.71,99.56 arc(176.75,99.51) 176.77,99.45 176.79,99.4 arc(176.76,99.25) 176.62,99.19 v2(176.5,99.19)
  BOTTOM w0.079: U400.AT5 116.43,84.22 arc(116.4,84.13) 116.44,84.04 arc(116.45,84.03) 116.46,84.02 arc(116.51,83.99) 116.57,83.99 arc(116.61,83.99) 116.66,84 arc(116.69,84.01) 116.71,84.02 116.75,84.04 arc(116.84,84.12) 116.87,84.24 116.87,85.12 arc(116.86,85.22) 116.82,85.3 arc(116.78,85.39) 116.77,85.48 116.77,86.4 arc(116.8,86.53) 116.88,86.65 116.94,86.71 arc(116.99,86.79) 117.01,86.88 117.01,87.25 arc(117,87.3) 116.99,87.35 116.98,87.36 arc(116.91,87.57) 116.88,87.79 116.88,88.51 arc(116.96,88.69) 117.15,88.77 117.3,88.77 arc(117.37,88.78) 117.42,88.82 arc(117.46,88.88) 117.47,88.94 v2(117.47,89.02)
TCP0_TX_N0_C: length 7.9
  TOP w0.109: C5901.1 177.5,99.76 arc(177.71,99.72) 177.89,99.6 178.02,99.47 arc(178.04,99.45) 178.07,99.43 arc(178.08,99.42) 178.09,99.41 arc(178.24,99.34) 178.41,99.31 178.82,99.31 arc(178.99,99.29) 179.15,99.21 arc(179.33,99.02) 179.39,98.77 179.39,98.53 arc(179.42,98.4) 179.5,98.3 v2(179.6,98.19)
  BOTTOM w0.079: U5900.J2 183.09,97.35 arc(182.98,97.42) 182.85,97.45 182.57,97.45 arc(182.48,97.43) 182.41,97.38 arc(182.35,97.34) 182.28,97.32 arc(182.27,97.32) 182.26,97.32 182.24,97.32 arc(182.07,97.29) 181.92,97.19 181.88,97.15 arc(181.81,97.11) 181.73,97.09 181.19,97.09 arc(181.14,97.1) 181.09,97.13
  BOTTOM w0.109: 181.09,97.13 180.64,97.13 arc(180.13,97.23) 179.7,97.52 179.41,97.81 arc(179.39,97.84) 179.39,97.87 179.39,97.91 arc(179.4,97.97) 179.43,98.01 v2(179.6,98.19)
TCP0_TX_N1: length 75.9
  TOP w0.109: C5909.2 176.8,92.66 arc(176.81,92.57) 176.86,92.5 v2(177.15,92.21)
  IN1 w0.079: v2(116.1,86.99) 116.25,87.14 arc(116.31,87.23) 116.34,87.34 arc(116.44,87.52) 116.63,87.59 117,87.59 arc(117.09,87.58) 117.18,87.55 arc(117.28,87.52) 117.37,87.51 118.68,87.51 arc(118.77,87.53) 118.84,87.58 118.96,87.69 arc(118.99,87.72) 119.01,87.76 arc(119.03,87.8) 119.03,87.84 119.03,88.23 arc(119.13,88.7) 119.39,89.1 121.89,91.6 arc(125.12,93.75) 128.92,94.51 130.9,94.51 arc(131.13,94.48) 131.35,94.38 131.45,94.31 arc(131.68,94.21) 131.94,94.17 132.86,94.17 arc(133.06,94.21) 133.23,94.32 133.47,94.56 arc(133.89,94.84) 134.38,94.94 136.19,94.94 arc(136.32,94.97) 136.44,95.04 136.79,95.4 arc(136.88,95.48) 136.98,95.55 arc(137.09,95.62) 137.21,95.67 arc(137.34,95.72) 137.48,95.73 138.13,95.73 arc(138.33,95.77) 138.51,95.89 139.39,96.76 arc(139.92,97.12) 140.54,97.24 141.59,97.24 arc(141.68,97.26) 141.75,97.31 141.89,97.45 arc(142.21,97.66) 142.59,97.74 146.61,97.74 arc(146.74,97.73) 146.86,97.71 146.86,97.71 arc(146.92,97.7) 146.97,97.68 147.26,97.55 arc(147.33,97.52) 147.38,97.47 149.14,95.71 arc(149.54,95.44) 150.02,95.35 153.39,95.35 arc(153.71,95.41) 153.98,95.59 154.81,96.43 arc(155.2,96.72) 155.66,96.89 arc(155.76,96.9) 155.86,96.91 157.44,96.91 arc(157.59,96.88) 157.72,96.79 158.04,96.47 arc(158.24,96.34) 158.48,96.29 161.47,96.29 arc(161.55,96.31) 161.62,96.36 162.04,96.77 arc(162.17,96.86) 162.32,96.89 163.84,96.89 arc(163.99,96.86) 164.11,96.77 164.53,96.36 arc(164.61,96.31) 164.69,96.29 167.61,96.29 arc(167.7,96.31) 167.77,96.36 168.21,96.79 arc(168.34,96.88) 168.49,96.91 172.2,96.91 arc(172.3,96.9) 172.4,96.89 arc(172.85,96.72) 173.24,96.43 176.82,92.85 arc(176.9,92.73) 176.92,92.59 176.92,92.58 arc(176.95,92.45) 177.03,92.33 v2(177.15,92.21)
  BOTTOM w0.079: U400.AM7 114.63,83.79 arc(114.59,83.82) 114.55,83.83 arc(114.55,83.83) 114.55,83.83 arc(114.49,83.85) 114.43,83.88 arc(114.39,83.9) 114.35,83.94 arc(114.3,84) 114.27,84.07 114.25,84.14 arc(114.24,84.2) 114.24,84.26 114.24,85 arc(114.37,85.31) 114.67,85.44 115.96,85.44 arc(116.07,85.48) 116.12,85.6 116.12,86.3 arc(116.13,86.36) 116.14,86.42 116.2,86.66 116.2,86.75 arc(116.18,86.88) v2(116.1,86.99)
TCP0_TX_N1_C: length 7.4
  TOP w0.109: v2(178.84,92.5) 178.74,92.4 arc(178.64,92.34) 178.52,92.31 178.42,92.31 arc(178.21,92.35) 178.03,92.47 177.9,92.6 arc(177.71,92.73) 177.49,92.78 C5909.1
  BOTTOM w0.079: U5900.C2 183.08,94.59 arc(182.97,94.66) 182.84,94.69 182.67,94.69 arc(182.58,94.67) 182.5,94.62 182.47,94.59 arc(182.45,94.57) 182.44,94.56 arc(182.35,94.51) 182.25,94.49 181.57,94.49 arc(181.52,94.5) 181.49,94.53
  BOTTOM w0.109: 181.49,94.53 181.27,94.53 arc(181.09,94.49) 180.95,94.39 180.49,93.94 arc(180.41,93.83) 180.35,93.71 180.23,93.35 arc(180.21,93.3) 180.18,93.26 179.26,92.34 arc(179.24,92.33) 179.22,92.32 179.13,92.29 arc(179.07,92.29) 179.02,92.32 v2(178.84,92.5)
TCP0_TX_P0: length 74.3
  TOP w0.109: R5947.2 176.8,98.74 arc(176.82,98.84) 176.87,98.92 v2(177.15,99.2)
  IN1 w0.079: v2(117.47,88.44) 117.35,88.57 arc(117.3,88.6) 117.24,88.63 arc(117.11,88.65) 117.01,88.72 116.96,88.77 arc(116.91,88.85) 116.89,88.94 116.89,89.66 arc(116.9,89.73) 116.91,89.8 arc(116.94,89.86) 116.97,89.92 arc(117,89.97) 117.04,90.02 117.78,90.76 arc(117.95,90.88) 118.15,90.95 118.67,91.04 arc(118.73,91.06) 118.79,91.1 119.85,92.16 arc(124.35,95.17) 129.67,96.23 132.73,96.23 132.73,96.23 arc(132.94,96.26) 133.13,96.34 133.22,96.39 arc(133.31,96.44) 133.42,96.45 135.39,96.45 arc(135.55,96.48) 135.67,96.57 135.79,96.69 arc(136.58,97.21) 137.51,97.4 137.51,97.4 arc(137.75,97.45) 137.96,97.58 138.77,98.39 arc(139.01,98.58) 139.29,98.71 arc(139.51,98.76) 139.74,98.78 140.91,98.78 arc(141.01,98.8) 141.1,98.86 141.27,99.03 arc(141.51,99.19) 141.8,99.25 147.3,99.25 arc(147.74,99.16) 148.1,98.91 150.05,96.97 arc(150.08,96.95) 150.12,96.93 arc(150.24,96.9) 150.37,96.89 152.72,96.89 arc(153.07,96.96) 153.37,97.16 153.9,97.69 arc(154.73,98.24) 155.71,98.44 157.99,98.44 arc(158.33,98.37) 158.63,98.17 158.91,97.89 arc(158.96,97.85) 159.03,97.84 160.68,97.84 arc(160.76,97.86) 160.84,97.9 161.23,98.3 arc(161.36,98.38) 161.51,98.41 164.52,98.41 arc(164.67,98.38) 164.8,98.3 165.19,97.9 arc(165.27,97.86) 165.35,97.84 166.99,97.84 arc(167.07,97.86) 167.15,97.9 167.56,98.32 arc(167.69,98.41) 167.84,98.44 172.65,98.44 arc(173.17,98.54) 173.6,98.83 173.98,99.21 arc(174.77,99.74) 175.69,99.92 176.35,99.92 arc(176.56,99.88) 176.74,99.76 176.83,99.68 arc(176.89,99.6) 176.94,99.49 arc(176.98,99.39) 177.04,99.3 v2(177.15,99.2)
  BOTTOM w0.079: v2(117.47,88.44) 117.41,88.51 arc(117.29,88.59) 117.15,88.61 arc(117.07,88.58) 117.04,88.51 117.04,87.79 arc(117.06,87.61) 117.12,87.43 117.13,87.42 arc(117.16,87.34) 117.17,87.25 117.17,86.88 arc(117.14,86.73) 117.05,86.6 116.99,86.54 arc(116.94,86.47) 116.93,86.4 116.93,85.48 arc(116.94,85.43) 116.96,85.38 arc(117.01,85.26) 117.03,85.12 117.03,84.24 arc(116.97,84.04) 116.82,83.9 116.79,83.88 arc(116.78,83.88) 116.78,83.88 116.69,83.83 U400.AT7
TCP0_TX_P0_C: length 7.9
  TOP w0.109: C5900.1 177.32,98.62 arc(177.38,98.62) 177.43,98.63 177.78,98.73 arc(177.83,98.74) 177.87,98.76 177.89,98.78 arc(177.89,98.78) 177.9,98.78 178.09,98.96 arc(178.25,99.05) 178.43,99.09 178.82,99.09 arc(178.93,99.07) 179.03,99.03 arc(179.13,98.91) 179.17,98.77 179.17,98.65 arc(179.13,98.47) 179.03,98.31 v2(178.9,98.19)
  BOTTOM w0.079: U5900.J1 182.83,97.24 arc(182.94,97.13) 182.83,97.03 182.59,97.03 arc(182.52,97.04) 182.47,97.08 arc(182.37,97.14) 182.26,97.17 182.24,97.17 arc(182.13,97.14) 182.03,97.08 181.99,97.04 arc(181.87,96.96) 181.73,96.93 181.14,96.93 arc(181.11,96.93) 181.09,96.91
  BOTTOM w0.109: 181.09,96.91 180.64,96.91 arc(180.05,97.03) 179.54,97.36 179.25,97.65 arc(179.19,97.75) 179.16,97.87 179.16,97.88 arc(179.15,97.93) 179.13,97.97 v2(178.9,98.19)
TCP0_TX_P1: length 75.8
  TOP w0.109: R5956.2 176.8,91.75 arc(176.77,91.89) 176.69,92.02 v2(176.5,92.2)
  IN1 w0.079: v2(116.69,86.99) 116.53,87.14 arc(116.51,87.18) 116.5,87.22 116.5,87.26 arc(116.5,87.29) 116.51,87.31 arc(116.55,87.39) 116.63,87.42 117,87.42 arc(117.06,87.42) 117.11,87.4 arc(117.24,87.36) 117.37,87.34 118.68,87.34 arc(118.83,87.37) 118.96,87.46 119.08,87.57 arc(119.12,87.62) 119.16,87.68 arc(119.19,87.75) 119.2,87.84 119.2,88.23 arc(119.28,88.64) 119.51,88.98 122.01,91.48 arc(125.18,93.6) 128.92,94.34 130.9,94.34 arc(131.09,94.32) 131.26,94.24 131.36,94.17 arc(131.64,94.05) 131.94,94 132.86,94 arc(133.12,94.06) 133.35,94.21 133.59,94.45 arc(133.95,94.69) 134.38,94.77 136.19,94.77 arc(136.39,94.81) 136.56,94.93 136.91,95.28 arc(136.99,95.35) 137.07,95.4 137.08,95.41 arc(137.17,95.47) 137.27,95.52 arc(137.37,95.55) 137.48,95.56 138.13,95.56 arc(138.4,95.62) 138.63,95.77 139.5,96.65 arc(139.98,96.96) 140.54,97.08 141.59,97.08 arc(141.74,97.11) 141.87,97.19 142.01,97.33 arc(142.28,97.51) 142.59,97.57 146.61,97.57 arc(146.72,97.57) 146.83,97.55 arc(146.87,97.54) 146.9,97.53 147.19,97.4 arc(147.23,97.38) 147.26,97.35 149.02,95.59 arc(149.48,95.29) 150.02,95.18 153.39,95.18 arc(153.77,95.26) 154.1,95.47 154.93,96.31 arc(155.28,96.57) 155.7,96.72 arc(155.78,96.73) 155.86,96.74 157.44,96.74 arc(157.53,96.72) 157.6,96.67 157.92,96.35 arc(158.18,96.18) 158.48,96.12 161.47,96.12 arc(161.62,96.15) 161.74,96.24 162.16,96.65 arc(162.23,96.7) 162.32,96.72 163.84,96.72 arc(163.92,96.7) 164,96.65 164.41,96.24 arc(164.54,96.15) 164.69,96.12 167.61,96.12 arc(167.76,96.15) 167.89,96.24 168.33,96.67 arc(168.4,96.72) 168.49,96.74 172.2,96.74 arc(172.29,96.73) 172.37,96.72 arc(172.77,96.57) 173.12,96.31 176.7,92.73 arc(176.74,92.67) 176.76,92.59 176.76,92.56 arc(176.74,92.47) 176.69,92.39 v2(176.5,92.2)
  BOTTOM w0.079: v2(116.69,86.99) 116.67,86.98 arc(116.65,86.95) 116.63,86.93 116.37,86.6 116.36,86.58 arc(116.35,86.57) 116.34,86.55 arc(116.33,86.53) 116.33,86.51 116.33,86.51 116.29,86.38 arc(116.28,86.34) 116.28,86.3 116.28,85.6 arc(116.19,85.37) 115.96,85.28 114.67,85.28 arc(114.48,85.2) 114.39,85 114.39,84.26 arc(114.4,84.22) 114.41,84.18 114.42,84.11 arc(114.44,84.08) 114.47,84.05 arc(114.49,84.03) 114.51,84.01 arc(114.54,84) 114.57,83.99 arc(114.58,83.99) 114.59,83.99 114.82,83.99 arc(114.88,84) 114.94,84.04 114.94,84.04 arc(114.99,84.15) 114.94,84.27 114.93,84.28 arc(114.86,84.33) 114.78,84.34 U400.AM5
TCP0_TX_P1_C: length 7.4
  TOP w0.109: v2(178.84,91.8) 178.69,91.95 arc(178.54,92.05) 178.36,92.09 178.34,92.09 arc(178.16,92.05) 178.01,91.95 177.84,91.78 arc(177.67,91.67) 177.48,91.63 C5908.1
  BOTTOM w0.079: U5900.C1 182.81,94.48 arc(182.92,94.36) 182.81,94.24 182.6,94.24 arc(182.54,94.25) 182.5,94.28 182.49,94.3 arc(182.44,94.33) 182.38,94.34 181.57,94.34 arc(181.52,94.33) 181.49,94.3
  BOTTOM w0.109: v2(178.84,91.8) 179.04,92 arc(179.12,92.05) 179.21,92.07 arc(179.3,92.09) 179.38,92.15 180.33,93.1 arc(180.4,93.18) 180.45,93.28 180.56,93.64 arc(180.6,93.72) 180.65,93.78 181.1,94.24 arc(181.18,94.29) 181.27,94.3 181.49,94.3
TCP0_TXRX_N0: length 70.5
  TOP w0.109: v2(176.76,96.79) 176.76,96.8 176.66,96.9 arc(176.62,96.94) 176.59,96.98 arc(176.48,97.16) R5954.2
  IN1 w0.079: v2(176.76,96.79) 176.6,96.63 arc(176.54,96.55) 176.52,96.44 arc(176.42,96.2) 176.17,96.1 175.2,96.1 arc(174.73,96.19) 174.33,96.45 174,96.78 arc(173.21,97.31) 172.28,97.49 168.15,97.49 arc(168.06,97.48) 167.99,97.43 167.56,97 arc(167.43,96.91) 167.28,96.88 165.05,96.88 arc(164.9,96.91) 164.77,97 164.35,97.42 arc(164.28,97.47) 164.19,97.48 161.97,97.48 arc(161.89,97.47) 161.81,97.42 161.4,97 arc(161.27,96.91) 161.12,96.88 158.81,96.88 arc(158.5,96.94) 158.24,97.12 157.93,97.43 arc(157.86,97.48) 157.77,97.49 155.78,97.49 arc(155.09,97.36) 154.51,96.97 153.76,96.22 arc(153.45,96.02) 153.09,95.94 150.15,95.94 arc(149.87,95.98) 149.62,96.08 arc(149.61,96.09) 149.6,96.09 147.64,98.05 arc(147.54,98.14) 147.42,98.2 147.24,98.27 arc(147.12,98.31) 146.99,98.32 142.12,98.32 arc(141.89,98.28) 141.69,98.15 141.53,97.99 arc(141.37,97.88) 141.17,97.84 139.64,97.84 arc(139.55,97.82) 139.48,97.77 138.25,96.54 arc(138.12,96.46) 137.97,96.43 137.41,96.43 arc(136.95,96.34) 136.57,96.08 136.13,95.64 arc(136,95.56) 135.85,95.53 133.93,95.53 arc(133.63,95.47) 133.38,95.31 arc(133.14,95.16) 132.87,95.11 129.06,95.11 arc(124.49,94.2) 120.62,91.61 119.08,90.08 arc(119.02,90.03) 118.94,89.99 arc(118.83,89.97) 118.71,89.96 118.61,89.96 arc(118.35,89.86) 118.25,89.61 118.25,88.9 arc(118.26,88.87) 118.27,88.84 118.29,88.83 arc(118.31,88.81) 118.35,88.8 arc(118.39,88.81) 118.43,88.84 v2(118.62,89.02)
  BOTTOM w0.079: v2(118.62,89.02) 118.62,89 118.46,88.84 arc(118.41,88.81) 118.36,88.8 118.32,88.8 arc(118.1,88.71) 118,88.48 118,87.51 arc(118.05,87.27) 118.19,87.07 118.65,86.6 arc(118.7,86.53) 118.71,86.46 118.71,86.25 arc(118.74,86.1) 118.83,85.97 118.92,85.88 arc(118.94,85.87) 118.97,85.85 arc(119,85.84) 119.03,85.81 U400.BB2
TCP0_TXRX_N0_C: length 7.2
  TOP w0.109: C5905.1 177.09,97.35 arc(177.3,97.31) 177.49,97.19 177.69,96.99 arc(177.73,96.95) 177.78,96.93 arc(177.87,96.9) 177.96,96.89 177.98,96.89 arc(178.17,96.86) 178.33,96.75 178.88,96.2 arc(178.97,96.13) 179.08,96.11 179.11,96.11 arc(179.22,96.13) 179.31,96.2 v2(179.52,96.4)
  BOTTOM w0.079: U5900.G2 183.08,96.43 arc(182.96,96.51) 182.83,96.54 182.66,96.54 arc(182.54,96.51) 182.44,96.44 182.43,96.44 arc(182.42,96.43) 182.41,96.42 arc(182.41,96.42) 182.41,96.42 arc(182.4,96.41) 182.38,96.41 arc(182.33,96.39) 182.27,96.38 181.39,96.38 arc(181.22,96.35) 181.08,96.25 arc(180.97,96.18) 180.85,96.14 arc(180.83,96.14) 180.81,96.14 180.75,96.14 arc(180.72,96.14) 180.7,96.16 180.69,96.17 180.67,96.17
  BOTTOM w0.109: 180.67,96.17 179.9,96.17 arc(179.76,96.2) 179.64,96.28 v2(179.52,96.4)
TCP0_TXRX_N1: length 75.2
  TOP w0.109: v2(176.5,94.61) 176.6,94.71 arc(176.74,94.93) C5913.2
  IN1 w0.079: v2(119.76,88.14) 119.84,88.05 arc(119.95,87.98) 120.08,87.95 120.15,87.95 arc(120.24,87.97) 120.32,88.01 120.32,88.02 arc(120.42,88.12) 120.48,88.26 arc(120.49,88.33) 120.5,88.4 120.5,88.42 arc(120.6,88.96) 120.91,89.42 122.65,91.16 arc(125.52,93.08) 128.9,93.75 130.8,93.75 arc(130.97,93.72) 131.11,93.62 131.23,93.51 arc(131.35,93.42) 131.5,93.39 132.93,93.39 arc(133.34,93.47) 133.68,93.7 133.8,93.82 arc(134.21,94.09) 134.68,94.19 136.44,94.19 arc(136.68,94.23) 136.88,94.37 137.14,94.63 arc(137.46,94.84) 137.83,94.92 138.08,94.92 arc(138.58,95.02) 139.01,95.3 139.92,96.22 arc(140.2,96.4) 140.52,96.47 141.83,96.47 arc(141.99,96.5) 142.12,96.59 142.29,96.75 arc(142.54,96.92) 142.84,96.98 146.55,96.98 arc(146.78,96.94) 146.98,96.8 148.65,95.13 arc(149.26,94.73) 149.97,94.59 153.49,94.59 arc(154.05,94.7) 154.52,95.01 155.41,95.91 arc(155.68,96.09) 156,96.15 157.1,96.15 arc(157.26,96.12) 157.38,96.04 157.67,95.75 arc(157.93,95.58) 158.24,95.52 161.86,95.52 arc(161.95,95.53) 162.02,95.58 162.43,96 arc(162.56,96.08) 162.71,96.11 163.36,96.11 arc(163.51,96.08) 163.64,96 164.05,95.58 arc(164.12,95.53) 164.21,95.52 167.93,95.52 arc(168.02,95.53) 168.09,95.58 168.55,96.04 arc(168.67,96.12) 168.82,96.15 172.09,96.15 arc(172.15,96.15) 172.2,96.14 172.31,96.12 arc(172.38,96.1) 172.45,96.06 172.71,95.86 arc(172.75,95.83) 172.79,95.8 174.91,93.67 arc(175.39,92.95) 175.56,92.1 arc(175.58,92.01) 175.63,91.94 175.81,91.76 arc(175.88,91.71) 175.97,91.69 177.6,91.69 arc(177.69,91.71) 177.76,91.76 178,91.99 arc(178.07,92.11) 178.08,92.25 arc(178.07,92.39) 178,92.51 177.01,93.5 arc(176.81,93.79) 176.74,94.14 176.74,94.21 arc(176.71,94.36) 176.62,94.49 v2(176.5,94.61)
  BOTTOM w0.079: U400.AY1 118.5,86.2 arc(118.54,86.09) 118.59,86 118.75,85.8 arc(118.79,85.75) 118.82,85.69 arc(118.85,85.65) 118.87,85.61 118.87,85.61 arc(118.96,85.49) 119.1,85.44 119.15,85.44 arc(119.29,85.5) 119.35,85.65 119.35,86.38 arc(119.32,86.56) 119.24,86.71 119.22,86.74 arc(119.07,87.01) 119.02,87.32 119.02,87.57 arc(119.12,87.83) 119.38,87.96 arc(119.39,87.96) 119.41,87.96 119.51,87.96 arc(119.6,87.98) 119.67,88.02 119.76,88.11 v2(119.76,88.14)
TCP0_TXRX_N1_C: length 6.6
  TOP w0.109: v2(179.18,94.97) 179.06,94.85 arc(178.93,94.76) 178.79,94.73 178.46,94.73 arc(178.25,94.78) 178.07,94.89 177.94,95.03 arc(177.76,95.15) 177.55,95.19 C5913.1
  BOTTOM w0.079: 181.67,95.49 181.69,95.49 181.72,95.45 182.32,95.45 arc(182.37,95.46) 182.41,95.49 182.44,95.5 arc(182.47,95.52) 182.5,95.55 182.49,95.55 arc(182.55,95.59) 182.61,95.6 182.85,95.6 arc(182.98,95.58) 183.09,95.51 U5900.E2
  BOTTOM w0.109: v2(179.18,94.97) 179.36,94.79 arc(179.4,94.77) 179.44,94.76 179.92,94.76 arc(180.04,94.79) 180.15,94.86 180.58,95.29 arc(180.8,95.44) 181.07,95.49 181.67,95.49
TCP0_TXRX_P0: length 70.5
  TOP w0.109: v2(176.11,96.78) 176.11,96.78 176.31,96.59 arc(176.38,96.48) 176.41,96.35 R5952.2
  IN1 w0.079: v2(118.62,88.44) 118.47,88.59 arc(118.42,88.62) 118.35,88.64 118.35,88.64 arc(118.25,88.65) 118.17,88.71 118.16,88.72 arc(118.1,88.8) 118.08,88.9 118.08,89.61 arc(118.24,89.98) 118.61,90.13 118.71,90.13 arc(118.81,90.14) 118.9,90.16 arc(118.93,90.17) 118.97,90.2 120.5,91.73 arc(124.42,94.35) 129.06,95.27 132.87,95.27 arc(133.08,95.32) 133.27,95.43 arc(133.57,95.63) 133.93,95.7 135.85,95.7 arc(135.94,95.71) 136.01,95.76 136.45,96.2 arc(136.89,96.49) 137.41,96.59 137.97,96.59 arc(138.06,96.61) 138.13,96.66 139.36,97.89 arc(139.49,97.98) 139.64,98.01 141.17,98.01 arc(141.3,98.03) 141.41,98.11 141.57,98.27 arc(141.82,98.43) 142.12,98.49 146.99,98.49 arc(147.15,98.48) 147.31,98.43 147.48,98.35 arc(147.63,98.27) 147.76,98.17 149.7,96.23 arc(149.92,96.14) 150.15,96.11 153.09,96.11 arc(153.39,96.17) 153.64,96.34 154.39,97.09 arc(155.03,97.51) 155.78,97.66 157.77,97.66 arc(157.92,97.63) 158.05,97.55 158.36,97.24 arc(158.56,97.1) 158.81,97.05 161.12,97.05 arc(161.2,97.07) 161.28,97.12 161.7,97.54 arc(161.82,97.62) 161.97,97.65 164.19,97.65 arc(164.34,97.62) 164.47,97.54 164.89,97.12 arc(164.96,97.07) 165.05,97.05 167.28,97.05 arc(167.37,97.07) 167.44,97.12 167.87,97.55 arc(168,97.63) 168.15,97.66 172.28,97.66 arc(173.27,97.46) 174.12,96.9 174.45,96.57 arc(174.79,96.34) 175.2,96.26 176.17,96.26 arc(176.3,96.32) 176.35,96.44 176.35,96.45 arc(176.35,96.46) 176.35,96.47 176.34,96.51 arc(176.33,96.55) 176.31,96.57 v2(176.11,96.78)
  BOTTOM w0.079: v2(118.62,88.44) 118.48,88.58 arc(118.41,88.63) 118.32,88.64 arc(118.21,88.6) 118.16,88.48 118.16,87.51 arc(118.19,87.33) 118.3,87.18 118.76,86.71 arc(118.84,86.59) 118.87,86.46 118.87,86.25 arc(118.89,86.16) 118.94,86.09 118.99,86.04 arc(119.08,86.02) 119.13,86.09 U400.BB1
TCP0_TXRX_P0_C: length 7.2
  TOP w0.109: C5904.1 177.08,96.21 arc(177.3,96.25) 177.48,96.37 177.7,96.6 arc(177.74,96.63) 177.79,96.65 arc(177.85,96.67) 177.91,96.67 177.98,96.67 arc(178.08,96.65) 178.17,96.59 178.72,96.04 arc(178.89,95.93) 179.08,95.89 179.21,95.89 arc(179.32,95.87) 179.41,95.8 v2(179.52,95.7)
  BOTTOM w0.079: U5900.G1 182.86,96.32 arc(182.97,96.21) 182.86,96.11 182.52,96.11 arc(182.48,96.12) 182.44,96.14 182.38,96.2 arc(182.36,96.22) 182.33,96.22 181.39,96.22 arc(181.28,96.2) 181.19,96.14 arc(181.05,96.04) 180.89,95.99 arc(180.85,95.98) 180.81,95.98 180.75,95.98 arc(180.72,95.97) 180.7,95.95 180.69,95.95 180.67,95.95
  BOTTOM w0.109: 180.67,95.95 179.92,95.95 arc(179.77,95.92) 179.64,95.83 v2(179.52,95.7)
TCP0_TXRX_P1: length 75.2
  TOP w0.109: v2(177.15,94.63) 176.87,94.35 arc(176.82,94.27) 176.8,94.17 C5912.2
  IN1 w0.079: v2(177.15,94.63) 177.02,94.5 arc(176.94,94.37) 176.91,94.22 176.91,94.14 arc(176.96,93.86) 177.13,93.62 178.11,92.63 arc(178.23,92.45) 178.25,92.25 arc(178.23,92.05) 178.11,91.87 177.88,91.64 arc(177.75,91.55) 177.6,91.52 175.97,91.52 arc(175.82,91.55) 175.69,91.64 175.51,91.82 arc(175.43,91.95) 175.4,92.1 arc(175.23,92.88) 174.79,93.55 172.67,95.68 arc(172.64,95.7) 172.61,95.73 172.35,95.93 arc(172.31,95.95) 172.28,95.96 172.17,95.98 172.17,95.98 arc(172.13,95.98) 172.09,95.98 168.82,95.98 arc(168.74,95.97) 168.66,95.92 168.21,95.46 arc(168.08,95.38) 167.93,95.35 164.21,95.35 arc(164.06,95.38) 163.93,95.46 163.52,95.88 arc(163.45,95.93) 163.36,95.94 162.71,95.94 arc(162.63,95.93) 162.55,95.88 162.14,95.46 arc(162.01,95.38) 161.86,95.35 158.23,95.35 arc(157.86,95.42) 157.55,95.63 157.26,95.92 arc(157.19,95.97) 157.1,95.98 156,95.98 arc(155.75,95.93) 155.53,95.79 154.63,94.89 arc(154.11,94.54) 153.49,94.42 149.97,94.42 arc(149.19,94.57) 148.53,95.02 146.86,96.68 arc(146.72,96.78) 146.55,96.82 142.84,96.82 arc(142.61,96.77) 142.4,96.63 142.24,96.47 arc(142.05,96.34) 141.83,96.3 140.52,96.3 arc(140.26,96.25) 140.04,96.1 139.12,95.18 arc(138.65,94.86) 138.08,94.75 137.83,94.75 arc(137.52,94.69) 137.26,94.51 137,94.25 arc(136.74,94.08) 136.44,94.02 134.68,94.02 arc(134.27,93.94) 133.92,93.7 133.8,93.58 arc(133.4,93.32) 132.93,93.23 131.5,93.23 arc(131.29,93.27) 131.11,93.39 130.99,93.5 arc(130.9,93.56) 130.8,93.58 128.9,93.58 arc(125.58,92.92) 122.76,91.04 121.03,89.3 arc(120.76,88.9) 120.66,88.42 120.66,88.4 arc(120.66,88.31) 120.64,88.21 arc(120.56,88.03) 120.43,87.89 120.42,87.88 arc(120.3,87.81) 120.15,87.78 120.03,87.78 arc(119.99,87.78) 119.96,87.76 v2(119.76,87.55)
  BOTTOM w0.079: v2(119.76,87.55) 119.59,87.72 arc(119.51,87.78) 119.41,87.8 arc(119.4,87.8) 119.39,87.8 arc(119.39,87.8) 119.39,87.8 arc(119.24,87.73) 119.18,87.57 119.18,87.32 arc(119.22,87.06) 119.34,86.83 119.36,86.81 arc(119.47,86.61) 119.51,86.38 119.51,85.65 arc(119.4,85.39) 119.15,85.29 119.1,85.29 arc(118.87,85.36) 118.72,85.56 arc(118.71,85.57) 118.71,85.58 118.7,85.58 arc(118.69,85.59) 118.68,85.61 118.63,85.65 arc(118.62,85.66) 118.61,85.67 118.59,85.68 arc(118.54,85.7) U400.AY2
TCP0_TXRX_P1_C: length 6.6
  TOP w0.109: C5912.1 177.56,94.05 arc(177.77,94.09) 177.95,94.21 178.1,94.35 arc(178.27,94.47) 178.48,94.51 178.79,94.51 arc(178.93,94.48) 179.06,94.4 v2(179.18,94.27)
  BOTTOM w0.079: 181.67,95.27 181.69,95.27 181.69,95.26 181.72,95.3 182.32,95.3 arc(182.4,95.28) 182.46,95.23 182.47,95.22 arc(182.51,95.2) 182.56,95.19 182.84,95.19 arc(182.94,95.29) 182.84,95.4 U5900.E1
  BOTTOM w0.109: 181.67,95.27 181.07,95.27 arc(180.89,95.23) 180.74,95.13 180.31,94.7 arc(180.13,94.58) 179.92,94.54 179.63,94.54 arc(179.46,94.51) 179.33,94.41 v2(179.18,94.27)
TCP1_AUX_CTRL: length 5.3
  IN3 w0.089: v2(194.77,92.34) 194.77,91.72 193.67,90.62 v2(193.67,90.12)
  BOTTOM w0.109: v2(193.67,90.12) v1(193.67,89.56) 193.67,88.95 193.41,88.68 U6100.12 ; v2(194.77,92.34) 194.77,92.72 R6125.2
TCP1_AUX_CTRL_R: length 2.5
  BOTTOM w0.109: U6101.6 195.82,94.51 195.81,94.53 R6124.1 194.49,94.32 R6125.1
TCP1_AUX_DN_C: length 3
  TOP w0.109: v1(196.45,95.48) 196.45,96.01 R6117.1
  BOTTOM w0.109: R6117.1 196.37,96.19 196.69,95.87 196.69,95.72 v1(196.45,95.48) 196.72,95.21 196.72,95.02 196.55,94.85 U6101.7
TCP1_AUX_DP_C: length 3
  TOP w0.109: v1(197.15,95.48) 197.15,96.01 R6119.1
  BOTTOM w0.109: C6110.1 197.23,96.19 196.91,95.87 196.91,95.72 v1(197.15,95.48) 196.95,95.29 196.95,94.92 197.05,94.81 U6101.8
TCP01_FLASH_BUSY#: length 2.9
  BOTTOM w0.079: U5900.A9 186.42,93.42 186.64,93.2 186.64,92.89 186.84,92.68 186.84,92.59
  BOTTOM w0.109: R5938.2 187.57,91.52 187.28,91.81 187.01,91.81 186.74,92.07 186.74,92.3 186.84,92.55 186.84,92.59
TCP1_RESET#_R: length 1.8
  BOTTOM w0.109: CON7701.14 167.85,82.58 168.11,82.84 TP7705.1
TCP_RETIMER_PERST#: length 79.9
  IN1 w0.079: v1(161.15,71.55) 161.39,71.31 162.82,71.31 163.38,70.75 165.44,70.75 165.89,71.2 v1(167.52,71.2)
  IN2 w0.089: v1(166.7,102.79) 165.28,102.79 164.68,102.2 164.68,95.08 163.38,93.77 163.38,88.66 165.2,86.84 165.2,84.07 165.63,83.64 165.63,81.67 167.09,80.21 167.09,74.5 167.57,74.02 167.57,73.13 166.67,72.24 166.67,71.83 167.3,71.2 v1(167.52,71.2)
  IN3 w0.089: v2(186.23,93.12) 186.23,93.12 186.24,93.11 186.24,93.05 185.2,92.01 184.09,92.01 183.36,91.29 183.36,90.1 183.05,89.79 181.69,89.79 181.44,90.04 180.85,90.04 180.61,90.27 180.61,90.82 179.93,91.51 179.93,92.88 179.35,93.45 178.11,93.45 177.82,93.74 173.28,93.74 171.63,95.4 171.63,97.28 167.46,101.45 167.46,102.56 167.23,102.79 v1(166.7,102.79)
  BOTTOM w0.109: U5900.B8 186.18,93.79 186.18,93.16 v2(186.23,93.12) ; R1550.1 161.15,71.27 v1(161.15,71.55) 161.16,71.56 R1562.1 161.07,72.11 160.78,72.4 160.78,72.54 160.12,73.2 159.84,73.2 U1502.4 158.72,73.88 R1572.1
TCRCOMP_DN: length 3.7
  BOTTOM w0.079: 115.03,89.31 115.03,86.56 U400.AN1
  BOTTOM w0.109: R400.2 114.71,89.76 115.03,89.43 115.03,89.31
TCRCOMP_DP: length 3.9
  BOTTOM w0.079: U400.AN2 115.23,85.81 114.86,86.18 114.86,89.03 R400.1
TESTMODE: length 7.8
  BOTTOM w0.109: v1(69.87,62.51) 69.73,62.65 R6616.1 69.73,65.84 70.89,67 71.45,67 71.6,67.16 71.6,68.64 U6600.AD9
THERM+: length 15.5
  TOP w0.109: TP6904.1 63.57,91.13 63.65,91.13 65.43,89.35 66.62,89.35 67,89.73 67.76,89.73 70.31,87.18 70.31,85.85 70.05,85.6 69.64,85.6 69.5,85.45 69.5,85.01 69.28,84.8 68.95,84.8 68.72,84.56 68.72,83.95 v2(69.11,83.56)
  BOTTOM w0.109: U6600.F12 69.48,83.93 v2(69.11,83.56)
THERM-: length 13
  TOP w0.109: v2(69.9,85.2) 69.99,85.2 70.53,85.75 70.53,87.3 70.43,87.4 70.43,88.89 69.07,90.25 65.73,90.25 65.53,90.46 64.88,90.46 63.83,91.51 TP6903.1
  BOTTOM w0.109: v2(69.9,85.2) 69.5,84.8 U6600.E12
THERM_SCI#: length 196.6
  TOP w0.109: R625.1 151.81,82.16 v2(151.32,82.16)
  IN2 w0.089: v1(159.86,53.94) 159.58,53.94 158.98,54.54 158.98,55.04 159.5,55.57 159.5,56.27 158.88,56.89 158.88,57.81 159.11,58.04 159.11,61.63 158.23,62.5 158.23,64.2 157.95,64.48 157.95,65.09 157.81,65.44 156.55,66.7 156.49,66.85 156.49,67.65 156.11,68.03 156.11,69.55 157.97,71.42 157.97,72.04 158.67,72.74 158.67,74.21 157.94,74.93 157.94,76.11 158.45,76.61 158.45,80.45 155.91,82.98 152.03,82.98 151.59,82.53 151.59,82.43 v2(151.32,82.16) 151.09,82.39 151.09,82.46 149.58,83.96 147.94,83.96 147.85,84.05 145.2,84.05 144.83,84.43 143.66,84.43 143.63,84.4 v2(143.63,84.4) ; v1(88.06,79.4) 87.78,79.12 87.78,78.75 85.24,76.22 85.24,73.28 79.52,67.55 79.52,65.46 77.41,63.35 72.97,63.35 71.12,61.49 71.12,57.94 64.91,51.74 v1(64.91,51.45)
  BOTTOM w0.079: v2(143.63,84.4) 143.63,84.4 143.67,84.44 U400.DU5
  BOTTOM w0.109: U5400.6 89.4,78.49 88.57,79.32 88.14,79.32 v1(88.06,79.4) ; v1(64.91,51.45) 65.75,50.61 73.93,50.61 75.86,52.54 77.55,52.54 77.78,52.31 102.1,52.31 109.24,45.18 114.93,45.18 119,49.25 149.29,49.25 149.91,48.63 150.63,48.63 150.88,48.88 150.88,49.28 151.64,50.04 152.31,50.04 153.83,51.57 157.74,51.57 158.31,51 158.58,51 158.68,51.1 158.82,51.19 158.98,51.26 159.08,51.36 159.08,52.73 159.86,53.51 v1(159.86,53.94)
THERM_SCL: length 286.5
  IN1 w0.079: v1(22.06,54.41) 23.04,55.39 23.77,55.39 28.48,60.09 34.86,60.09 40.67,54.28 41.62,54.28 42.49,55.15 47.13,55.15 48.23,56.26 50.73,56.26 51.69,55.3 57.9,55.3 58.64,54.56 61.83,54.56 v1(61.92,54.48)
  IN3 w0.089: v1(22.06,54.41) 23.29,53.19 23.29,46.2 21.74,44.65 21.74,35.66 21.38,35.3 21.38,31.3 22.43,30.25 22.43,29.16 23.32,28.27 24.25,28.27 25.83,26.69 25.83,24.02 26.52,23.33 26.52,22.02 28.43,20.12 31.88,20.12 35.08,16.92 47.08,16.92 48.86,15.14 53.94,15.14 54.23,14.85 58.2,14.85 59.05,14 61.95,14 62.83,14.88 67.49,14.88 67.78,14.58 69.5,14.58 71.79,16.87 78.23,16.87 79.09,16.01 81.13,16.01 82.37,17.26 83.19,17.26 84.48,18.54 86.89,18.54 89.21,16.22 92.52,16.22 93.27,16.96 93.27,18.77 93.95,19.44 96.83,19.44 96.93,19.34 105.02,19.34 105.11,19.43 110.33,19.43 111.6,20.71 113.04,20.71 113.84,21.5 115.49,21.5 116.6,20.4 119.76,20.4 120.43,19.72 142.32,19.72 142.35,19.7 156.96,19.7 158.09,18.57 v2(158.09,18.01)
  BOTTOM w0.109: v1(61.92,54.48) 61.92,54.3 62.44,53.77 73.71,53.77 75.91,55.97 82.77,55.97 84.35,57.55 84.35,57.86 84.94,58.44 86.54,58.44 87.65,59.56 87.65,63.13 87.98,63.46 87.98,65.59 87.39,66.18 87.39,67.86 86.98,68.28 86.98,68.85 87.66,69.53 90.26,69.53 90.83,70.11 90.83,71.15 90.99,71.3 Q5404.1 91.62,71.3 91.85,71.53 R5418.2 92.55,71.72 91.28,73 91.28,79.27 90.76,79.79 U5400.8 ; v2(158.09,18.01) 158.09,17.57 160.31,15.35 U5403.8

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_LANP_R: length 4.4
  TOP w0.109: R7618.1 11.84,17.63 12.19,17.63 12.35,17.78 12.35,18.6 12.1,18.85 11.47,18.85 11.22,18.6 11.22,18.21 10.85,17.83 10.67,17.83 10.52,17.68 CON7602.19
CLK_PCIE_SSDN: length 181.8
  IN1 w0.079: v2(133.52,82.76) 133.31,82.98 133.07,82.98 132.93,83.12 132.93,84.43 132.8,84.56 132.8,85.44 133.43,86.07 133.74,86.07 134.02,86.35 134.02,87.37 132.93,88.46 132.93,88.88 132.55,89.26 127.84,89.26 127.68,89.42 127.38,89.42 127.12,89.17 127.12,86.45 126.64,85.96 125.89,85.96 125.52,86.33 124.44,86.33 122.15,84.04 122.15,82.37 121.62,81.85 121.47,81.85 121.23,81.61 121.23,80.46 119.97,79.19 111.28,79.19 110.12,80.35 110.12,80.49 109.86,80.75 109.4,80.75 109.15,81.01 109.15,82.28 108.24,83.19 108.24,85.12 107.83,85.53 104.87,85.53 104.12,85.21 102.11,85.21 100.77,83.87 98.6,83.87 96.98,82.24 96.42,82.24 95.42,81.24 94.33,81.24 93.71,80.62 91.4,80.62 89.03,78.26 88.31,78.26 85.73,75.67 85.73,75.43 82.53,72.23 82.53,71.96 80.82,70.25 80.82,69.33 78.91,67.42 77.95,67.42 77.36,66.82 77.36,65.26 75.74,63.65 74.42,63.65 72.34,61.57 72.34,56.83 59.54,44.04 55.23,44.04 52.3,41.11 51.79,41.11 49.25,38.57 45.58,38.57 44.73,37.71 43.17,37.71 42.6,38.29 36.66,38.29 36.34,38.61 31.78,38.61 31.46,38.29 28.82,38.29 27.57,37.03 26.09,37.03 25.7,36.64 25.7,36.11 24.66,35.07 24.66,31.84 20.85,28.03 20.85,27.85 19.17,26.18 19.17,23.28 17.18,21.29 17.18,19.98 16.84,19.63 16.67,19.63 v1(16.39,19.36)
  BOTTOM w0.109: CON4300.53 14.2,15.25 14.35,15.4 14.92,15.4 15.29,15.77 15.29,18.53 15.52,18.76 15.52,19.41 15.74,19.63 16.11,19.63 v1(16.39,19.36) ; v2(133.52,82.76) 133.24,83.04 U400.CN8
CLK_PCIE_SSDP: length 181.9
  IN1 w0.079: v1(16.39,20.12) 16.71,19.8 16.77,19.8 17.02,20.05 17.02,21.36 19.01,23.35 19.01,26.25 20.68,27.92 20.68,28.1 24.49,31.91 24.49,35.14 25.54,36.18 25.54,36.71 26.02,37.2 27.5,37.2 28.75,38.45 31.39,38.45 31.71,38.77 36.41,38.77 36.73,38.45 42.67,38.45 43.24,37.88 44.66,37.88 45.51,38.73 49.18,38.73 51.72,41.27 52.23,41.27 55.16,44.21 59.47,44.21 72.17,56.9 72.17,61.64 74.35,63.81 75.67,63.81 77.19,65.33 77.19,66.89 77.89,67.59 78.84,67.59 80.65,69.4 80.65,70.32 82.36,72.02 82.36,72.3 85.56,75.5 85.56,75.74 88.24,78.42 88.96,78.42 91.33,80.79 93.64,80.79 94.26,81.4 95.35,81.4 96.35,82.41 96.91,82.41 98.53,84.04 100.7,84.04 102.04,85.38 104.09,85.38 104.84,85.69 107.9,85.69 108.41,85.19 108.41,83.26 109.31,82.35 109.31,81.08 109.47,80.92 109.93,80.92 110.29,80.56 110.29,80.42 111.34,79.36 119.9,79.36 121.06,80.53 121.06,81.68 121.4,82.01 121.55,82.01 121.98,82.44 121.98,84.11 124.37,86.5 125.59,86.5 125.96,86.13 126.57,86.13 126.96,86.52 126.96,89.24 127.31,89.59 127.75,89.59 127.91,89.43 132.62,89.43 133.1,88.95 133.1,88.53 134.19,87.44 134.19,86.28 133.81,85.9 133.5,85.9 132.97,85.37 132.97,84.63 133.09,84.5 133.09,83.19 133.14,83.15 133.34,83.15 v2(133.55,83.36)
  BOTTOM w0.109: U400.CN7 133.21,83.69 v2(133.55,83.36) ; v1(16.39,20.12) 16.13,19.86 15.65,19.86 15.29,19.5 15.29,18.85 15.07,18.63 15.07,15.86 14.83,15.62 14.35,15.62 14.22,15.75 CON4300.55
CLK_PCIE_WLANN: length 80
  IN3 w0.089: v2(126.35,87.03) 126.54,87.21 126.74,87.21 127.12,87.59 127.12,89.18 127.96,90.02 129.39,90.02 129.91,89.49 129.91,87.21 130.94,86.17 132.04,86.17 132.7,85.51 134.82,85.51 135.43,84.89 135.43,84.76 135.89,84.3 136.92,84.3 137.08,84.45 137.49,84.45 138.28,83.66 140.62,83.66 140.79,83.48 140.79,83.1 141.15,82.75 141.68,82.75 141.71,82.78 142.26,82.78 142.79,82.25 143.84,82.25 144.18,81.91 148.17,81.91 149.46,80.62 150.86,80.62 151.51,79.97 157.62,79.97 159.68,77.91 160.98,77.91 161.69,77.2 162,77.2 162.35,76.85 162.85,76.85 163.08,76.62 163.08,76.21 164.16,75.13 164.16,74.07 165.57,72.66 165.57,72.33 167.67,70.23 168.11,70.23 169.12,69.21 169.12,68.51 169.9,67.73 170.8,67.73 v1(171,67.53)
  BOTTOM w0.079: U400.BW5 126.99,84.67 126.67,85 126.6,85.16 126.6,87.07 126.53,87.14 126.47,87.14 v2(126.35,87.03)
  BOTTOM w0.109: CON4100.49 184.59,71.03 182.93,69.36 182.28,69.36 182.11,69.19 181.56,69.19 181.23,68.85 181.23,68.18 180.76,67.71 180.33,67.71 179.39,66.78 176.75,66.78 v1(176.19,66.21) 175.62,66.78 175.08,66.78 174.13,67.73 171.19,67.73 v1(171,67.53)
CLK_PCIE_WLANP: length 79.9
  IN3 w0.089: v2(126.17,87.57) 126.35,87.4 126.67,87.4 126.93,87.67 126.93,89.26 127.88,90.21 129.46,90.21 130.1,89.57 130.1,87.28 131.02,86.36 132.12,86.36 132.78,85.7 134.9,85.7 135.62,84.97 135.62,84.84 135.97,84.49 136.84,84.49 137,84.64 137.57,84.64 138.36,83.85 140.7,83.85 140.98,83.56 140.98,83.18 141.22,82.94 141.6,82.94 141.63,82.97 142.34,82.97 142.87,82.44 143.92,82.44 144.26,82.1 148.25,82.1 149.54,80.81 150.93,80.81 151.59,80.16 157.7,80.16 159.75,78.1 161.06,78.1 161.77,77.39 162.08,77.39 162.42,77.04 162.93,77.04 163.27,76.7 163.27,76.29 164.35,75.21 164.35,74.15 165.76,72.74 165.76,72.41 167.75,70.42 168.19,70.42 169.31,69.29 169.31,68.59 169.98,67.92 170.86,67.92 171,68.05 v1(171,68.29)
  BOTTOM w0.079: U400.BW4 126.99,85.06 126.83,85.06 126.8,85.09 126.76,85.2 126.76,87.13 126.32,87.57 v2(126.17,87.57)
  BOTTOM w0.109: v1(171,68.29) 171,68.06 171.1,67.96 171.19,67.96 171.19,67.95 174.23,67.95 175.18,67 175.71,67 v1(176.19,67.48) 176.67,67 179.3,67 180.24,67.94 180.67,67.94 181,68.27 181,68.94 181.47,69.41 182.02,69.41 182.19,69.59 182.83,69.59 184.09,70.84 CON4100.47
CLK_PCIE_WWANN: length 157.4
  IN3 w0.089: v1(189.92,10.4) 189.85,10.46 189.72,10.46 189.56,10.3 189.56,10.11 189.86,9.8 190.69,9.8 191.83,10.95 193.13,10.95 193.22,11.04 197.26,11.04 197.75,11.53 201.57,11.53 202.81,12.76 206.97,12.76 207.62,13.42 207.62,16.11 205.48,18.25 205.48,19.61 205.45,19.65 205.45,20.14 202.37,23.21 202.37,23.41 201.18,24.61 200.97,24.61 200.67,24.92 200.17,24.92 198.04,27.05 196.47,27.05 196.21,27.3 194.02,27.3 192.54,28.78 191.93,28.78 188.45,32.27 188.45,33.51 187.73,34.23 187.73,36.29 187.24,36.78 187.24,37.64 187.76,38.16 187.76,40.33 185.96,42.12 185.96,45.25 185.76,45.46 185.76,46.17 185.08,46.86 185.08,47.81 184.53,48.35 184.53,51.19 182.66,53.06 182.66,54.17 181.87,54.96 181.87,55.77 181.28,56.37 181.28,58.78 180.77,59.29 180.77,59.84 179.54,61.07 177.33,61.07 176.86,60.61 175.79,60.61 174.46,61.93 174.17,61.93 172.7,63.4 171.69,64.41 171.69,65.44 170.26,66.87 169.94,66.87 167.46,69.35 167.46,69.61 166.35,70.72 165.4,70.72 164.73,71.39 164.73,71.94 163.08,73.59 163.08,74.23 163.07,74.24 162.44,74.87 162.44,75.76 161.79,76.41 160.35,76.41 157.5,79.26 154.8,79.26 154.16,78.62 150.36,78.62 150.36,78.62 148.59,80.39 146.92,80.39 146.52,80.79 143.33,80.79 142.29,81.84 137.89,81.84 137.4,81.34 136.23,81.34 134.94,82.63 134.94,84.31 134.85,84.53 134.28,85.1 131.63,85.1 131.27,85.47 130.74,85.47 129.02,87.18 128.56,87.18 arc(128.35,87.23) 128.17,87.34 127.95,87.56 127.95,88.03 127.82,88.16 127.61,88.16 127.52,88.07 v2(127.52,87.85)
  BOTTOM w0.079: U400.BY3 127.53,85.37 127.4,85.37 127.38,85.38 127.38,86.62 127.15,86.85 127.15,88.05 127.27,88.18 127.82,88.18 127.88,88.12 127.88,87.8 127.78,87.7 127.58,87.7 127.52,87.77 v2(127.52,87.85)
  BOTTOM w0.109: CON4202.53 189.41,9.9 189.54,10.19 189.75,10.4 v1(189.92,10.4)
CLK_PCIE_WWANP: length 157.5
  IN3 w0.089: v1(189.18,10.4) 189.37,10.22 189.37,10.03 189.78,9.61 190.76,9.61 191.91,10.76 193.2,10.76 193.3,10.85 197.34,10.85 197.82,11.34 201.65,11.34 202.89,12.57 207.05,12.57 207.81,13.34 207.81,16.19 205.67,18.33 205.67,19.69 205.64,19.73 205.64,20.22 202.56,23.29 202.56,23.49 201.25,24.8 201.05,24.8 200.75,25.11 200.25,25.11 198.12,27.24 196.55,27.24 196.29,27.49 194.1,27.49 192.62,28.97 192.01,28.97 188.64,32.35 188.64,33.59 187.92,34.31 187.92,36.37 187.43,36.86 187.43,37.56 187.95,38.08 187.95,40.41 186.15,42.2 186.15,45.33 185.95,45.53 185.95,46.25 185.27,46.94 185.27,47.89 184.72,48.43 184.72,51.27 182.85,53.14 182.85,54.25 182.07,55.04 182.07,55.85 181.47,56.45 181.47,58.86 180.96,59.37 180.96,59.92 179.62,61.26 177.25,61.26 176.78,60.8 175.86,60.8 174.54,62.12 174.25,62.12 172.78,63.59 172.78,63.59 171.88,64.49 171.88,65.52 170.34,67.06 170.02,67.06 167.65,69.43 167.65,69.69 166.42,70.91 165.48,70.91 164.92,71.47 164.92,72.02 163.27,73.67 163.27,74.32 162.63,74.95 162.63,75.84 161.87,76.6 160.43,76.6 157.58,79.45 154.72,79.45 154.08,78.81 150.43,78.81 148.67,80.58 147,80.58 146.6,80.98 143.41,80.98 142.37,82.03 137.82,82.03 137.32,81.53 136.31,81.53 135.13,82.71 135.13,84.35 135.01,84.64 134.36,85.29 131.71,85.29 131.35,85.66 130.82,85.66 129.1,87.37 128.56,87.37 arc(128.42,87.4) 128.31,87.48 128.14,87.64 128.14,88.11 127.9,88.35 127.68,88.35 v2(127.51,88.51)
  BOTTOM w0.079: v2(127.51,88.51) 127.34,88.34 127.21,88.34 126.99,88.12 126.99,86.79 127.23,86.55 127.23,85.32 127.56,84.99 U400.BY4
  BOTTOM w0.109: CON4202.55 188.92,9.77 189.27,10.12 189.28,10.15 189.28,10.3 v1(189.18,10.4)
CLKREQ_C1: length 4.4
  BOTTOM w0.109: R6615.1 81.22,63.28 Q6600.2 83.42,62.95 Q6601.3
CNV_BRI_DT: length 65.6
  TOP w0.109: v2(135.2,75.11) 135.2,75.51 135.05,75.66 135.05,77.26 135.62,77.83 R1410.2
  IN1 w0.079: v2(153.13,73.63) 153.46,73.3 154.48,73.3 154.78,73.01 157.29,73.01 157.51,73.23 160.36,73.23 161,72.59 162.39,72.59 162.67,72.87 163.87,72.87 164.26,73.27 167.58,73.27 167.94,73.63 172.01,73.63 173.6,72.04 176.17,72.04 176.85,72.72 177.45,73.32 178.27,73.32 178.74,73.78 v1(178.74,74.19)
  IN3 w0.089: v2(153.13,73.63) 152.7,74.06 152.7,74.6 152.42,74.88 151.81,74.88 151.29,75.41 146.69,75.41 146.15,75.94 144.41,75.94 144.03,75.56 138.5,75.56 138.2,75.87 135.96,75.87 v2(135.2,75.11)
  BOTTOM w0.109: CON4100.36 181.34,80.07 180.87,80.54 180.87,81.63 180.47,82.04 R4144.2 180.24,82.34 179.98,82.6 179.09,82.6 178.81,82.31 178.81,78.4 177.75,77.34 177.75,76.38 178.74,75.38 v1(178.74,74.19)
CNV_BRI_DT_R: length 4
  TOP w0.109: v2(137.89,78.73) 137.36,78.73 R1241.2 137.16,78.81 136.71,78.36 R1243.2 136.47,78.28 R1410.1
  BOTTOM w0.079: v2(137.89,78.73) 137.89,79 138.03,79.32 138.08,79.37 138.13,79.42 138.33,79.5 138.62,79.5 U400.DF17
CNV_BRI_RSP: length 48.1
  TOP w0.109: v2(153.49,79.6) 153.49,80.14 R1400.2
  IN1 w0.079: v2(139.27,79.79) 139.7,80.22 142.17,80.22 142.56,80.61 144.54,80.61 144.99,81.06 147.93,81.06 147.94,81.07 150.9,81.07 151.62,80.35 152.74,80.35 v2(153.49,79.6) 154.36,80.47 156.99,80.47 157.12,80.34 162.63,80.34 163.34,79.63 164.73,79.63 165.29,79.07 166.84,79.07 167.4,79.63 168.62,79.63 169.54,78.71 176.15,78.71 176.83,78.03 v1(177.82,78.03)
  BOTTOM w0.109: v2(139.27,79.79) 138.96,80.11 U400.DF15 ; v1(177.82,78.03) 177.82,78.18 178.39,78.75 178.39,81.88 178.13,82.14 v1(177.85,82.14) R4126.1
CNV_BRI_RSP_R: length 1.7
  BOTTOM w0.109: R4126.2 177.85,80.69 177.84,80.68 CON4100.22
CNV_RF_RESET#: length 45
  TOP w0.109: v1(168.93,81.61) 168.82,81.5 166.19,81.5 165.88,81.81 v1(165.68,81.81) 165.45,81.81 164.74,82.52 160.92,82.52 160.53,82.13 157.99,82.13 156.73,83.38 154.67,83.38 154.04,84.02 153.57,84.02 153.51,83.96 150.99,83.96 150.67,84.28 150.45,84.28 147.62,87.1 147.62,87.86 147.21,88.27 v1(146.63,88.27) 146.63,87.22 144.96,85.55 142.74,85.55 141.02,83.83 141.02,82.42 v2(140.99,82.4)
  BOTTOM w0.109: U400.DK10 140.99,82.06 v2(140.99,82.4) ; R4153.2 173.82,81.5 172.2,81.5 171.35,82.34 169.6,82.34 168.96,81.71 168.96,81.63 v1(168.93,81.61) ; v1(146.63,88.27) 147.3,88.27 148.05,89.02 R1412.1
CNV_RF_RESET#_L: length 1.8
  BOTTOM w0.109: R4153.1 174.64,80.54 174.84,80.35 CON4100.10
CNV_RGI_DT: length 39.3
  TOP w0.109: v1(179.79,74.34) 179.08,73.64 178.68,73.64 178.08,74.24 177.16,74.24 176.15,75.25 175.52,75.51 174.77,75.51 174.36,75.92 v1(173.51,75.92) 169.77,75.92 168.79,76.9 168.79,78.53 166.68,80.65 164.61,80.65 163.59,81.67 161.27,81.67 160.88,81.28 156.93,81.28 156.48,80.82 156.19,80.82 R1409.2
  BOTTOM w0.109: v1(179.79,74.34) 179.63,74.49 179.63,80.96 R4141.1 180.08,80.66 180.08,80.37 180.34,80.11 CON4100.32
CNV_RGI_DT_R: length 17.7
  TOP w0.109: v2(152.07,78.1) 152.37,78.41 152.62,78.41 152.97,78.76 R1222.1 153.02,78.91 R1225.1 153.61,78.89 R1409.1
  IN2 w0.089: v2(139.81,80.58) 140.28,80.11 142.36,80.11 142.75,80.49 144.27,80.49 144.83,81.05 148.61,81.05 149.83,79.82 149.83,79.68 151.41,78.1 v2(152.07,78.1)
  BOTTOM w0.109: U400.DG13 139.81,80.79 v2(139.81,80.58)
CNV_RGI_RSP: length 50.7
  TOP w0.109: v2(152.94,79.58) 152.96,79.59 152.96,80.14 R1401.2
  IN1 w0.079: v2(139.89,79.76) 140.17,80.04 144.53,80.04 145.17,80.67 150.74,80.67 151.45,79.96 152.58,79.96 152.94,79.59 v2(152.94,79.58) 152.96,79.58 153.33,79.21 154.18,79.21 155.06,80.08 156.83,80.08 157.09,79.82 159.64,79.82 160.36,79.1 164.71,79.1 165.13,78.69 167,78.69 167.56,79.25 168.41,79.25 169.33,78.33 175.95,78.33 176.65,77.62 177.87,77.62 v1(178.26,77.24)
  BOTTOM w0.079: v2(139.89,79.76) 139.89,80.15 140.22,80.49 U400.DJ13
  BOTTOM w0.109: v1(178.26,77.24) 179.22,78.2 179.22,82.19 179.4,82.37 179.88,82.37 180.16,82.09 180.16,81.81 R4127.1
CNV_RGI_RSP_R: length 1.8
  BOTTOM w0.109: CON4100.34 180.84,80.09 180.46,80.46 R4127.2
CNV_WT_RCOMP: length 8.6
  BOTTOM w0.109: R1405.1 147.28,59.44 145.55,61.16 142.52,61.16 141.84,61.85 141.84,62.54 141.69,62.68 141.69,63.1 142,63.4 U400.DN51
CPPWR_EN: length 96.1
  TOP w0.076: U4700.E9 v2(194.14,19.59)
  TOP w0.109: v1(201.21,85.16) 200.67,85.16 199.92,84.42 U6203.8
  IN1 w0.079: v1(201.21,85.16) 199.26,83.21 199.26,80.08 200.1,79.25 200.1,78.18 199.82,77.9 199.82,73.25 201.32,71.75 201.32,71.14 200.93,70.75 200.93,69.13 201.31,68.74 201.31,64.08 202.18,63.21 202.18,60.45 202.89,59.74 202.89,54.38 202.46,53.95 202.23,53.95 197.3,49.01 194.11,49.01 v1(193.33,49.79)
  IN2 w0.076: v2(194.14,19.59) 193.77,19.96 193.77,20.55 193.88,20.65 193.88,21.03 193.62,21.28 193.29,21.28 193.14,21.44 192.35,21.44 192,21.08
  IN2 w0.089: v1(179.69,36.84) 179.88,36.65 179.88,35.42 180.36,34.95 180.46,34.85 181.06,34.85 181.71,34.19 181.71,33.54 184.39,30.86 184.39,29.67 185.75,26.37 186.95,25.17 187.55,25.17 187.73,24.99 188.1,24.84 188.7,24.24 188.7,23.79 190.37,22.11 190.37,21.49 190.78,21.08 192,21.08
  BOTTOM w0.109: v1(193.33,49.79) 193.23,49.79 192.15,48.71 192.15,47.5 191.74,47.08 190.44,47.08 189.3,45.95 189.3,45.62 188.77,45.08 187.74,45.08 185.75,43.09 185.75,42.55 185.27,42.08 184.73,42.08 183.93,41.27 181.65,41.27 181.27,40.9 181.27,39.88 180.46,39.07 180.46,38.6 179.69,37.82 v1(179.69,36.84)
CPU_C10_GATE#: length 114.3
  TOP w0.109: v2(136.12,93.67) 136.12,93.52 135.89,93.29 135.33,93.29 135.15,93.47 PR10613.1 ; v1(158.95,84.66) 158.95,85.32 159.27,85.64 159.62,85.64 160.13,86.16 160.71,86.16 160.83,86.27 PU10605.1 160.83,87.62 160.49,87.96 159.5,87.96 159.01,88.45 v1(159.01,89.76) 159.01,90.8 158.26,91.55 158.26,92.31 156.36,94.21 v1(156.36,94.59) 156.29,94.66 150.86,94.66 150.59,94.93 149.28,94.93 148.5,95.7 147.54,95.7 147.08,96.16 147.08,97.67 146.73,98.02 145.21,98.02 144.98,98.24 144.98,98.37 144.64,98.72 PD9603.1 ; R1507.1 152.52,72.1 152.28,71.87 151.52,71.87 v2(151.41,71.98)
  IN1 w0.079: v1(160.52,71.52) 160.22,71.52 159.61,72.13 158.85,72.13 158.55,71.84 157.07,71.84 156.58,71.35 152.04,71.35 v2(151.41,71.98) 151,71.98 150.86,72.12 150.6,72.12 148.98,73.74 146.68,73.74 v2(146.46,73.96) ; v1(132.34,100.18) 132.71,100.55 133.92,100.55 134.34,100.98 134.34,102.42 v1(135.28,103.35)
  IN2 w0.089: v1(156.36,94.59) 156.07,94.3 150.22,94.3 147.78,96.74 147.78,99.26 146.91,100.13 146.91,100.58 146.43,101.06 145.13,101.06 143.84,102.36 137.62,102.36 136.62,103.35 v1(135.28,103.35) ; v1(158.95,84.66) 159.61,84 159.61,82.55 160.76,81.39 160.76,78.34 161.41,77.69 161.95,77.69 162.27,77.37 162.27,73.82 161.15,72.71 161.15,72.4 160.52,71.77 v1(160.52,71.52) ; v2(136.12,93.67) 136.12,94.46 134.13,96.45 134.13,97.38 132.26,99.25 132.26,99.6 132.26,100.1 v1(132.34,100.18)
  BOTTOM w0.079: v2(146.46,73.96) 146.46,73.85 146.06,73.44 145.62,73.44 144.82,74.24 144.45,74.24 144.33,74.36 142.84,74.36 142.54,74.65 U400.DN27
  BOTTOM w0.109: R1576.1 154.89,74.14 153.74,73 151.76,73 151.53,72.77 151.53,72.11 v2(151.41,71.98)
CPU_EAR: length 23.1
  IN1 w0.079: v1(90.7,84.49) 91.76,85.55 94.11,85.55 98.09,89.54 102.44,89.54 v1(102.48,89.57)
  BOTTOM w0.109: v1(90.7,84.49) 90.72,84.49 v1(91.33,83.88) 92.12,83.08 92.73,83.08 92.88,82.93 R621.1 ; U400.G1 103.6,86.4 103.45,86.75 103.45,87.04 103.63,87.22 103.63,87.61 101.82,89.42 101.82,90.07 R624.2 102.16,89.85 102.45,89.56 102.47,89.56 102.48,89.57 v1(102.48,89.57)
CPU_EDP_HPD: length 203.8
  IN2 w0.089: v1(164.18,44.59) 163.93,44.84 163.93,45.99 163.05,46.87 163.05,47.67 162.09,48.62 162.09,53.49 160.93,54.66 160.93,55.24 159.81,56.36 159.67,56.36 159.06,56.96 159.06,57.59 159.29,57.81 159.29,61.7 158.41,62.58 158.41,64.28 158.13,64.56 158.13,65.13 157.96,65.54 156.73,66.78 156.67,66.92 156.67,67.72 156.29,68.1 156.29,69.48 158.15,71.34 158.15,71.97 158.85,72.66 158.85,74.28 158.12,75.01 158.12,76.03 158.62,76.53 158.62,80.52 155.99,83.16 150.68,83.16 149.51,84.33 v2(148.88,84.33) 148.87,84.33 148.5,84.7 148.16,84.7 147.7,84.23 145.53,84.23 144.52,85.24 143.17,85.24 142.58,84.64 142.58,84.08 v2(142.57,84.08)
  BOTTOM w0.109: R401.2 149.35,83.86 v2(148.88,84.33) ; v1(164.18,44.59) 163.83,44.24 163.83,41.26 162.4,39.84 161.99,39.84 161.65,39.5 161.65,37.25 159.07,34.67 124.16,34.67 119.83,30.34 103.11,30.34 102.23,31.21 39.32,31.21 37.5,29.39 36.85,29.39 35.49,30.75 33.97,30.75 33.88,30.83 L3403.2 ; v2(142.57,84.08) 142.58,84.08 142.82,84.33 U400.DR5
CPU_POPI_RCOMP: length 1.9
  TOP w0.109: R606.2 134.54,70.58 v2(134.73,70.39)
  BOTTOM w0.109: U400.CT39 134.61,70.27 v2(134.73,70.39)
CPU_PRDY#: length 79.9
  TOP w0.109: v1(55.65,43.19) 54.97,43.19 52.26,40.48 CON7703.5
  IN3 w0.089: v1(55.65,43.19) 56.57,43.19 57.07,43.69 67.01,43.69 78.2,54.88 78.68,54.88 80.22,56.42 81.07,56.42 86.15,61.5 86.6,61.5 89.96,64.87 89.96,66.41 91.56,68.01 91.56,68.59 92.57,69.6 92.57,70.23 95.13,72.79 97.07,72.79 97.24,72.96 97.24,73.31 98.28,74.35 98.28,77.38 97.65,78.01 97.4,78.01 v1(96.89,78.52)
  BOTTOM w0.109: v1(96.89,78.52) 96.62,78.8 TP607.1 97.65,79.7 98.22,80.27 98.22,80.56 99.42,81.76 101.29,81.76 101.52,81.53 101.85,81.53 101.95,81.63 102.13,81.63 U400.D11
CPU_PREQ#: length 85
  TOP w0.109: v1(57.47,48.93) 57.14,48.6 57.14,43.35 55.7,41.92 54.54,41.92 52.25,39.62 50.09,39.62 49.89,39.82 R7701.2 49.1,40.08 49,39.98 CON7703.3
  IN2 w0.089: v1(97.64,80.81) 97.64,80.68 92.52,75.57 92.52,72.33 88.17,67.97 87.66,67.97 87.28,67.6 86.45,67.6 84.56,65.71 84.56,63.88 80.73,60.06 80.73,59.28 78.55,57.11 76.39,57.11 71.9,52.62 70.91,52.62 66.8,48.51 57.89,48.51 v1(57.47,48.93)
  BOTTOM w0.109: v1(97.64,80.81) 97.28,80.45 95.21,80.45 95.17,80.49 R614.1 96.24,81.23 TP606.1 96.56,81.35 98.63,81.35 99.27,81.99 101.57,81.99 U400.C11
CPU_PROCHOT#: length 457.5
  TOP w0.109: PR8829.1 80.19,106.46 v1(80.11,106.46) 79.69,106.46 PR8803.2 ; v1(155.72,55.73) 155.72,55.55 156.36,54.91 v1(156.61,54.91) 156.8,54.73 156.8,54 156.69,53.9 156.69,52.4 156.94,52.15 156.94,50.16 v1(156.67,49.88)
  IN1 w0.079: v1(97.81,91.13) 96.84,91.13 95.84,92.13 91.55,92.13 90.4,93.28 90.4,96.17 88.75,97.82 87.9,97.82 87.45,98.27 87.45,98.66 87.32,98.79 86.96,98.79 85.38,100.37 85.38,101.82 84.81,102.4 82.41,102.4 80.54,104.26 80.54,106.03 v1(80.11,106.46) ; v1(22.32,49.77) 24.27,49.77 26.72,52.22 29.18,52.22 30.28,51.12 36.21,51.12 37.45,52.36 38.94,52.36 39.08,52.51 40.22,52.51 40.54,52.83 42.14,52.83 42.59,53.29 43.58,53.29 43.71,53.41 43.71,53.97 43.94,54.2 47.57,54.2 47.85,54.48 51.21,54.48 51.36,54.33 56.89,54.33 58.01,53.21 58.47,53.21 58.95,53.69 59.74,53.69 v1(59.93,53.88) 60.28,54.23 60.88,54.23 61.27,53.85 62.28,53.85 64.33,55.89 64.33,58.13 66.44,60.25 66.44,62.05 72.84,68.44 72.84,70.39 73.07,70.62 75.44,70.62 78.29,73.48 78.53,73.48 80.33,75.29 80.33,76.81 81.47,77.94 81.95,77.94 82.59,78.59 82.59,79.85 84.98,82.23 84.98,83.05 87.71,85.79 87.71,86.97 88.32,87.58 88.32,91.55 v1(89.59,92.82)
  IN2 w0.089: v1(39.98,11.74) 38.97,12.75 38.27,12.75 34.13,16.89 32.56,16.89 22.94,26.51 22.44,26.51 21.7,27.25 21.7,32.45 22.74,33.49 22.74,34.21 21.82,35.14 21.82,37.72 22.2,38.1 22.2,43.46 22.58,43.84 22.58,46.71 20.8,48.49 20.8,48.89 21.68,49.77 v1(22.32,49.77)
  IN3 w0.089: v1(39.98,11.74) 42.79,11.74 42.92,11.61 43.62,11.61 44.53,12.52 45.73,12.52 47.68,14.47 53.62,14.47 53.76,14.33 57.85,14.33 58.71,13.48 62.17,13.48 63.05,14.36 67.28,14.36 67.57,14.06 69.96,14.06 71.67,15.77 74.56,15.77 75.74,14.58 79.15,14.58 80.06,15.49 85.75,15.49 85.93,15.67 88.06,15.67 88.11,15.62 88.85,15.62 88.92,15.69 93.42,15.69 93.78,16.06 100.36,16.06 101.96,17.65 101.96,17.91 102.87,18.82 103.91,18.82 104.24,18.49 104.24,17.75 104.47,17.52 105.23,17.52 105.28,17.57 110.57,17.57 112.56,19.57 119.59,19.57 120.15,19.01 141.89,19.01 141.91,19 156.13,19 v1(157.12,18.01)
  BOTTOM w0.109: v1(155.72,55.73) 155.16,56.29 155.16,58.24 155.82,58.9 155.82,61.43 154.79,62.46 PR8411.1 154.79,64.74 154.66,64.86 154.66,66.49 R1614.2 154.16,67.09 153.16,68.1 D1600.2 ; v1(59.93,53.88) 59.8,53.88 58.16,52.24 58.16,50.48 59.93,48.71 80.98,48.71 81.95,49.69 101,49.69 108.09,42.6 116.06,42.6 119.3,45.85 151.47,45.85 152.07,46.44 152.07,47.23 152.96,48.13 152.96,49.19 154.03,50.26 154.87,50.26 155.25,49.88 v1(156.67,49.88) ; R603.1 98.73,90.76 98.36,91.13 v1(97.81,91.13) 94.94,91.13 93.43,92.65 89.77,92.65 v1(89.59,92.82) 89.52,92.75 89.52,87.23 92.43,84.32 R602.1 ; R5419.1 v1(157.12,18.01)
CPU_SVID_CLK: length 11.3
  TOP w0.109: R706.1 102.82,90.88 102.99,90.7 v1(102.99,90.02) 102.99,87.62 103.29,87.33 103.29,86.62 103.83,86.08 104.24,86.08 104.77,85.54 104.77,85.54 105.45,84.86 105.45,82.67 v2(106.03,82.09)
  BOTTOM w0.109: U400.M11 105.92,82.09 v2(106.03,82.09)
CPU_SVID_DAT: length 15.1
  TOP w0.109: v2(106.04,80.95) 105.64,80.54 104.47,80.54 103.81,81.2 103.81,84.78 102.55,86.03 102.55,87.02 101.44,88.14 101.44,90.46 100.84,91.06 v1(100.84,91.16) R707.1
  BOTTOM w0.109: U400.M12 105.9,81.09 v2(106.04,80.95)
CPU_THERM#: length 85.1
  IN2 w0.089: v1(40.05,52.88) 40.61,53.44 42.06,53.44 43.25,54.63 50.06,54.63 50.24,54.81 53.34,54.81 54.45,53.7 56.39,53.7 59.87,50.22 65.87,50.22 70.26,54.61 71.07,54.61 75.45,58.99 75.73,58.99 76.1,59.36 76.1,59.63 78.99,62.53 78.99,62.74 80.87,64.62 81.39,64.62 82.88,66.11 82.88,68.72 86.92,72.76 86.92,75.65 91.36,80.09 v1(91.58,80.09)
  BOTTOM w0.109: U5400.4 93.99,77.84 93.88,77.95 93.88,79.14 93.39,79.63 92.05,79.63 v1(91.58,80.09) 91.54,80.13 R5407.1 ; Q5401.2 35.09,57.45 35.22,57.32 35.22,56.83 37.32,54.72 37.32,53.33 38.21,52.43 39.61,52.43 v1(40.05,52.88)
CPU_VIDALERT#: length 13.5
  TOP w0.109: v2(106.03,81.54) 105.47,80.97 v1(105.28,80.97) 104.95,80.97 104.65,81.28 104.65,84.74 102.92,86.47 102.92,87.18 101.95,88.15 101.95,91.06 R705.1
  BOTTOM w0.109: v2(106.03,81.54) 106.04,81.54 U400.P12
CR_GPIO: length 1.6
  TOP w0.109: R7600.2 181.13,39.75 U7600.28
CSI_RCOMP: length 15.7
  BOTTOM w0.079: U400.K14 104.2,79.93 103.86,79.93 103.72,79.79 103.72,79.39 103.38,79.06 102.14,79.06 102.14,79.06 101.07,79.06
  BOTTOM w0.109: 101.07,79.06 100.13,79.06 99.88,78.81 99.88,76.37 99.02,75.51 99.02,73.11 99.11,73.02 99.11,72.39 99.01,72.29 99.01,71.4 98.64,71.03 97.72,71.03 97.58,70.89 R1417.2
CSP_N: length 17.8
  TOP w0.203: v2(192.35,91.13) 192.88,91.13 R6127.2
  IN2 w0.254: v2(186,82.92) 187.44,82.92 188.19,83.67 188.19,87.63 189.55,88.99 189.55,89.22 190.07,89.74 191.4,89.74 191.88,90.21 192.2,90.21 192.62,89.79 192.96,89.79 193.16,89.99 193.16,90.73 193.01,90.88 192.61,90.88 v2(192.35,91.13)
  BOTTOM w0.109: v2(186,82.92) 187.06,82.92 187.63,83.49 U6100.38
CSP_P: length 17.8
  TOP w0.203: v2(194.99,91.31) 194.99,91.11 194.81,90.93 R6128.2
  IN2 w0.254: v2(186.53,83.85) 186.53,83.5 186.64,83.39 187.27,83.39 187.81,83.92 187.81,87.75 189.18,89.13 189.18,89.39 189.91,90.12 191.21,90.12 191.62,90.53 191.89,91.19 191.89,91.44 192.1,91.64 192.29,91.64 192.62,91.51 192.81,91.31 v2(194.99,91.31)
  BOTTOM w0.102: 186.68,83.7 v2(186.53,83.85)
  BOTTOM w0.109: 186.68,83.7 186.94,83.44 187.22,83.44 187.46,83.68 187.46,83.73 187.62,83.89 U6100.39
CYPRE_INT: length 155
  TOP w0.109: v1(159.45,57.38) 159.26,57.19 v1(159.26,56.74) 158.49,55.98 158.49,53.57 159.58,52.48 v1(159.58,52.15) ; v1(166.9,84.63) 168.29,83.24 169.43,83.24 171.87,80.8 179.9,80.8 180.83,81.73 181.7,81.73 182.2,81.24 v1(182.2,80.6)
  IN1 w0.079: v1(170.25,45.82) 170.51,45.82 170.91,46.23 171.75,46.23 171.89,46.09 172.83,46.09 173.37,46.63 v1(174.34,46.63) ; v2(196.04,85.7) 195.83,85.49 195.83,85.29 195.68,85.14 195.68,81.38 194.82,80.52 191.82,80.52 191.57,80.27 182.52,80.27 v1(182.2,80.6)
  IN2 w0.089: v1(174.34,46.63) 173,46.63 170.79,48.84 170.79,50.29 170.97,50.47 171.47,50.47 171.8,50.8 171.8,51.23 171.65,51.38 171.65,55.34 171.89,55.57 171.89,57.5 171.65,57.73 171.65,63.13 170.57,64.22 170.57,64.98 170.76,65.17 170.76,66.78 169.99,67.55 169.99,68.61 170.22,68.84 170.47,68.84 170.92,69.29 170.92,70.07 171.19,70.35 171.19,73.8 169.25,75.74 169.25,77.91 168.6,78.55 168.6,81.39 166.9,83.09 v1(166.9,84.63)
  IN3 w0.089: v1(159.58,52.15) 159.72,52.15 159.93,52.36 161.63,52.36 162.45,51.54 163.07,51.54 165.25,49.36 168.27,49.36 169.48,48.15 169.48,46.59 v1(170.25,45.82) ; v2(135.52,68.72) 137.51,66.73 137.51,64.59 138.48,63.62 139.65,63.62 140.63,62.65 147.68,62.65 148.42,61.9 148.42,58.48 151.1,55.8 154.49,55.8 156.12,57.43 159.39,57.43 v1(159.45,57.38)
  BOTTOM w0.109: R1510.2 195.24,88.6 195.45,88.39 196.49,88.39 196.97,87.91 196.97,87 196.93,86.89 196.47,86.43 196.47,86.31 196.04,85.88 v2(196.04,85.7) 196.03,85.7 194.99,85.7 194.8,85.89 U6100.17 ; v1(166.9,84.63) 165.83,84.63 164.51,83.31 164.51,81.95 165.42,81.04 165.42,79.8 165.77,79.45 166.29,79.45 166.42,79.58 CON7701.8 ; v2(135.52,68.72) U400.CW40
CYPRE_INT_EC#: length 148.6
  TOP w0.076: U4700.A11 191.78,21.13 190.88,21.13 190.14,21.87
  TOP w0.109: 190.14,21.87 190.14,22.07 189.2,23.01 v1(188.11,23.01) 187.83,23.01 187.71,23.13 v2(187.5,23.13)
  IN2 w0.089: v1(165.85,77.58) 165.85,77.35 165.79,77.28 165.79,74.17 164.46,72.84 164.46,72.57 164.89,72.13 164.89,71.27 165.94,70.23 165.94,69.72 167.69,67.97 167.69,66.49 166.88,65.68 166.88,65.28 167.26,64.89 167.26,64.34 168.81,62.78 168.81,60.57 167.53,59.29 167.53,58.69 168.22,58.01 168.22,53.08 166.87,51.74 166.87,50.89 169.04,48.72 169.04,45.26 170.04,44.27 172.16,44.27 172.25,44.36 172.96,44.36 173.26,44.67 174.61,44.67 175.8,43.47 175.8,38.31 176.4,37.71 177.16,37.71 177.87,36.99 177.87,36.1 v1(178.38,35.59) ; v2(193.31,81.34) 193.46,81.34 194.46,80.34 194.46,79.96 194.05,79.55 194.05,78.46 195.55,76.96 195.55,75.84 196.14,75.26 196.14,74.78 197.33,73.58 197.33,70.86 197.98,70.21 197.98,66.35 199.03,65.3 199.03,63.27 199.75,62.56 201.08,62.56 201.55,62.09 202.78,62.09 203.73,61.14 203.73,58.17 203.07,57.5 203.07,53.41 202.16,52.5 200.99,52.5 200.1,51.61 200.1,49.1 196.42,45.41 v1(191.41,45.41)
  IN3 w0.089: v1(178.38,35.59) 178.67,35.3 178.67,33.45 181.1,31.02 181.1,30.78 182.41,29.47 182.41,29.21 183.9,26.98 184.39,25.78 187.04,23.13 v2(187.5,23.13)
  BOTTOM w0.102: R6114.2 193.5,81.16 v2(193.31,81.34) 193.01,81.65 U6100.26
  BOTTOM w0.109: v1(178.38,35.59) 179.04,36.25 179.73,36.25 180.19,36.7 180.19,37.99 180.69,38.5 180.69,38.98 182.71,40.99 183.97,40.99 184.82,41.85 185.37,41.85 185.98,42.46 185.98,43 187.37,44.4 187.73,44.4 187.91,44.22 188.54,44.22 189.74,45.41 v1(191.41,45.41) ; CON7701.4 v1(165.85,77.58)
D64019_N: length 9.4
  TOP w0.109: R7516.2 20.69,33.53 v1(20.98,33.25) 21.11,33.12 R7520.2 21.64,32.69 21.74,32.59 D7501.3 22.05,32.06 22.3,32.32 22.3,32.56 22.6,32.87 R7519.2 22.85,31.82 22.1,31.07 R7515.2 R7518.2
DBG_PMODE: length 167.8
  TOP w0.109: v1(37.85,50.29) 38.48,50.93 R7706.1
  IN1 w0.079: v1(131.42,101.76) 131.42,101.32 127.17,97.07 122.32,97.07 121.89,97.49 110.72,97.49 110,96.78 97.64,96.78 97.49,96.92 93.68,96.92 92.33,98.27 v1(92.14,98.27)
  IN2 w0.089: v1(131.42,101.76) 131.24,101.58 131.24,100 131.72,99.52 131.72,99.28 133.74,97.27 133.74,96.33 134.74,95.33 134.74,93.98 135.48,93.24 136.01,93.24 137.51,91.74 138.08,91.74 v1(138.93,90.9) ; v1(92.14,98.27) 91.47,97.6 91.47,93.27 92.11,92.63 94.53,92.63 96.6,90.57 96.6,88.19 93.24,84.83 93.24,83.78 91.79,82.33 91.79,80.85 91.11,80.17 91.11,80.09 86.74,75.72 86.74,72.83 82.68,68.78 82.68,66.16 81.31,64.79 80.79,64.79 78.79,62.79 78.79,62.6 75.89,59.71 75.89,59.56 75.56,59.23 75.42,59.23 70.97,54.79 70.18,54.79 65.8,50.4 59.94,50.4 56.46,53.88 54.65,53.88 53.54,54.99 50.14,54.99 49.96,54.81 42.79,54.81 41.67,53.69 40.3,53.69 39.6,52.99 39.6,52.04 v1(37.85,50.29)
  BOTTOM w0.109: v1(138.93,90.9) 138.93,92.05 139.43,92.56 R1242.1 140.03,92.07 R1244.1 140.33,91.97 140.82,91.48 140.82,90.22 TP1201.1 140.69,89.08 141.32,88.44 141.32,87.93 141.14,87.74 140.94,87.74 139.76,86.56 139.76,86.09 139.53,85.86 139.53,85.33 U400.DF4
DCIN_EN: length 6.2
  TOP w0.109: v1(197.77,56.17) U3501.8
  BOTTOM w0.109: v1(197.77,56.17) 197.82,56.17 199.41,54.58 199.7,54.58 200.86,53.42 200.86,52.48 R3506.1
DCPRTC: length 3.9
  BOTTOM w0.109: U400.DV34 144.87,71.38 145.21,71.31 145.46,71.21 146.61,70.98 148.37,70.98 C1653.1
DDIB_AUX_DN: length 8.4
  TOP w0.109: TP401.1 112.49,89.56 112.49,86.89 111.09,85.48 111.09,83.58 110.69,83.19 v2(110.61,83.19)
  BOTTOM w0.109: U400.AD9 110.61,82.84 v2(110.61,83.19)
DDIB_AUX_DP: length 5
  TOP w0.109: TP400.1 108.61,80.29 108.71,80.39 108.71,80.59 108.9,80.78 109.1,80.78 109.22,80.9 109.22,82.93 v2(109.62,83.34)
  BOTTOM w0.109: U400.AB9 109.62,82.92 v2(109.62,83.34)
DDR3_DRAMRST#: length 172.4
  TOP w0.109: C2800.2 142.26,23.5 v1(142.17,23.42) ; R510.2 C500.2 154.12,53.83 v1(154.12,53.21) 154.12,52.83 154.3,52.65 v1(154.3,52.25) ; v1(65.76,22.22) 65.7,22.28 C2900.2
  IN3 w0.089: v1(65.76,22.22) 65.3,21.77 65.3,21.08 65.96,20.42 82.76,20.42 83.2,20.85 97.42,20.85 97.52,20.75 104.43,20.75 104.56,20.88 107.47,20.88 109.27,22.68 110.16,22.68 110.95,23.47 114.27,23.47 114.67,23.07 116.34,23.07 117.14,23.87 119.64,23.87 120.08,23.44 120.08,22.07 121.01,21.13 141.15,21.13 141.3,21.28 141.3,22.54 v1(142.17,23.42) 143.08,22.52 143.08,21.84 143.81,21.11 161.06,21.11 161.25,20.92 174.99,20.92 176.23,22.15 176.23,28.41 169.82,34.82 169.82,35.23 168.96,36.09 168.96,36.83 168.6,37.18 167.46,37.18 165.51,39.13 165.51,40.05 165.22,40.34 161.68,40.34 160.98,41.05 160.24,41.05 159.31,41.98 159.31,43.6 157.08,45.83 157.08,47.36 155.64,48.81 155.64,49.58 154.3,50.92 v1(154.3,52.25)
  BOTTOM w0.109: JDIM2900.108 66.22,21.77 v1(65.76,22.22) ; JDIM2800.108 143.17,22.42 v1(142.17,23.42)
DDR_RCOMP0: length 4.3
  BOTTOM w0.079: U400.C49 101.54,64.53 101.05,64.04 100.54,64.04 100.21,63.71
  BOTTOM w0.254: 100.21,63.71 98.35,63.71 98.12,63.93 R500.1
DDR_VTT: length 4.6
  BOTTOM w0.203: JDIM2800.258 182.68,19.07 v1(182.84,18.91) ; v1(102.06,10.16) 102.36,10.46 C2817.1 ; JDIM2900.258 v1(105.72,21.79) 105.72,21.89 v1(106.17,22.35)
  vias: v1(95.76,16.74) v1(96.09,17.3) v1(96.39,16.74) v1(97.74,14.86) v1(105.81,22.91) v1(117.4,16.61) v1(117.83,17.07) v1(181.67,18.59) v1(182.22,18.88)
DDR_VTT_CTRL: length 11.4
  BOTTOM w0.079: U400.E52 102.82,63.11 102.82,62.28
  BOTTOM w0.178: R512.1 95.78,63.51 v1(96.91,62.38) 97.83,61.47 102,61.47 102.82,62.28
DDR_VTT_PG_CTRL: length 217
  TOP w0.109: v1(108.63,12.47) 108.96,12.14 R3307.1 108.96,10.76 108.76,10.56 108.76,9.5 108.41,9.14 108.41,8.1 108.98,7.52 PQ8702.2
  IN1 w0.079: v1(21.25,48.62) 21.47,48.4 26.85,48.4 27.46,47.8 28.19,47.8 28.45,48.06 30.67,48.06 31.34,48.72 38.83,48.72 40.04,49.93 46.69,49.93 47.88,51.13 49.73,51.13 51.05,52.45 56.28,52.45 56.87,53.03 58.52,53.03 58.98,53.49 60.23,53.49 v1(60.58,53.85)
  IN2 w0.089: v1(21.25,48.62) 22.76,47.12 22.76,43.66 22.38,43.28 22.38,38 21.99,37.62 21.99,35.21 22.92,34.29 22.92,33.41 21.89,32.39 21.89,27.31 22.52,26.68 23.07,26.68 32.69,17.07 34.2,17.07 38.32,12.95 39.24,12.95 39.86,12.34 41.75,12.34 42.78,13.37 43.77,13.37 44.95,12.2 48.11,12.2 48.46,12.55 53.24,12.55 53.97,11.82 56.1,11.82 56.72,11.2 57.9,11.2 58.16,11.46 68.47,11.46 71.22,14.22 74.39,14.22 75.61,13 78.94,13 80.11,14.16 87.35,14.16 87.79,14.6 92.53,14.6 93.89,15.96 97.25,15.96 97.64,16.35 104.29,16.35 104.73,16.79 110.23,16.79 110.55,16.47 110.55,15.22 108.63,13.31 v1(108.63,12.47)
  BOTTOM w0.109: Q500.3 89.61,67.66 89.43,67.49 R504.2 89.09,66.92 R511.2 89.18,66.72 88.71,66.25 88.71,63.15 88.38,62.83 88.38,58.9 86.48,57 84.83,57 82.95,55.12 76.11,55.12 74,53.02 61.82,53.02 60.99,53.85 v1(60.58,53.85)
DDR_VTTREF: length 2.7
  TOP w0.254: PC8711.1 107.35,7.3 v1(107.35,7.54) 107.28,7.61 PR8707.1
DDSP_1_HPD1: length 77.7
  TOP w0.109: v2(149.68,63.88) 150.22,64.41 150.77,64.41 151.08,64.72 151.08,64.91 151.33,65.17 151.8,65.17 152.18,64.78 154.94,64.78 155.24,65.08 R405.1 155.7,64.76 155.85,64.61 156.47,64.61 156.82,64.26 156.82,63.84 157.1,63.57 157.1,62.95 156.84,62.7 156.84,62.43 157.53,61.74 157.53,61.22 158.4,60.35 158.4,59.12 v1(158.76,58.76) 160.01,57.51 160.01,56.73 160.32,56.42 160.32,55.12 v1(160.31,55.1)
  IN1 w0.079: v1(160.31,55.1) 160.33,55.08 161.25,55.08 161.73,55.55 162.36,55.55 163.26,56.45 164.95,56.45 165.6,55.8 169.1,55.8 169.45,56.15 170.54,57.24 170.97,57.24 171.4,56.82 172.15,56.82 172.35,57.02 172.85,57.02 173.25,57.42 176.77,57.42 179.62,60.27 179.62,61.21 185.85,67.44 186.69,67.44 187.01,67.12 187.64,67.12 v1(187.78,67.26)
  IN3 w0.089: v2(149.68,63.88) 148.73,63.88 148.71,63.86 146.71,63.86 144.85,65.71 143.32,65.71 142.72,66.3 139.42,66.3 v2(139.23,66.11)
  BOTTOM w0.109: Q6100.1 197.46,68.7 192.43,68.7 192.08,69.06 R6115.1 191.56,69.62 190.88,68.93 189.45,68.93 v1(187.78,67.26) ; U400.DF45 138.92,66.42 v2(139.23,66.11)
DEVSLP1: length 19.2
  TOP w0.109: R4304.1 157.4,80.58 v1(157.23,80.74)
  IN2 w0.089: v1(157.23,80.74) 157.17,80.81 157.17,81.47 155.84,82.8 152.11,82.8 151.76,82.46 151.76,81.91 151.66,81.8 150.63,81.8 150.41,82.03 150.41,82.45 149.25,83.61 147.15,83.61 147.06,83.7 144.1,83.7 143.95,83.84 143.42,83.84 142.95,83.38 v2(142.5,83.38)
  BOTTOM w0.079: U400.DN6 142.17,83.71 v2(142.5,83.38)
DEVSLP1_R: length 253.1
  TOP w0.109: R4304.2 158.82,80.17 159.31,80.65 161.14,80.65 161.53,81.05 163.25,81.05 164.89,79.4 167.05,79.4 168.18,78.27 168.18,77.62 v2(168.36,77.44)
  IN1 w0.079: v1(38.09,44.96) 37.89,45.17 29.05,45.17 27.91,44.02 25.37,44.02 23.36,42.01 19.93,42.01 19.49,42.45 16.62,42.45 16.38,42.21 14.95,42.21 13.06,40.33 13.06,37.8 10.92,35.66 8.51,35.66 v1(7.17,34.32) ; v1(163.42,48.96) 163.44,48.99 164.14,48.99 165.18,50.02 166.05,50.02 166.22,50.19 168.15,50.19 168.76,50.8 169.56,50.8 v1(170.53,51.76)
  IN2 w0.089: v1(170.53,51.76) 170.53,55.49 171.17,56.14 171.17,56.93 170.23,57.88 170.23,63.44 169.3,64.38 169.3,67.24 169.08,67.45 169.08,69.41 169.28,69.61 169.28,71.5 169.96,72.18 170.27,72.18 170.48,72.39 170.48,73.5 168.48,75.5 168.48,76.14 168.36,76.27 v2(168.36,77.44) ; v1(7.17,34.32) 6.28,33.42 6.28,28.93 7.44,27.76 7.44,24.02 6.11,22.68 6.11,20.31 6.81,19.62 6.81,18.22 6.09,17.5 6.09,12.46 v1(7.05,11.5)
  BOTTOM w0.109: v1(163.42,48.96) 161.9,47.44 161.9,45.91 160.05,44.06 160.05,43.34 160.24,43.14 160.24,42.69 159.66,42.11 159.66,42.07 157.31,39.72 156.94,39.72 155.1,37.89 123.82,37.89 118.67,32.74 104.38,32.74 103.15,33.97 48.14,33.97 43.76,38.36 43.48,38.36 42.82,39.02 42.82,39.73 38.09,44.46 v1(38.09,44.96) ; CON4300.38 v1(7.05,11.5)
DG_SMBUS_SCL: length 2.3
  BOTTOM w0.109: U5900.A7 185.62,93.43 185.62,92.66 185.39,92.43 185.39,91.7 R5916.1
DG_SMBUS_SDA: length 2.9
  BOTTOM w0.109: U5900.B7 185.27,93.79 185.27,93.39 185.42,93.24 185.42,92.78 185.13,92.49 185.13,91.98 184.83,91.69 R5918.1
DGPU_EDIDCLK: length 7.5
  TOP w0.109: v1(74.22,90.44) 74.08,90.59 73.26,90.59 72.72,91.13 72.72,92.18 72.24,92.66 R6924.1
  BOTTOM w0.109: U6600.A9 72.09,88.13 72.09,88.78 72.82,89.52 73.76,89.52 74.22,89.98 v1(74.22,90.44)
DGPU_EDIDDATA: length 8.7
  TOP w0.109: v1(74.83,90.68) 74.6,90.9 73.35,90.9 73.15,91.1 v1(73.15,91.97) 73.15,92.48 R6926.1
  BOTTOM w0.109: v1(74.83,90.68) 74.83,90.27 73.85,89.29 72.94,89.29 72.35,88.7 72.35,87.81 71.96,87.42 U6600.B9
DGPU_HOLD_RST#: length 175.7
  TOP w0.109: v2(154.07,79.6) 154.33,79.86 R1307.2
  IN2 w0.089: v1(69.94,49.77) 70.66,49.77 76.94,56.05 78.76,56.05 80.82,58.11 v1(81.38,58.11) ; v1(158.95,50.78) 159,50.83 159,51.67 158.66,52 158.66,52.27 157.13,53.8 157.13,54.63 156.7,55.06 154.94,55.06 153.03,56.97 151.4,56.97 150.11,58.25 150.11,58.52 149.7,58.94 149.7,61.6 152.5,64.41 152.5,65.16 151.9,65.77 151.9,67.83 151.39,68.34 151.39,70.08 151.79,70.48 152.36,70.48 152.86,70.99 155.86,70.99 156.91,72.03 156.91,72.48 157.6,73.18 157.6,73.72 156.74,74.59 156.74,75.67 156.67,75.74 156.67,77.09 155.77,77.98 155.32,77.98 155.12,78.18 155.12,78.71 154.51,79.32 154.36,79.32 v2(154.07,79.6) 153.63,80.05 151.92,80.05 151.06,80.9 150.11,80.9 148.58,82.43 144.76,82.43 143.83,81.5 143.32,81.5 142.85,81.96 139.26,81.96 138.82,82.41 v2(138.81,82.41)
  BOTTOM w0.109: v2(138.81,82.41) 138.72,82.41 U400.DD8 ; v1(69.94,49.77) 73.73,49.77 76.04,52.08 77.36,52.08 77.59,51.85 101.92,51.85 109.03,44.74 115.14,44.74 119.19,48.79 148.31,48.79 148.77,48.33 150.81,48.33 151.21,48.73 151.21,49.17 151.86,49.81 152.4,49.81 153.93,51.34 157.62,51.34 158.18,50.78 v1(158.95,50.78) ; v1(81.38,58.11) 81.33,58.11 79.89,59.56 U6601.1
DGPU_OVT#: length 36.9
  IN2 w0.089: v1(87.91,82.37) 87.91,81.5 88.18,81.22 88.18,80.07 87.42,79.31 87.42,78.65 85.04,76.26 85.04,74.8 80.92,70.68 80.92,69.84 79.27,68.19 79.27,65.76 v1(78.47,64.96)
  BOTTOM w0.109: D6901.1 v1(85.52,82.35) 86.6,82.35 86.99,81.96 87.5,81.96 v1(87.91,82.37) 88.23,82.69 Q6903.3 ; v1(78.47,64.96) 78.47,64.97 78.48,64.98 79.86,64.98 79.96,65.08 82.62,65.08 83.2,65.67 84.27,65.67 84.76,65.17 84.76,63.95 85.26,63.45 R6946.2 85.55,62.38 Q6902.3
DGPU_PGOK-1: length 89.9
  IN1 w0.079: v1(82.09,82.65) 80.54,81.1 80.54,78.57 79.67,77.7 79.02,77.7 77.79,76.48 77.79,75.82 77.37,75.4 77.37,74.48 76.79,73.9 75.37,73.9 74.24,72.77 73.21,72.77 72.55,72.11 71.9,72.11 71.9,72.11 71.39,72.11 70.68,71.41 68.55,71.41 67.86,70.72 67.86,66.99 57.61,56.74 53.94,56.74 53.72,56.97 46.73,56.97 v1(46.35,56.59)
  IN3 w0.089: v1(82.09,82.65) 81.89,82.85 81.89,85.16 82.01,85.28 82.01,88.09 79.6,90.51 79.6,95.43 78.28,96.74 77.01,96.74 76.89,96.63 67.43,96.63 v1(67.33,96.53)
  BOTTOM w0.109: Q6801.2 60.7,92.56 C6809.1 R6809.1 61.72,93.32 62.08,93.67 62.76,93.67 63.91,94.82 v1(64.97,94.82) 65,94.84 65.58,94.84 67.26,96.53 v1(67.33,96.53) ; v1(46.35,56.59) 46.33,56.61 Q6800.3
DGPU_POK2: length 4
  BOTTOM w0.109: Q6802.2 38.21,57.32 v1(37.84,56.94) 37.41,57.38 C6810.1 36.97,58.19 36.97,58.8 37.45,59.28 R6811.1
DGPU_POK4: length 3
  BOTTOM w0.109: R6808.1 48.61,57.12 48.58,57.09 C6808.1 48,56 v1(47.78,56) 47.28,56.5 Q6800.2
DGPU_PRSNT#: length 11.3
  TOP w0.109: v2(145.53,81.43) 145.08,80.98 142.9,80.98 142.46,81.42 142.46,81.43 141.73,81.43 v2(141.69,81.46)
  BOTTOM w0.109: U400.DK8 141.09,82.85 141.84,82.11 141.84,81.61 v2(141.69,81.46) ; v2(145.53,81.43) 146.01,80.95 147.41,80.95 148.14,80.22 149.06,80.22 149.27,80.43 R1127.1 R1124.1
DGPU_PWR_EN: length 100.9
  TOP w0.109: v2(140.43,83.29) 140.43,83.97 140.71,84.26 140.71,86 140.38,86.34 140.38,87.3 140.53,87.45 140.53,89.06 R1121.2
  IN1 w0.079: v1(91.3,98.95) 91.7,98.54 91.7,97.73 92.83,96.61 97.36,96.61 97.51,96.47 110.13,96.47 110.85,97.18 121.76,97.18 122.19,96.75 127.31,96.75 131.69,101.13 132.41,101.13 v1(132.9,101.61)
  IN2 w0.089: v2(140.43,83.29) 140.43,84.76 141.29,85.62 142.24,85.62 144.83,88.21 144.83,90.02 142.68,90.02 142.16,90.54 142.16,91.36 141.64,91.89 138.69,91.89 138.3,92.28 137.73,92.28 136.83,93.17 136.83,95.62 135.87,96.59 135.87,98.48 135.46,98.89 134.28,98.89 133.5,99.67 133.5,100.69 132.9,101.3 v1(132.9,101.61)
  BOTTOM w0.109: v2(140.43,83.29) 140.22,83.49 U400.DJ6 ; R1146.2 80.77,102.11 81.37,101.51 U6901.2 81.37,100.2 82.37,99.2 R6710.1 83.23,99.3 83.59,99.67 v1(84.35,99.67) 87.52,99.67 88.44,98.75 88.44,97.76 88.32,97.64 88.32,96.81 88.06,96.55 87.96,96.55 U6902.1 88.12,96.07 88.97,96.07 89.22,96.33 89.22,96.61 89.44,96.83 89.99,96.83 90.27,97.11 90.27,97.92 v1(91.3,98.95)
DISP_UTILS: length 5.1
  TOP w0.109: v2(128.89,83.97) 128.44,83.52 128.44,83.15 128.59,83 129.06,83 129.34,82.72 TP402.1
  BOTTOM w0.109: U400.CE4 129.47,84.92 129.15,84.6 129.15,84.23 v2(128.89,83.97)
DP_RCOMP: length 2.5
  BOTTOM w0.254: 111.07,88.39 110.41,87.73 110.41,86.75 U400.AB1
DPB_DDCCLK: length 82.2
  TOP w0.109: U3501.31 199.66,60.57 v1(200.07,60.98) 200.18,61.08 200.41,61.08 200.73,61.41 200.73,62 v1(200.58,62.15) 199.77,62.15 R3516.1
  IN1 w0.079: v2(141.83,74.22) 142.18,73.87 143.07,73.87 143.4,73.53 143.93,73.53 145.15,72.31 145.15,71.97 145.61,71.51 147.23,71.51 147.44,71.72 149.51,71.72 149.86,71.37 149.86,70.89 150.64,70.12 151.31,70.12 151.85,69.58 153.7,69.58 153.78,69.65 154.55,69.65 154.89,70 157.1,70 157.51,70.4 159.56,70.4 159.73,70.23 160.79,70.23 161.35,69.67 164.48,69.67 164.79,69.36 165.79,69.36 166.08,69.07 167.53,69.07 170.15,66.45 172.3,66.45 173.47,67.62 173.47,69 174.43,69.95 176.21,69.95 177.02,70.76 177.39,70.76 178.44,71.81 179.48,71.81 180.45,72.78 180.45,73.3 181.04,73.89 183.47,73.89 184.55,72.8 185.81,72.8 186.56,73.56 186.56,74.06 188.22,75.71 188.9,75.71 191.06,73.55 191.06,72.41 190.7,72.06 190.7,69.65 192.9,67.45 195.29,67.45 v1(200.58,62.15)
  BOTTOM w0.109: U400.DM29 141.83,74.05 v2(141.83,74.22)
DPB_DDCDATA: length 81
  TOP w0.109: U3501.32 199.26,60.6 199.41,60.75 R3517.1 199.66,61.57 v1(200.3,61.57)
  IN1 w0.079: v1(200.3,61.57) 194.81,67.06 192.74,67.06 190.29,69.51 190.29,72.19 190.67,72.57 190.67,73.39 188.74,75.33 188.38,75.33 187.04,73.99 187.04,73.48 185.98,72.42 184.39,72.42 183.31,73.5 181.33,73.5 180.95,73.12 180.95,71.93 180.26,71.24 178.64,71.24 177.37,69.98 176.78,69.98 176.37,69.57 174.58,69.57 173.86,68.84 173.86,67.46 172.46,66.06 169.97,66.06 167.36,68.68 165.79,68.68 165.49,68.98 164.63,68.98 164.34,69.28 161.2,69.28 161.07,69.41 158.68,69.41 158.5,69.59 156.82,69.59 156.79,69.61 155.05,69.61 154.71,69.27 154.03,69.27 153.95,69.19 151.62,69.19 151.08,69.73 150.48,69.73 149.09,71.12 145.45,71.12 144.76,71.81 144.76,72.15 143.77,73.14 143.16,73.14 142.74,73.56 141.92,73.56 v2(141.29,74.19)
  BOTTOM w0.109: U400.DK27 141.29,74.24 v2(141.29,74.19)
DPWROK: length 89.2
  TOP w0.076: U4700.E7 v2(194.14,18.29)
  TOP w0.109: v1(166.7,69.52) 166.7,69.77 166.84,69.91 166.84,70.25 166.58,70.51 166.07,70.51 PR8127.1 165.14,69.86 164.7,70.3 C1502.1 164.44,70.05 164.24,69.85 R1528.1 162.81,69.46 R1527.2
  IN2 w0.076: v2(194.14,18.29) 194.14,18.27 193.72,17.85 193.42,17.85 193.02,18.25
  IN2 w0.089: v1(166.7,69.52) 166.75,69.47 166.75,69.16 167.87,68.04 167.87,65.5 167.43,65.07 167.43,64.41 168.99,62.86 168.99,60.5 167.71,59.22 167.71,58.77 168.63,57.85 168.63,52.13 168.38,51.88 167.55,51.88 167.23,51.55 167.23,51.04 169.4,48.87 169.4,45.41 170.18,44.63 171.95,44.63 172.04,44.72 172.8,44.72 173.1,45.02 174.75,45.02 176.16,43.62 176.16,38.46 176.55,38.06 178.19,38.06 179.1,37.15 179.1,36.08 179.39,35.8 179.39,35.07 181.26,33.19 181.55,33.19 184.03,30.72 184.03,29.6 185.45,26.17 186.91,24.71 187.48,24.71 187.9,24.53 188.34,24.09 188.34,23.08 188.88,22.54 188.88,21.55 188.89,21.51 188.91,21.44 188.95,21.35 189.12,21.18 190.17,21.18 190.63,20.72 191.4,20.72 192.24,19.88 192.24,19.03 193.02,18.25
  BOTTOM w0.076: v2(194.14,18.29) 193.75,17.9 193.39,17.9 193.16,18.14 192.47,18.14 191.97,18.64 191.92,18.64
  BOTTOM w0.109: 191.92,18.64 190.9,18.64 190.68,18.41 190.68,17.7 190.45,17.47 190.45,16.91 189.96,16.43 189.96,15.36 190.23,15.1 190.23,13.58 189.62,12.97 PU8102.4
DPWROK_Q: length 17.6
  TOP w0.109: PR8124.2 186.14,10.74 v1(186.14,10.62) 186.2,10.62 186.87,9.95 186.87,9.83 187.33,9.37 Q4703.5 ; PR8123.2 177.8,12.77 179.08,11.49 179.08,9.27 179.71,8.63 180.34,8.63 180.77,9.07 v1(180.9,9.07)
  IN1 w0.079: v1(186.14,10.62) 186.14,10.2 185.22,9.28 182.92,9.28 182.71,9.07 v1(180.9,9.07)
  BOTTOM w0.109: v1(186.14,10.62) 186.14,10.78 186.54,11.17 186.84,11.17 187.33,11.67 PU8102.1
DRAM_RESET#: length 17.3
  TOP w0.109: R510.1 R509.2 152.76,54.54 152.08,55.22 151.03,55.22 150.34,55.9 150.34,56.1 149.53,56.91 148.78,58.03 148.44,58.86 148.3,59.57 147.9,59.97 147.9,64.13 147.26,64.77 147.19,64.77 v2(147.19,64.77)
  BOTTOM w0.109: U400.DV47 144.74,65.03 145.24,65.03 145.74,64.53 146.95,64.53 147.19,64.77 v2(147.19,64.77)
DSI_DE_TE_2: length 8.5
  TOP w0.109: v2(105.94,83.31) 105.67,83.58 105.67,84.95 104.99,85.63 104.99,86.88 104.56,87.3 103.95,87.3 103.51,87.75 103.51,89.57 R403.1
  BOTTOM w0.109: v2(105.94,83.31) 105.68,83.04 U400.M8
EC_PECI: length 135
  TOP w0.109: v2(202.54,16.28) 202.79,16.53 R4812.1
  IN1 w0.079: v1(158.1,42.51) 158.42,42.83 158.42,42.93 158.76,43.27 160.39,43.27 162.56,45.44 162.56,45.79 162.82,46.05 164.16,46.05 165.15,47.04 166.32,47.04 166.55,47.27 166.7,47.27 167.09,47.66 168.07,47.66 169.47,49.06 173.34,49.06 173.47,48.93 174.19,48.93 174.4,49.13 175.98,49.13 176.93,48.18 177.26,48.18 178.88,46.56 181.72,46.56 182.31,45.96 183.03,45.96 184.31,44.68 184.86,44.68 185.49,44.05 185.49,40.14 185.04,39.68 185.04,38.41 185.3,38.15 185.3,35.39 187.42,33.27 187.42,31.61 188.92,30.11 188.92,29.72 189.18,29.46 190.75,29.46 191.19,29.02 191.19,28.15 191.84,27.5 193.26,27.5 197.09,23.67 199.11,23.67 199.69,23.09 200.39,23.09 201.5,22.63 202.48,21.64 202.48,16.94 202.36,16.81 202.36,16.46 v2(202.54,16.28)
  IN3 w0.089: v1(158.1,42.51) 157.69,42.92 156.21,42.92 154.5,44.63 154.5,44.96 153.88,45.58 153.26,45.58 151.52,47.32 147.9,47.32 138.89,56.34 138.89,61.86 135.6,65.15 135.6,68.01 134.37,69.24 134.37,70.61 135.07,71.32 135.07,73.38 134.11,74.34 132.26,74.34 129.06,77.54 126.49,77.54 125.96,78.07 125.96,79.14 125.44,79.66 124.06,79.66 122.96,80.76 122.96,82.28 v2(122.53,82.72)
  BOTTOM w0.109: U400.BK9 122.63,82.72 v2(122.53,82.72)
EC_PECI_R: length 4.5
  TOP w0.109: R4812.2 202.33,16.79 202.33,17.12 202.26,17.19 202.26,17.62 C4802.2 201.32,17.62 200.32,18.62 199.33,18.62 U4700.M7
EC_RTCRST_CTRL: length 269.7
  TOP w0.076: U4700.J11 197.42,21.57 197.42,22.29 197.51,22.38 197.51,22.52
  TOP w0.109: v1(182.26,2.32) 182.35,2.41 183.82,2.41 184.14,2.74 184.45,3.48 184.45,4.29 183.67,5.08 180.56,5.08 v1(179.62,6.02) ; v1(20.65,29.61) 22.1,29.61 22.39,29.91 D7501.1 22.39,30.59 v1(23.65,31.85) 23.63,31.87 R7519.1 ; 197.51,22.52 197.45,22.66 197.43,22.7 197.43,23.01 197.56,23.14 197.56,25.88 198.15,26.47 R4744.2 197.28,27.18 196.86,27.6 v2(196.86,27.61)
  IN2 w0.089: v1(182.26,2.32) 183.71,2.32 184.63,3.25 184.63,4.89 186.03,6.3 187.45,6.3 187.78,5.97 188.22,5.97 189.03,6.78 189.34,6.78 189.98,6.14 191.88,6.14 192.13,5.89 194.33,5.89 194.68,6.24 194.68,7.65 194.95,7.92 195.83,7.92 196.88,6.87 200.75,6.87 201.32,7.44 202.59,7.44 207.03,11.88 207.03,12.83 208.2,13.99 208.2,18.7 207.77,19.12 207.77,20.9 207.44,21.23 206.83,21.23 204.55,23.51 204.55,23.52 204.19,23.87 202.21,23.87 201.05,25.04 200.11,25.04 198.42,26.72 198.42,27.13 197.56,27.99 197.38,27.99 197.34,27.98 197.21,27.98 196.86,27.63 v2(196.86,27.61) ; v1(20.65,29.61) 20.65,27.91 22.23,26.33 22.84,26.33 32.48,16.69 34.03,16.69 38.2,12.52 38.58,12.52 39.77,11.33 43.33,11.33 43.84,11.83 45.64,11.83 46.1,11.38 46.71,11.38 v1(47.14,11.81)
  IN3 w0.089: v1(47.8,5.44) 48.71,6.35 50.29,6.35 50.84,6.9 51.15,6.9 51.69,6.67 52.33,6.04 54.35,6.04 56.24,4.15 58.9,4.15 59,4.25 59.59,4.25 60.28,3.55 62.99,3.55 63.53,4.09 65.1,4.09 65.63,4.62 72.51,4.62 74.6,6.7 74.6,7.19 75.14,7.73 75.14,8.34 75.59,8.79 97.88,8.79 98.81,7.87 101.36,7.87 101.92,7.31 105.24,5.93 122.83,5.93 123.62,6.72 124.91,6.72 125.06,6.66 125.27,6.45 126.2,6.45 126.76,7 130.22,7 130.69,7.47 132.43,7.47 133.22,6.68 136.09,6.68 137,7.59 139.61,7.59 140.99,6.21 143.02,6.21 143.33,6.52 143.33,7.6 143.61,7.88 144.23,7.88 144.35,8 145.43,8 145.58,8.15 146.46,8.15 146.68,7.93 146.68,7.59 146.92,7.35 147.76,7.35 148.06,7.66 148.06,7.68 148.38,8 151.1,8 151.49,7.61 159.69,7.61 159.77,7.69 161.16,7.69 161.45,7.97 162.25,7.97 162.77,8.49 164.82,8.49 165.29,8.01 169.64,8.01 171.56,6.09 176.78,6.09 177.39,6.7 178.59,6.7 178.83,6.46 179.18,6.46 v1(179.62,6.02)
  BOTTOM w0.109: v1(47.14,11.81) 47.14,11.5 45.87,10.23 45.87,8.74 45.44,8.3 45.01,8.3 44.69,7.99 44.69,5.24 44.93,5 47.39,5 47.8,5.41 v1(47.8,5.44)
EDIDCLK_R: length 5.2
  TOP w0.109: C3419.1 31.94,34.15 31.62,34.15 R3429.2 31.25,34.13 31.03,34.13 30.74,34.42 30.74,34.87 30.53,35.07 30.34,35.07 v1(30.07,35.34)
  BOTTOM w0.109: v1(30.07,35.34) 29.82,35.09 29.31,35.09 29.15,35.25 CON3400.20
EDIDDATA_R: length 5.2
  TOP w0.109: v1(30.07,34.58) 30.34,34.85 30.43,34.85 30.51,34.77 30.51,34.33 30.94,33.9 31.3,33.9 R3421.2 31.62,33.93 31.93,33.93 C3418.1
  BOTTOM w0.109: v1(30.07,34.58) 29.78,34.87 29.15,34.87 29.03,34.75 CON3400.19
EMU_LID: length 274.2
  TOP w0.076: U4700.J10 v2(197.39,20.24)
  TOP w0.109: v1(13.8,42.37) 13.8,43.04 14.69,43.93 14.69,47.33 14.96,47.61 15.81,47.61 v1(16.41,48.21) 16.79,48.59 16.79,49.53 17.06,49.8 17.53,49.8 17.75,49.58 17.75,48.94 17.96,48.73 18.91,48.73 19.25,49.07 R3409.2
  IN2 w0.076: 198.75,19.76 198.55,19.76 198.14,20.16 197.47,20.16 v2(197.39,20.24)
  IN2 w0.089: v1(179.02,2.49) 179.42,2.89 179.42,4.35 183.18,8.11 184.48,8.11 184.96,8.58 190.89,8.58 192.02,9.72 193.71,9.72 194.87,10.87 198.65,10.87 199.84,12.06 199.97,12.06 200.58,12.67 200.58,13.1 200.94,13.46 201.46,13.46 202.05,14.05 202.05,15.24 201.69,15.59 201.69,15.97 202.44,16.71 202.44,19.7 201.88,20.25 200.79,20.25 200.18,19.63 198.88,19.63 198.75,19.76
  IN3 w0.089: v1(13.8,42.37) 11.7,42.37 10.37,41.04 10.37,39.73 10.93,39.17 10.93,36.79 9.47,35.33 9.47,30.3 9.7,30.08 9.7,20.69 7.81,18.8 7.81,9.29 10.19,6.91 16.13,6.91 16.52,6.51 21.4,6.51 21.97,5.94 22.94,5.94 23.42,5.46 23.42,4.85 24.13,4.13 31.97,4.13 32.09,4.25 50.11,4.25 50.99,5.13 51.89,5.13 52.56,4.46 52.83,4.46 53.34,3.95 54.65,2.64 67.59,2.64 67.95,2.27 74.44,2.27 75.81,3.65 75.81,6.93 76.94,8.06 97.55,8.06 98.45,7.15 101.06,7.15 101.5,6.72 105.1,5.22 132.89,5.22 133.17,5.5 136.85,5.5 137.52,6.17 137.97,6.17 138.64,5.5 163.44,5.5 163.7,5.77 168.52,5.77 171.95,2.33 178.86,2.33 v1(179.02,2.49)
EN_1V8: length 2.9
  BOTTOM w0.109: R3308.2 119.15,12.44 118.67,11.96 v1(118.67,11.86) 120.15,11.86 120.33,12.05 PR9209.1
EN_3V: length 0.7
  BOTTOM w0.109: R3306.2 PR8606.1

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ46: length 48.5
  IN3 w0.114: v2(37.14,73.3) 37.54,72.9 37.54,64.89 38.07,64.36 38.07,63.48 41.74,59.81 48.09,59.81 48.2,59.92 48.2,60.56 48.33,60.69 48.55,60.69 48.66,60.57 48.66,59.92 48.78,59.81 49.42,59.81 50.62,58.6 54.04,58.6 57.05,61.61 57.05,66.3 57.43,66.69 58.38,66.69 59.62,67.93 59.62,69.63 59.82,69.84 60.2,69.84 60.53,70.17 60.53,70.7 60.41,70.83 60.41,71.28 60.69,71.56 61.14,71.56 61.52,71.94 v2(61.58,71.94)
  BOTTOM w0.14: v2(37.14,73.3) 37.54,72.9 VRAM7001.F11 ; v2(61.58,71.94) U6600.Y22
VMA_DQ47: length 49.5
  IN3 w0.114: v2(36.34,73.3) 36.57,73.3 36.98,73.71 37.62,73.71 38.39,72.94 38.39,70.64 38,70.25 38,68.98 38.49,68.49 38.49,63.65 41.92,60.23 46.96,60.23 48.15,61.42 48.88,61.42 49.2,61.1 49.2,60.83 51.01,59.02 53.87,59.02 55.86,61.01 55.86,63.99 55.97,64.1 56.45,64.1 56.56,64.21 56.56,64.44 56.45,64.56 55.97,64.56 55.86,64.67 55.86,64.9 55.97,65.01 56.45,65.01 56.56,65.13 56.56,65.36 56.45,65.47 55.97,65.47 55.86,65.59 55.86,66.04 57.17,67.36 58.04,67.36 58.76,68.07 58.76,70.5 58.98,70.72 59.56,70.72 v2(59.94,71.1)
  BOTTOM w0.14: U6600.AA23 v2(59.94,71.1) ; VRAM7001.F13 v2(36.34,73.3)
VMA_DQ48: length 30.6
  IN1 w0.102: v2(56.14,69.1) 55.89,68.86 55.89,61.65 53.69,59.45 47.84,59.45 47.32,59.97 41.34,59.97 37.58,63.73 37.17,63.73 v2(37.14,63.7)
  BOTTOM w0.14: VRAM7001.U11 v2(37.14,63.7) ; U6600.AD27 56.23,69 v2(56.14,69.1)
VMA_DQ49: length 35
  IN1 w0.102: v2(57.52,69.43) 57.46,69.43 57.1,69.06 57.1,68.3 56.36,67.56 56.36,61.47 53.9,59 47.65,59 47.1,59.56 41.13,59.56 37.38,63.32 36.96,63.32 36.57,63.7 v2(35.54,63.7)
  BOTTOM w0.14: v2(57.52,69.43) 57.52,70.11 57.72,70.31 58.12,70.31 58.51,70.7 U6600.AB25 ; VRAM7001.U13 v2(35.54,63.7)
VMA_DQ50: length 33.3
  IN1 w0.102: v2(57.52,68.61) 57.52,68.11 56.81,67.4 56.81,61.33 54.07,58.6 47.49,58.6 46.93,59.16 40.95,59.16 v2(37.19,62.92)
  BOTTOM w0.14: v2(57.52,68.61) 57.91,69 U6600.AD26 ; VRAM7001.T11 37.92,64.52 37.92,63.42 37.42,62.92 v2(37.19,62.92)
VMA_DQ51: length 36.6
  IN1 w0.102: v2(35.52,64.48) 35.15,64.11 35.15,63.49 36.63,62.01 37.53,62.01 40.78,58.75 46.76,58.75 47.32,58.19 54.35,58.19 57.3,61.15 57.3,67.26 57.99,67.94 57.99,69.07 v2(58.34,69.43)
  BOTTOM w0.14: U6600.AC25 58.34,69.45 v2(58.34,69.43) ; VRAM7001.T13 v2(35.52,64.48)
VMA_DQ52: length 29.9
  IN1 w0.102: v2(56.79,71.93) 56.28,71.42 54.86,71.42 54.01,70.57 54.01,68.56 52.47,67.02 51.11,67.02 45.68,61.6 42.01,61.6 38.96,64.65 38.96,66.75 38.43,67.27 37.52,67.27 v2(37.15,66.91)
  BOTTOM w0.14: v2(37.15,66.91) 37.54,67.3 VRAM7001.N11 ; U6600.AA27 56.79,71.85 v2(56.79,71.93)
VMA_DQ53: length 32.8
  IN1 w0.102: v2(57.57,71.92) 56.66,71.01 55.03,71.01 54.42,70.4 54.42,68.27 52.62,66.47 51.14,66.47 45.85,61.19 41.85,61.19 38.45,64.58 38.45,66.24 38.2,66.49 36.95,66.49 36.75,66.7 36.75,67.11 36.55,67.3 35.94,67.3 v2(35.53,67.71)
  BOTTOM w0.14: U6600.AA26 57.57,71.87 v2(57.57,71.92) ; VRAM7001.N13 v2(35.53,67.71)
VMA_DQ54: length 30.7
  IN1 w0.102: v2(37.15,67.74) 37.5,68.09 38.55,68.09 39.4,67.24 39.4,64.78 42.18,62 45.52,62 53.61,70.09 53.61,70.74 54.3,71.43 v2(54.3,71.88)
  BOTTOM w0.14: v2(54.3,71.88) 54.99,72.57 55.97,72.57 56.16,72.75 57.29,72.75 57.72,73.18 U6600.W26 ; v2(37.15,67.74) 37.16,67.74 37.16,67.75 37.51,68.1 VRAM7001.M11
VMA_DQ55: length 33.1
  IN1 w0.102: v2(58.31,72.73) 58.01,72.43 55.64,72.43 55.5,72.29 54.13,72.29 53.88,72.04 53.88,71.65 53.16,70.93 53.16,70.22 45.35,62.41 42.45,62.41 39.92,64.94 39.92,67.5 38.44,68.98 37.12,68.98 36.74,68.61 36.74,68.1 v2(36.34,67.7)
  BOTTOM w0.14: VRAM7001.M13 v2(36.34,67.7) ; v2(58.31,72.73) 58.35,72.73 U6600.Y25
VMA_DQ56: length 22.9
  IN3 w0.114: v2(43.55,64.51) 44.14,63.93 46.49,63.93 52.52,69.96 53.36,69.96 54.45,71.04 54.45,71.44 54.69,71.68 54.69,72.34 55.15,72.8 v2(55.15,74.46)
  BOTTOM w0.079: 56.18,76.49 56.21,76.51 56.65,76.51 56.92,76.78 57.38,76.78 57.7,76.46 U6600.R26
  BOTTOM w0.14: v2(55.15,74.46) 55.15,75.63 56.01,76.49 56.18,76.49 ; VRAM7001.U4 v2(43.55,64.51)
VMA_DQ57: length 23.9
  IN3 w0.114: v2(56.46,74.48) 56.46,74.67 55.82,75.31 54.55,75.31 54.28,75.04 54.28,72.95 53.48,72.15 53.48,71.21 53.23,70.95 52.33,70.95 46.25,64.88 44.64,64.88 v2(44.26,64.5)
  BOTTOM w0.102: U6600.T25 58.62,75.78 58.2,75.96 57.98,76.05 56.89,76.05 56.66,76.14 56.52,76.14 56.37,76.08 56.18,75.89 56.11,75.73
  BOTTOM w0.14: v2(56.46,74.48) 56.28,74.66 56.11,75.06 56.11,75.73 ; v2(44.26,64.5) 44.66,64.1 VRAM7001.U2
VMA_DQ58: length 25.8
  IN3 w0.114: v2(42.74,64.5) 42.31,64.93 42.31,69.43 43.36,70.48 45.74,70.48 46.44,71.17 49.59,71.17 52.04,73.63 52.04,73.89 52.8,74.64 52.8,76.71 54.04,77.96 54.57,77.96 v2(54.71,78.09)
  BOTTOM w0.14: U6600.N27 56.97,78.14 56.75,78.36 56.26,78.36 55.86,77.96 54.84,77.96 v2(54.71,78.09) ; v2(42.74,64.5) VRAM7001.T4
VMA_DQ59: length 19.5
  IN3 w0.114: v2(55.59,74.94) 55.48,74.83 54.99,74.83 54.71,74.55 54.71,72.84 53.78,71.92 53.78,70.97 53.19,70.38 52.35,70.38 46.41,64.44 v2(45.15,64.44)
  BOTTOM w0.079: U6600.R27 57,76.32 56.31,76.32 56.23,76.25
  BOTTOM w0.102: v2(55.59,74.94) 55.59,75.6 56.23,76.25
  BOTTOM w0.14: v2(45.15,64.44) 44.74,64.85 VRAM7001.T2
VMA_DQ60: length 19.1
  IN3 w0.114: v2(53.23,74.33) 53.2,74.33 52.7,73.83 52.7,73.7 49.41,70.41 46.47,70.41 45.84,69.77 44.12,69.77 43.94,69.59 43.94,68.1 v2(43.54,67.7)
  BOTTOM w0.102: U6600.V26 57.65,74.27 57.41,74.27 57.23,74.34 56.9,74.34 56.55,73.99
  BOTTOM w0.14: 56.55,73.99 53.52,73.99 53.23,74.28 v2(53.23,74.33) ; VRAM7001.N4 v2(43.54,67.7)
VMA_DQ61: length 16.3
  IN3 w0.114: v2(53.29,73.3) 52.89,73.3 49.29,69.69 47.95,69.69 47.14,68.88 44.86,68.88 44.76,68.78 44.76,68 v2(45.1,67.66)
  BOTTOM w0.14: VRAM7001.N2 v2(45.1,67.66) ; U6600.V27 56.94,73.98 56.69,73.74 55.83,73.74 55.74,73.65 53.64,73.65 v2(53.29,73.3)
VMA_DQ62: length 18.4
  IN3 w0.114: v2(42.75,67.65) 43.27,67.13 43.79,67.13 43.99,67.33 44.68,67.33 45.27,66.74 47.52,66.74 52.15,71.37 53.06,71.37 v2(53.09,71.4)
  BOTTOM w0.14: v2(42.75,67.65) 42.75,67.71 VRAM7001.M4 ; U6600.W27 56.06,73.18 55.75,72.87 54.71,72.87 53.82,71.98 53.82,71.64 53.55,71.37 53.13,71.37 53.1,71.4 v2(53.09,71.4)
VMA_DQ63: length 17.9
  IN3 w0.114: v2(45.15,68.5) 45.54,68.11 45.54,67.5 45.84,67.2 46.91,67.2 48.35,68.63 48.82,68.63 52.5,72.31 53.06,72.31 v2(53.09,72.28)
  BOTTOM w0.102: U6600.W25 58.74,73.26 58.47,73.53 56.9,73.53 56.8,73.43 55.92,73.43 55.76,73.26
  BOTTOM w0.14: v2(45.15,68.5) 45.14,68.5 VRAM7001.M2 ; v2(53.09,72.28) 53.71,72.28 54.7,73.26 55.76,73.26
VMA_WCK01: length 28.6
  IN1 w0.079: v2(42.74,92.1) 42.97,92.33 43.9,92.33 44.98,93.41 45.42,93.41 45.65,93.64 46.86,93.64 50.34,90.15 60.89,90.15 61.51,89.54 62.74,89.54 63.08,89.2 63.08,87.18 63.46,86.8 63.46,85.79 63.64,85.6 64.02,85.6 64.12,85.5 v2(64.12,85.2)
  BOTTOM w0.109: v2(64.12,85.2) U6600.D18 ; VRAM7000.D4 v2(42.74,92.1)
VMA_WCK01#: length 28.6
  IN1 w0.079: v2(64.12,86) 64.12,85.94 63.95,85.77 63.71,85.77 63.63,85.86 63.63,86.87 63.24,87.25 63.24,89.27 62.81,89.7 61.58,89.7 60.96,90.32 50.41,90.32 46.93,93.81 45.58,93.81 45.35,93.58 44.91,93.58 43.83,92.49 42.87,92.49 42.74,92.62 v2(42.74,92.9)
  BOTTOM w0.109: VRAM7000.D5 v2(42.74,92.9) ; U6600.C18 v2(64.12,86)
VMA_WCK23: length 34.2
  IN3 w0.089: v2(42.76,84.12) 42.56,84.32 42.27,84.32 42.04,84.54 41.9,84.9 41.9,86.51 42.09,86.97 42.74,87.63 42.98,87.63 43.3,87.95 43.77,88.14 48.1,88.14 49.44,88.7 50.13,88.7 52.63,89.73 54.58,91.68 62.17,91.68 62.58,91.28 62.58,90.1 63.31,89.37 63.31,87.18 63.7,86.79 64.15,86.6 64.38,86.6 65.21,85.78 65.56,85.78 v2(65.78,86)
  BOTTOM w0.109: v2(42.76,84.12) VRAM7000.P4 ; U6600.D17 65.38,85.6 v2(65.78,86)
VMA_WCK23#: length 34.3
  IN3 w0.089: v2(65.78,85.2) 65.89,85.31 65.89,85.49 65.79,85.59 65.13,85.59 64.3,86.41 64.11,86.41 63.59,86.63 63.12,87.1 63.12,89.29 62.39,90.02 62.39,91.2 62.09,91.49 54.66,91.49 52.74,89.57 50.17,88.5 49.48,88.5 48.14,87.95 43.8,87.95 43.41,87.79 43.06,87.44 42.82,87.44 42.25,86.86 42.09,86.47 42.09,84.94 42.21,84.65 42.35,84.51 42.68,84.51 42.74,84.57 v2(42.74,84.9)
  BOTTOM w0.109: VRAM7000.P5 42.34,84.5 v2(42.74,84.9) ; U6600.D16 66.18,85.6 v2(65.78,85.2)
VMA_WCK45: length 40.9
  IN1 w0.079: v2(42.74,74.9) 42.74,74.75 42.81,74.69 43.39,74.69 43.57,74.51 43.57,74.03 43.75,73.86 44.13,73.86 44.21,73.94 44.21,74.37 44.38,74.55 44.75,74.55 44.92,74.37 44.92,73.94 45,73.86 45.46,73.86 45.6,74 45.6,74.23 45.77,74.39 46.18,74.39 46.34,74.24 46.34,74.09 46.37,74.05 47.05,74.05 47.78,73.33 47.95,73.33 48.08,73.46 48.08,73.57 47.36,74.29 47.36,74.54 47.62,74.8 47.87,74.8 48.59,74.08 48.7,74.08 48.86,74.24 48.86,74.35 48.14,75.07 48.14,75.32 48.4,75.58 48.65,75.58 49.37,74.86 49.48,74.86 49.64,75.02 49.64,75.13 48.92,75.85 48.92,76.1 49.18,76.36 49.43,76.36 50.15,75.64 50.26,75.64 50.42,75.8 50.42,75.91 49.7,76.63 49.7,76.88 49.96,77.14 50.21,77.14 50.93,76.42 51.04,76.42 51.2,76.58 51.2,76.69 50.48,77.41 50.48,77.66 50.74,77.92 50.99,77.92 51.71,77.2 51.82,77.2 52.05,77.43 52.05,77.54 51.74,77.86 51.74,78.11 51.99,78.37 52.24,78.37 52.56,78.05 52.67,78.05 52.83,78.21 52.83,78.32 52.52,78.64 52.52,78.89 52.75,79.12 53.07,79.12 53.4,78.79 53.54,78.79 53.85,79.1 56.36,79.1 57.15,78.31 57.15,77.24 57.23,77.16 57.4,77.16 57.58,76.99 57.58,76.5 57.39,76.31 57.22,76.31 57.15,76.24 57.15,75.85 57.28,75.72 57.83,75.72 57.98,75.87 58.54,75.87 58.72,75.69 59.94,75.69 60.07,75.82 60.07,75.91 v2(59.94,76.04)
  BOTTOM w0.109: v2(42.74,74.9) VRAM7001.D4 ; v2(59.94,76.04) 59.92,76.04 U6600.T24
VMA_WCK45#: length 40.9
  IN1 w0.079: v2(42.74,74.1) 42.74,74.41 42.85,74.52 43.32,74.52 43.41,74.44 43.41,73.96 43.68,73.69 44.2,73.69 44.37,73.87 44.37,74.3 44.45,74.38 44.68,74.38 44.76,74.3 44.76,73.87 44.93,73.69 45.53,73.69 45.77,73.93 45.77,74.16 45.84,74.23 46.11,74.23 46.17,74.17 46.17,74.02 46.3,73.89 46.98,73.89 47.71,73.16 48.02,73.16 48.25,73.39 48.25,73.64 47.53,74.36 47.53,74.47 47.69,74.63 47.8,74.63 48.52,73.91 48.77,73.91 49.03,74.17 49.03,74.42 48.31,75.14 48.31,75.25 48.47,75.41 48.58,75.41 49.3,74.69 49.55,74.69 49.81,74.95 49.81,75.2 49.09,75.92 49.09,76.03 49.25,76.19 49.36,76.19 50.08,75.47 50.33,75.47 50.59,75.73 50.59,75.98 49.87,76.7 49.87,76.81 50.03,76.97 50.14,76.97 50.86,76.25 51.11,76.25 51.37,76.51 51.37,76.76 50.65,77.48 50.65,77.59 50.81,77.75 50.92,77.75 51.64,77.03 51.89,77.03 52.22,77.36 52.22,77.61 51.9,77.93 51.9,78.04 52.06,78.2 52.17,78.2 52.49,77.88 52.74,77.88 53,78.14 53,78.39 52.68,78.71 52.68,78.82 52.81,78.95 53,78.95 53.33,78.62 53.61,78.62 53.92,78.93 56.29,78.93 56.98,78.24 56.98,77.18 57.16,77 57.33,77 57.41,76.92 57.41,76.57 57.32,76.48 57.15,76.48 56.98,76.31 56.98,75.78 57.21,75.55 57.89,75.55 58.05,75.7 58.48,75.7 58.65,75.52 59.83,75.52 59.94,75.41 v2(59.94,75.17)
  BOTTOM w0.109: v2(42.74,74.1) VRAM7001.D5 ; v2(59.94,75.17) 59.89,75.17 U6600.U24
VMA_WCK67: length 31.9
  IN1 w0.079: v2(59.14,74.38) 58.94,74.18 58.94,74.05 58.67,73.77 53.18,73.77 51.62,72.21 51.62,70.21 50.5,69.09 50.28,69.09 50.04,69.32 49.92,69.32 49.77,69.18 49.77,68.97 49.99,68.76 49.99,68.51 49.64,68.17 49.21,68.17 48.98,68.41 48.81,68.41 48.63,68.23 48.63,68.15 48.99,67.78 48.99,67.5 48.75,67.26 48.48,67.26 47.97,67.76 47.8,67.76 47.64,67.6 47.64,67.48 48.16,66.96 48.16,66.72 47.88,66.44 47.61,66.44 47.33,66.73 47.19,66.73 47,66.55 47,66.4 47.32,66.08 47.32,65.77 45.41,63.86 42.63,63.86 41.98,64.51 41.98,66.42 42.24,66.67 42.51,66.67 v1(42.74,66.9)
  BOTTOM w0.102: v2(59.14,74.38) 59.14,74.38 U6600.V24
  BOTTOM w0.109: v1(42.74,66.9) VRAM7001.P4
VMA_WCK67#: length 32
  IN1 w0.079: v2(58.39,74.38) 58.68,74.38 58.77,74.29 58.77,74.12 58.6,73.94 53.11,73.94 51.45,72.28 51.45,70.28 50.43,69.25 50.35,69.25 50.11,69.49 49.85,69.49 49.6,69.25 49.6,68.9 49.82,68.69 49.82,68.58 49.57,68.34 49.28,68.34 49.05,68.58 48.74,68.58 48.46,68.3 48.46,68.08 48.83,67.71 48.83,67.57 48.68,67.42 48.55,67.42 48.04,67.93 47.73,67.93 47.47,67.67 47.47,67.41 47.99,66.89 47.99,66.79 47.81,66.61 47.68,66.61 47.39,66.9 47.12,66.9 46.84,66.62 46.84,66.33 47.15,66.01 47.15,65.84 45.34,64.03 42.7,64.03 42.15,64.58 42.15,66.35 42.31,66.51 42.81,66.51 42.92,66.39 42.92,66.19 42.83,66.1 v1(42.74,66.1)
  BOTTOM w0.102: v2(58.39,74.38) 58.39,74.33 U6600.V25
  BOTTOM w0.109: VRAM7001.P5 42.64,66.5 42.74,66.4 v1(42.74,66.1)
VR_SVID_ALERT#: length 39.1
  TOP w0.109: v1(103.37,92.24) 102.98,92.24 v1(102.64,92.58) 102.25,92.97 R703.1 R705.2 ; v1(80.93,108.63) 80.44,109.12 PR8801.2 80.32,109.12 79.97,108.77 PR8833.1
  IN1 w0.079: v1(80.93,108.63) 80.93,108.03 81.37,107.58 81.37,107.21 81.21,107.04 81.21,104.59 82.7,103.1 85.1,103.1 86.08,102.11 86.08,100.74 87.33,99.49 88.07,99.49 91.15,96.41 91.15,93.51 91.84,92.83 96.13,92.83 97.02,91.95 103.11,91.95 103.37,92.21 v1(103.37,92.24)
VR_SVID_CLK: length 37
  TOP w0.109: R706.2 102.89,91.73 103.55,91.73 v1(104.03,92.21) ; PR8835.1 PR8802.2 79.93,107.27 v1(80.09,107.11)
  IN1 w0.079: v1(104.03,92.21) 103.41,91.6 96.87,91.6 95.99,92.48 91.69,92.48 90.75,93.43 90.75,96.32 87.93,99.14 87.11,99.14 85.73,100.51 85.73,101.97 84.95,102.75 82.55,102.75 80.87,104.43 80.87,106.32 v1(80.09,107.11)
VR_SVID_DATA: length 35.1
  TOP w0.109: v1(80.92,109.34) 80.92,109.93 80.98,109.99 PR8831.1 80.98,110.42 81.13,110.56 81.25,110.56 81.44,110.75 PR8800.2 ; v1(99.65,92.38) 99.65,92.48 v1(100.03,92.87) 100.41,93.24 R704.1 100.84,93.22 R707.2
  IN1 w0.079: v1(99.65,92.38) 99.57,92.3 97.16,92.3 96.28,93.18 92.05,93.18 91.49,93.75 91.49,96.57 88.22,99.84 87.53,99.84 86.43,100.93 86.43,102.26 85.24,103.45 82.84,103.45 81.54,104.75 81.54,106.91 81.71,107.07 81.71,107.72 81.34,108.08 81.34,108.83 80.92,109.24 v1(80.92,109.34)
VRALERT#: length 23.7
  IN3 w0.089: v2(151.6,64.78) 151.12,64.3 149.54,64.3 149.45,64.21 148.28,64.21 147.29,65.2 147.14,65.2 146.32,66.02 145.12,66.02 144.44,66.71 143.22,66.71 142.99,66.48 140.4,66.48 140.16,66.72 140.16,67.07 139.9,67.33 138.71,67.33 138.46,67.59 137.44,67.59 137.34,67.69 137.34,68.28 v2(136.92,68.7)
  BOTTOM w0.109: D1600.1 153.38,66.99 R1614.1 R1613.1 153.4,65.86 153.4,65.18 153,64.78 v1(152.86,64.78) v2(151.6,64.78) ; v2(136.92,68.7) 136.93,68.69 137.14,68.69 U400.DB39
VRAVDDQ_FB: length 3.3
  TOP w0.178: 106.42,10.6 106.29,10.72 PU8700.6
  TOP w0.203: 106.42,10.6 107,10.02 PR8715.1 107,9.75 106.67,9.75 106.37,9.44 PR8714.1 106.37,8.96 PR8713.2
VRAVR_ON: length 52.6
  TOP w0.109: PR8827.1 80.47,104.73 v1(80.14,104.4)
  IN3 w0.089: v1(124.69,107.82) 123.98,107.11 122.96,107.11 122.27,107.8 111.94,107.8 111.22,108.51 107.28,108.51 105.68,110.11 97.17,110.11 96.6,109.53 92.75,109.53 91.93,110.35 89.83,110.35 88.39,108.91 84.05,108.91 80.77,105.63 80.77,104.59 80.58,104.4 v1(80.14,104.4)
  BOTTOM w0.109: R3309.2 124.03,106.02 124.03,107.16 v1(124.69,107.82)
VREF_VMA1_MOS: length 2.3
  TOP w0.109: R7001.2 30.4,95.81 30.07,95.48 v1(29.61,95.48) Q7000.3
VREF_VMA2_MOS: length 3.2
  BOTTOM w0.109: R7012.2 32,71.35 31.89,71.46 Q7001.3
VREFC_VMA1: length 13.5
  TOP w0.109: v1(32.2,89.99) 32.27,89.99 32.66,90.38 32.66,90.88 v1(32.26,91.29) 32.08,91.46 32.08,93.06 31.78,93.36 R7000.2 31.47,93.85 31.27,93.65 30.91,93.65 30.54,93.28 R7017.2 30.02,93.52 30.35,93.85 R7002.2 30.69,94.1 C7058.1 31.53,95.29 31.29,95.53 R7001.1
  BOTTOM w0.109: v1(32.2,89.99) 32.84,89.99 34.33,88.5 VRAM7000.J14
VREFC_VMA2: length 9
  BOTTOM w0.109: R7018.2 32.6,75.17 32.21,74.77 R7016.2 ; R7018.2 33.32,74.73 33.32,73.99 32.8,73.46 C7061.1 33.04,73.16 33.04,71.85 32.81,71.62 R7012.1 32.99,71.17 33.45,71.17 34.12,70.5 VRAM7001.J14 ; R7018.2 32.89,75.56 32.87,75.58 R7011.2
VRPVDDQ_PG: length 0.7
  TOP w0.203: PR8105.2 PR8700.2
VSYS: length 1.5
  BOTTOM w0.203: 191.81,89.07 U6100.8
  BOTTOM w0.254: R6103.1 191.8,89.73 191.8,89.07 191.81,89.07
WIFI_PCIE_REST#: length 9.5
  TOP w0.109: v1(183.46,83.72) 183.08,84.1 182.92,84.1 R4137.2 182.89,84.75 R4151.1 182.7,84.79 182.47,85.01 182.47,85.88 v1(182.21,86.15) 181.93,86.15 181.67,85.89 U4102.4
  BOTTOM w0.109: CON4100.52 185.34,80.56 185.49,80.72 185.49,81.8 C4113.2 183.78,83.51 183.67,83.51 v1(183.46,83.72)
WIRELESS_ON: length 6.1
  BOTTOM w0.109: R4121.2 173.84,80.94 CON4100.6 173.84,78.56 173.98,78.42 176.19,78.42 176.34,78.56 CON4100.16
WLAN_ALERT#: length 9.9
  BOTTOM w0.109: CON4100.62 187.84,78.56 190.79,75.6 192.18,75.6 193.39,76.81 193.39,77.74 TP4101.1
WLAN_DISABLE: length 87.5
  TOP w0.076: U4700.E4 v2(194.14,16.99)
  TOP w0.109: v1(200.76,71.39) 200.96,71.59 R4155.1
  IN1 w0.079: v1(201.83,59.51) 201.83,63.1 201,63.93 201,68.61 200.61,69 200.61,71.24 v1(200.76,71.39)
  IN2 w0.089: v1(178.46,36.85) 178.46,36.39 179.21,35.64 179.21,35 181.19,33.02 181.48,33.02 183.85,30.64 183.85,29.56 185.3,26.07 186.91,24.46 187.6,24.46 187.81,24.37 188.16,24.02 188.16,23.01 188.71,22.47 188.71,21.51 188.73,21.4 188.8,21.23 189.04,20.99 190.13,20.99 190.56,20.56 191.33,20.56 192.08,19.81 192.08,18.91 193.51,17.47 193.66,17.47 v2(194.14,16.99)
  BOTTOM w0.076: R4814.2 192.5,17.24 193.09,17.24 193.19,17.35 193.79,17.35 v2(194.14,16.99)
  BOTTOM w0.109: v1(178.46,36.85) 178.46,36.91 180.23,38.69 180.23,39.16 181.05,39.98 181.05,40.99 181.55,41.49 182.44,41.49 184.07,43.12 184.71,43.12 185.04,43.45 185.8,43.45 189.64,47.3 191.63,47.3 191.92,47.6 191.92,48.82 192.81,49.71 192.81,51.1 193.24,51.53 195.53,51.53 196.4,50.67 200.18,50.67 200.76,50.09 203.12,50.09 203.5,50.47 203.5,51.53 202.92,52.12 202.92,55.04 201.83,56.13 v1(201.83,59.51)
WLAN_I2CCLK: length 11.2
  BOTTOM w0.109: TP4102.1 194.25,77.7 193.62,77.06 193.62,76.72 192.28,75.37 190.7,75.37 187.76,78.31 187.52,78.31 187.34,78.48 187.34,78.48 CON4100.60
WLAN_I2DATA: length 10.3
  BOTTOM w0.109: TP4100.1 194.13,76.91 192.37,75.15 190.6,75.15 187.73,78.02 187.4,78.02 186.84,78.59 CON4100.58
WLAN_TRANSMIT_OFF#: length 71
  TOP w0.109: R4136.2 196.49,67.26 196.08,67.67 192.24,67.67 v1(191.99,67.43) 191.8,67.24 R4134.2 v1(191.13,66.75)
  IN1 w0.079: v1(180.59,74.34) 180,73.75 180,72.98 179.28,72.27 177.88,72.27 176.59,70.98 172.82,70.98 171.74,72.06 169.95,72.06 168.72,70.83 167.07,70.83 166.99,70.9 165.82,70.9 165.51,70.59 163.31,70.59 162.75,71.15 160.21,71.15 159.84,71.52 159.84,71.68 159.54,71.97 158.91,71.97 158.62,71.68 157.13,71.68 156.64,71.19 151.76,71.19 151.76,71.19 151.56,71.19 150.79,71.96 150.54,71.96 149.47,73.04 146.52,73.04 145.82,73.73 v2(145.82,73.95)
  IN2 w0.089: v1(193.26,75.13) 192.73,74.61 192.73,71.84 193.45,71.12 193.45,70.52 193.23,70.31 193.23,69.85 191.13,67.75 v1(191.13,66.75)
  BOTTOM w0.109: v1(193.26,75.13) 192.99,75.13 192.78,74.92 189.62,74.92 189.22,75.32 181.57,75.32 v1(180.59,74.34) ; v2(145.82,73.95) 145.66,73.95 U400.DW27
WLAN_WAKE#: length 10.4
  TOP w0.109: Q4112.1 187.54,70.49 187.74,70.7 R4140.1 187.55,71.14 187.07,70.66 187.07,69.29 v1(186.46,68.68) 186.46,68.34 R4139.1 185.86,68.01 184.87,69 v1(184.87,69.98)
  BOTTOM w0.109: CON4100.55 186.09,71.03 185.82,70.76 185.56,70.76 184.99,70.2 184.99,70.11 v1(184.87,69.98)
WP#_3: length 4.6
  TOP w0.109: R6839.2 56.69,92.66 55.34,94 TP6807.1 55.34,94.64 55.9,95.2 U6801.3
WR_CLK_DN: length 56.5
  IN1 w0.079: v2(146.15,65.66) 146.05,65.66 145.99,65.6 145.99,65.14 146.68,64.45 146.68,64.03 146.84,63.88 148.14,63.88 149.06,62.95 150.65,62.95 151.04,63.34 154.64,63.34 156.11,61.87 156.11,61.23 156.19,61.15 156.42,61.15 156.5,61.23 156.5,61.54 156.67,61.72 157.04,61.72 157.22,61.54 157.22,61.23 157.29,61.15 157.52,61.15 157.6,61.23 157.6,61.54 157.78,61.72 158.56,61.72 158.7,61.86 162.43,61.86 162.64,61.64 166.13,61.64 166.23,61.74 166.23,61.93 165.68,62.48 165.68,62.73 165.94,62.99 166.19,62.99 166.83,62.35 166.9,62.35 167.09,62.53 167.09,62.63 166.29,63.43 166.29,63.67 166.54,63.91 166.82,63.91 167.2,63.53 170.56,63.53 170.75,63.73 173.68,63.73 174.29,64.34 174.8,64.34 176.35,65.89 176.82,65.89 177,65.72 177,65.27 177.08,65.19 177.31,65.19 177.38,65.27 177.38,65.72 177.56,65.89 178.05,65.89 178.27,66.11 178.27,67.08 178.69,67.49 178.69,68.02 178.94,68.27 178.94,68.71 179.3,69.08 179.57,69.08 180.21,69.71 180.21,69.82 v1(180.09,69.94)
  BOTTOM w0.079: U400.DW44 144.64,66.8 144.6,66.75 144.6,66.59 144.64,66.55 144.88,66.55 145.08,66.34 145.74,66.34 145.94,66.15 145.94,65.84 146.12,65.66 v2(146.15,65.66)
  BOTTOM w0.109: CON4100.21 177.59,71.07 177.73,70.93 177.73,70.47 177.98,70.22 178.9,70.22 179.14,70.46 180.25,70.46 180.51,70.2 180.51,70.06 180.4,69.94 v1(180.09,69.94)
WR_CLK_DP: length 56.7
  IN1 w0.079: v1(180.67,69.57) 180.3,69.57 179.64,68.91 179.37,68.91 179.11,68.64 179.11,68.2 178.85,67.95 178.85,67.42 178.44,67.01 178.44,66.04 178.12,65.73 177.63,65.73 177.55,65.65 177.55,65.2 177.37,65.02 177.01,65.02 176.83,65.2 176.83,65.65 176.75,65.73 176.42,65.73 174.87,64.18 174.36,64.18 173.74,63.56 170.82,63.56 170.63,63.37 167.13,63.37 166.75,63.74 166.61,63.74 166.46,63.6 166.46,63.49 167.25,62.7 167.25,62.46 166.97,62.18 166.76,62.18 166.12,62.82 166.01,62.82 165.84,62.66 165.84,62.55 166.39,62 166.39,61.67 166.2,61.48 162.57,61.48 162.36,61.69 158.77,61.69 158.63,61.55 157.85,61.55 157.77,61.47 157.77,61.16 157.59,60.98 157.22,60.98 157.05,61.16 157.05,61.47 156.97,61.55 156.74,61.55 156.66,61.47 156.66,61.16 156.49,60.98 156.12,60.98 155.95,61.16 155.95,61.8 154.57,63.17 151.11,63.17 150.72,62.79 148.99,62.79 148.07,63.71 146.77,63.71 146.52,63.96 146.52,64.38 145.82,65.07 145.82,65.51 145.67,65.66 v2(145.61,65.66)
  BOTTOM w0.079: U400.DV44 144.44,66.66 144.44,66.53 144.58,66.39 144.81,66.39 145.02,66.19 145.68,66.19 145.78,66.08 145.78,65.82 145.62,65.66 v2(145.61,65.66)
  BOTTOM w0.109: CON4100.23 178.09,71.1 177.95,70.97 177.95,70.56 178.07,70.44 178.81,70.44 179.04,70.68 180.35,70.68 180.73,70.29 180.73,69.96 180.7,69.93 180.7,69.93 180.67,69.89 v1(180.67,69.57)
WR_LANE0_DN: length 57.3
  IN1 w0.079: v1(179.57,68.4) 179.8,68.4 179.87,68.34 179.87,66.28 177.78,64.19 175.91,64.19 175.51,63.79 174.52,63.79 173.9,63.17 171.09,63.17 170.9,62.98 168.32,62.98 166.42,61.09 162.32,61.09 162.11,61.3 158.96,61.3 158.24,60.58 157.26,60.58 155.53,58.86 155.53,58.68 154.05,57.19 151.59,57.19 149.88,58.91 149.88,61.36 147.91,63.33 146.22,63.33 145.92,63.62 145.92,64.28 145.24,64.96 145.24,65.52 144.04,66.71 143.1,66.71 142.86,66.96 142.86,67.21 v2(142.89,67.24)
  BOTTOM w0.109: U400.DT43 143.51,67.27 143.51,67.08 143.42,66.98 143.28,66.98 143.02,67.24 v2(142.89,67.24) ; CON4100.15 176.09,71.07 176.22,70.94 176.22,70.08 176.77,69.54 178.26,69.54 178.86,68.93 179.48,68.93 179.7,68.71 179.7,68.54 v1(179.57,68.4)
WR_LANE0_DP: length 57.3
  IN1 w0.079: v2(142.4,66.96) 142.62,66.96 143.04,66.55 143.98,66.55 145.07,65.45 145.07,64.89 145.76,64.21 145.76,63.55 146.15,63.16 147.84,63.16 149.71,61.29 149.71,58.84 151.52,57.03 154.12,57.03 155.7,58.61 155.7,58.79 157.33,60.42 158.31,60.42 159.03,61.14 162.04,61.14 162.25,60.92 166.49,60.92 168.39,62.82 170.97,62.82 171.16,63.01 173.97,63.01 174.59,63.62 175.58,63.62 175.98,64.02 177.85,64.02 180.03,66.21 180.03,68.32 180.11,68.4 v1(180.24,68.4)
  BOTTOM w0.109: v1(180.24,68.4) 180.24,68.49 179.57,69.16 178.96,69.16 178.35,69.76 176.86,69.76 176.45,70.18 176.45,70.96 176.59,71.1 CON4100.17 ; U400.DR44 142.56,66.8 v2(142.4,66.96)
WR_LANE1_DN: length 57.5
  IN1 w0.079: v2(145.96,66.74) 145.85,66.74 145.8,66.68 145.8,66.37 145.94,66.23 146.39,66.23 147.22,65.4 147.4,65.4 149.29,63.51 150.06,63.51 150.51,63.96 155.31,63.96 156.97,62.3 157.5,62.3 157.68,62.48 157.68,63.07 157.91,63.29 159.32,63.29 159.54,63.07 159.54,62.54 159.67,62.41 159.91,62.41 159.98,62.49 159.98,63.58 160.19,63.78 160.53,63.78 160.7,63.61 160.7,62.49 160.78,62.41 161.01,62.41 161.09,62.49 161.09,63.61 161.26,63.78 161.63,63.78 161.8,63.61 161.8,62.49 161.88,62.41 162.14,62.41 162.22,62.49 162.22,64.15 162.53,64.46 164.41,64.46 164.49,64.54 164.49,65.03 164.66,65.2 165.03,65.2 165.21,65.03 165.21,64.54 165.29,64.46 165.51,64.46 165.59,64.54 165.59,65.04 165.75,65.19 166.11,65.19 166.31,65 166.31,64.54 166.39,64.46 167.23,64.46 167.61,64.09 170.26,64.09 170.45,64.28 173.45,64.28 174.06,64.89 174.57,64.89 175.9,66.23 175.9,66.51 175.6,66.82 175.6,67.04 175.85,67.29 176.14,67.29 176.46,66.97 177.24,66.97 178.06,67.8 178.06,68.42 177.91,68.58 v1(177.73,68.58)
  BOTTOM w0.079: U400.DV43 144.33,67.45 144.27,67.39 144.27,67.25 144.31,67.2 144.92,67.2 145.08,67.36 145.58,67.36 145.73,67.21 145.73,66.89 145.88,66.74 v2(145.96,66.74)
  BOTTOM w0.109: v1(177.73,68.58) 177.89,68.74 177.89,68.91 177.79,69.01 176.46,69.01 175.8,69.67 175.57,69.67 174.72,70.53 174.72,70.94 174.59,71.08 CON4100.9
WR_LANE1_DP: length 57.7
  IN1 w0.079: v2(145.42,66.71) 145.48,66.71 145.63,66.55 145.63,66.3 145.87,66.06 146.32,66.06 147.15,65.23 147.33,65.23 149.22,63.34 150.13,63.34 150.58,63.79 155.24,63.79 156.9,62.14 157.57,62.14 157.85,62.41 157.85,63 157.98,63.13 159.25,63.13 159.38,63 159.38,62.47 159.6,62.24 159.98,62.24 160.15,62.42 160.15,63.51 160.26,63.62 160.46,63.62 160.53,63.54 160.53,62.42 160.71,62.24 161.08,62.24 161.25,62.42 161.25,63.54 161.33,63.62 161.56,63.62 161.64,63.54 161.64,62.42 161.81,62.24 162.21,62.24 162.39,62.42 162.39,64.08 162.6,64.3 164.48,64.3 164.66,64.47 164.66,64.96 164.73,65.04 164.96,65.04 165.04,64.96 165.04,64.47 165.22,64.3 165.58,64.3 165.76,64.47 165.76,64.97 165.82,65.03 166.05,65.03 166.14,64.93 166.14,64.47 166.32,64.3 167.16,64.3 167.54,63.92 170.33,63.92 170.52,64.11 173.52,64.11 174.13,64.73 174.64,64.73 176.07,66.16 176.07,66.58 175.76,66.89 175.76,66.97 175.92,67.13 176.07,67.13 176.39,66.81 177.31,66.81 178.23,67.73 178.23,68.29 v1(178.46,68.52)
  BOTTOM w0.079: U400.DU43 144.11,67.32 144.11,67.18 144.25,67.04 144.99,67.04 145.15,67.2 145.52,67.2 145.58,67.15 145.58,66.86 145.42,66.71 v2(145.42,66.71)
  BOTTOM w0.109: CON4100.11 175.09,71.08 174.94,70.93 174.94,70.62 175.66,69.9 175.89,69.9 176.56,69.23 177.88,69.23 178.11,69 178.11,68.87 v1(178.46,68.52)
WT_CLK_DN: length 66.6
  IN1 w0.079: v2(141.82,65.94) 142.21,65.56 144.12,65.56 144.46,65.21 144.46,64.61 145.06,64.02 145.06,62.6 146.76,60.9 147.8,60.9 149.13,59.57 149.13,58.52 151.24,56.42 154.29,56.42 156.26,58.39 156.26,58.54 157.23,59.5 158.18,59.5 159.26,60.59 161.81,60.59 162.02,60.37 166.86,60.37 167.53,61.04 168.67,61.04 169.69,62.06 171.46,62.06 171.85,62.46 173.8,62.46 174.14,62.12 174.72,62.12 175.41,62.81 176.19,62.81 176.35,62.65 177.28,62.65 181.33,66.7 181.33,68.93 181.79,69.39 182.32,69.39 184.15,71.22 187.41,71.22 189.68,73.5 v1(189.96,73.5)
  BOTTOM w0.109: CON4100.71 190.09,72.51 190.23,72.65 190.23,72.94 190.49,73.2 190.49,73.64 190.24,73.89 189.97,73.89 189.84,73.77 189.84,73.61 v1(189.96,73.5) ; v2(141.82,65.94) 141.82,65.92 U400.DN47
WT_CLK_DP: length 66.6
  IN1 w0.079: v1(189.42,74.04) 189.42,73.47 187.34,71.39 184.08,71.39 182.25,69.56 181.72,69.56 181.16,69 181.16,66.77 177.21,62.82 176.42,62.82 176.26,62.98 175.34,62.98 174.65,62.29 174.21,62.29 173.87,62.62 171.78,62.62 171.39,62.23 169.62,62.23 168.6,61.21 167.46,61.21 166.79,60.54 162.09,60.54 161.88,60.75 159.19,60.75 158.11,59.67 157.16,59.67 156.09,58.61 156.09,58.46 154.22,56.59 151.31,56.59 149.3,58.59 149.3,59.64 147.87,61.07 146.83,61.07 145.23,62.67 145.23,64.09 144.63,64.68 144.63,65.28 144.19,65.72 142.67,65.72 v2(142.45,65.94)
  BOTTOM w0.109: v1(189.42,74.04) 189.52,73.93 189.69,73.93 189.87,74.11 190.33,74.11 190.71,73.74 190.71,73.11 190.45,72.85 190.45,72.66 190.59,72.53 CON4100.73 ; U400.DN45 142.36,66.47 142.45,66.38 v2(142.45,65.94)
WT_LANE0_DN: length 66.1
  IN1 w0.079: v2(142.63,64.44) 142.63,64.66 142.68,64.7 142.89,64.7 143.02,64.58 143.61,64.58 144.4,63.79 144.4,62.48 146.77,60.1 147.81,60.1 148.58,59.34 148.58,58.3 151.07,55.81 154.46,55.81 156.83,58.18 156.83,58.27 157.51,58.95 158.45,58.95 159.54,60.03 161.54,60.03 161.75,59.82 167.12,59.82 167.76,60.46 169.05,60.46 169.95,61.36 171.69,61.36 172.18,61.86 173.57,61.86 173.86,61.57 175.71,61.57 175.98,61.31 176.57,61.31 177.14,61.87 178.23,61.87 179.27,62.92 179.27,63.17 178.98,63.46 178.98,63.57 179.14,63.73 179.25,63.73 179.54,63.44 179.79,63.44 180.38,64.03 180.38,64.81 180.58,65.01 180.69,65.01 180.99,64.71 181.24,64.71 181.5,64.97 181.5,65.22 181.2,65.52 181.2,65.63 181.36,65.79 181.47,65.79 181.77,65.49 182.02,65.49 182.28,65.75 182.28,66 181.98,66.3 181.98,66.41 182.47,66.9 182.47,67.01 183.18,67.72 183.18,68.38 182.95,68.62 182.74,68.62 v1(182.45,68.91)
  BOTTOM w0.109: CON4100.65 188.59,71.05 188.72,70.91 188.72,70.62 188.12,70.01 187.18,70.01 186.29,69.12 185.15,69.12 184.78,69.49 183.89,69.49 183.04,68.64 182.71,68.64 v1(182.45,68.91) ; v2(142.63,64.44) 143.01,64.82 U400.DR49
WT_LANE0_DP: length 66.1
  IN1 w0.079: v2(142.43,65.05) 142.61,64.87 142.96,64.87 143.09,64.74 143.68,64.74 144.56,63.86 144.56,62.55 146.84,60.27 147.88,60.27 148.75,59.41 148.75,58.37 151.14,55.98 154.39,55.98 156.66,58.25 156.66,58.34 157.44,59.12 158.38,59.12 159.47,60.2 161.61,60.2 161.82,59.99 167.05,59.99 167.69,60.63 168.98,60.63 169.88,61.53 171.62,61.53 172.11,62.03 173.63,62.03 173.93,61.74 175.78,61.74 176.05,61.47 176.5,61.47 177.07,62.04 178.16,62.04 179.1,62.99 179.1,63.1 178.81,63.39 178.81,63.64 179.07,63.9 179.32,63.9 179.61,63.61 179.72,63.61 180.21,64.1 180.21,64.88 180.51,65.18 180.76,65.18 181.06,64.87 181.17,64.87 181.33,65.04 181.33,65.15 181.03,65.45 181.03,65.7 181.29,65.96 181.54,65.96 181.84,65.66 181.95,65.66 182.11,65.82 182.11,65.93 181.81,66.23 181.81,66.48 182.31,66.97 182.31,67.08 183.02,67.78 183.02,68.31 182.88,68.45 182.75,68.45 v1(182.45,68.15)
  BOTTOM w0.109: CON4100.67 189.09,71.03 188.94,70.88 188.94,70.52 188.21,69.79 187.28,69.79 186.38,68.89 185.06,68.89 184.68,69.27 183.99,69.27 183.14,68.42 182.72,68.42 v1(182.45,68.15) ; v2(142.43,65.05) 142.13,65.05 142.01,64.93 142.01,64.8 U400.DN49
WT_LANE1_DN: length 65.4
  IN1 w0.079: v1(185.56,70.14) 186.01,70.14 186.08,70.21 186.53,70.21 186.89,69.85 186.89,69.18 186.5,68.79 185.07,68.79 184.61,69.25 184.12,69.25 183.77,68.9 183.77,67.48 183.16,66.87 183.16,65.84 178.46,61.14 177.19,61.14 176.8,60.76 175.75,60.76 175.49,61.02 173.67,61.02 173.58,60.93 172.44,60.93 172.17,60.66 170.03,60.66 169.27,59.91 168.1,59.91 167.46,59.27 161.29,59.27 161.08,59.48 159.76,59.48 158.68,58.4 157.83,58.4 154.64,55.21 150.89,55.21 148.97,57.12 148.18,57.12 147.72,57.58 147.72,58.14 147.8,58.22 147.8,58.67 147.51,58.96 147.13,58.96 143.58,62.51 143.58,63.23 143.16,63.65 142.48,63.65 142.06,64.07 142.06,64.55 141.75,64.85 141.75,65.16 141.54,65.37 141.38,65.37 v2(141.18,65.18)
  BOTTOM w0.109: U400.DM47 141.18,65.22 v2(141.18,65.18) ; CON4100.59 187.09,71.07 187.25,70.91 187.25,70.71 187.11,70.56 186.43,70.56 186.01,70.14 v1(185.56,70.14)
WT_LANE1_DP: length 65.4
  IN1 w0.079: v1(186,69.59) 186,69.9 186.15,70.04 186.46,70.04 186.72,69.78 186.72,69.25 186.43,68.96 185.14,68.96 184.68,69.42 184.05,69.42 183.6,68.97 183.6,67.55 182.99,66.94 182.99,65.91 178.39,61.31 177.12,61.31 176.73,60.92 175.82,60.92 175.55,61.19 173.6,61.19 173.51,61.1 172.37,61.1 172.1,60.83 169.96,60.83 169.2,60.08 168.03,60.08 167.39,59.44 161.36,59.44 161.15,59.65 159.69,59.65 158.61,58.57 157.76,58.57 154.57,55.38 150.95,55.38 149.04,57.29 148.25,57.29 147.89,57.65 147.89,58.07 147.97,58.15 147.97,58.74 147.58,59.13 147.2,59.13 143.75,62.58 143.75,63.29 143.23,63.82 142.55,63.82 142.23,64.14 142.23,64.62 141.92,64.92 141.92,65.23 141.61,65.54 141.27,65.54 141.18,65.63 v2(141.18,65.94)
  BOTTOM w0.109: U400.DK47 140.78,65.65 140.78,65.78 140.94,65.94 v2(141.18,65.94) ; v1(186,69.59) 186,69.82 186.52,70.34 187.2,70.34 187.48,70.62 187.48,70.94 187.59,71.05 CON4100.61
WW_LED#: length 1.7
  TOP w0.109: v1(206.63,3.38) 206.4,3.15 TP4200.1
  BOTTOM w0.109: v1(206.63,3.38) 207.12,3.87 207.14,3.87 R4205.1
WW_LED#_C: length 10.9
  BOTTOM w0.109: R4205.2 207.31,5.08 207.24,5.15 204.67,5.15 204.6,5.23 201.43,5.23 200.07,3.87 200.07,2.21 200.16,2.12 CON4202.10
WWAN_ASPM_EXIT: length 136.3
  TOP w0.109: v1(195.7,7.41) 195.28,7.84 194.61,7.84 v1(194.57,7.8) 194.51,7.75 R4208.2 193.78,6.8 193.62,6.65 R817.1 193.32,6.65 193.27,6.69 U4200.6
  IN1 w0.079: v1(156.62,44.07) 157.05,44.07 157.17,44.19 160.01,44.19 161.64,45.82 161.64,46.17 163.14,47.67 163.54,47.67 164.07,48.2 164.47,48.2 165.5,49.23 166.41,49.23 166.59,49.4 168.52,49.4 169.11,50 171.89,50 172.79,50.91 174.47,50.91 174.87,50.51 176.55,50.51 177.39,49.67 178.56,49.67 179.67,48.57 182.07,48.57 183.29,47.34 184.22,47.34 v1(184.33,47.24)
  IN2 w0.089: v1(195.7,7.41) 196.09,7.41 196.8,6.7 200.87,6.7 201.24,6.32 203.45,6.32 203.59,6.46 204.63,6.46 204.99,6.82 204.99,7.15 205.84,8 205.84,10.19 207.41,11.76 207.41,12.71 209.1,14.39 209.89,14.39 210.24,14.74 210.24,15.12 209.72,15.64 209.53,15.64 208.79,16.38 208.79,17.44 209.8,18.46 209.8,20.47 208.96,21.31 208.65,21.31 206.87,23.09 206.7,23.09 205.77,24.02 205.77,24.18 204.25,25.71 203.62,25.71 202.82,26.51 201.99,26.51 201.68,26.82 200.28,26.82 200,27.1 199.46,27.1 199.23,27.33 199.23,27.56 197.65,29.13 197.52,29.19 197.4,29.31 193.68,29.31 193.03,29.95 192.73,29.95 190.15,32.53 190.15,34.1 186.12,38.13 186.12,39.03 186.45,39.35 186.45,43.54 184.37,45.61 184.37,46.88 184.3,46.95 184.3,47.22 v1(184.33,47.24) ; v1(156.62,44.07) 155.88,44.07 153.53,46.42 152.52,46.42 151.24,47.71 149.23,47.71 147.33,49.61 146.33,49.61 141.46,54.48 v1(141.46,55.6)
  BOTTOM w0.079: 138.71,58.26 138.71,58.72 138.74,58.75 138.74,59.23 138.67,59.29 138.67,60.63 138.18,61.11 138.18,62.07 U400.DC53
  BOTTOM w0.109: v1(141.46,55.6) 140.53,55.6 138.71,57.42 138.71,58.26
WWAN_CONFIG_0: length 103.4
  IN2 w0.089: v1(180.14,45.5) 178.83,44.19 178.83,42.87 181.31,40.39 181.31,38.81 182.71,37.42 182.71,36.34 186.93,32.12 186.93,30.18 187.17,29.59 189.11,27.65 189.24,27.65 190.13,26.76 190.13,26.15 191.06,25.22 191.06,24.83 191.94,23.95 195.13,23.95 196.06,23.01 197.33,23.01 197.95,22.39 197.95,22.08 198.67,21.36 201.62,21.36 202.03,20.95 202.03,20.69 202.79,19.92 202.79,18.92 203.07,18.64 203.5,18.64 203.71,18.44 203.71,15.78 203.41,15.48 202.99,15.48 202.4,14.89 202.4,13.87 201.77,13.23 201.77,12.86 200.62,11.7 199.99,11.7 198.58,10.29 v1(198.53,10.29)
  IN3 w0.089: v2(149.46,67.42) 148.93,67.42 148.45,66.95 148.45,66.59 148.67,66.37 149.15,66.37 149.2,66.42 150.33,66.42 150.75,65.99 151.79,65.99 152.27,65.79 152.61,65.46 152.79,65.02 152.79,64.62 153.5,63.91 156.69,63.91 157.72,62.88 157.72,62.38 156.1,60.77 156.1,60.18 157.68,58.6 158.44,58.6 158.8,58.24 160.29,58.24 160.95,58.9 161.54,58.9 162.37,58.07 162.37,57.51 165.93,53.95 166.89,53.95 167.82,53.03 168.51,53.03 171.01,50.53 171.5,50.53 172.68,49.36 173.36,49.36 173.82,48.9 175.24,48.9 178.64,45.5 v1(180.14,45.5)
  BOTTOM w0.109: v1(198.53,10.29) 197.77,10.29 197.41,9.94 CON4202.21 ; v2(149.46,67.42) 149.65,67.42 R1573.2
WWAN_CONFIG_0_R: length 6.2
  BOTTOM w0.109: R1573.1 149.87,68.26 149.42,67.81 R1514.2 149.05,67.54 148.07,67.54 146.33,69.27 145.1,69.27 U400.DW38
WWAN_CONFIG_2: length 100
  IN2 w0.089: v2(150.54,67.27) 150.8,67.02 150.8,65.91 150.2,65.31 150.2,63.64 148.62,62.06 148.62,58.51 149.05,58.08 149.05,57.81 150.95,55.9 151.94,55.9 155.08,52.77 v1(155.08,52.23) ; v1(164.82,41.1) 164.48,41.43 164.48,42.14 164.71,42.37 167.85,42.37 169.82,40.41 171.21,40.41 173.04,38.58 173.04,38.05 173.42,37.66 173.42,36.69 175.92,34.19 175.92,33.69 178.51,31.1 178.51,29.67 180.69,27.5 180.69,24.18 183.07,21.8 183.07,20.04 184.75,18.36 184.75,17.87 185.93,16.69 186.84,16.69 187.32,16.21 187.66,16.21 188.35,15.52 188.35,13.22 187.75,12.63 185.22,12.63 185.15,12.7 182.31,12.7 v2(181.92,12.32)
  IN3 w0.089: v1(155.08,52.23) 155.08,52.07 155.47,51.69 155.83,51.69 157.68,49.84 157.68,48.26 158.85,47.09 158.85,45.23 161.05,43.03 161.44,43.03 161.83,42.63 161.83,42.17 163.04,40.96 164.68,40.96 v1(164.82,41.1)
  BOTTOM w0.109: R1512.2 150.78,67.27 v2(150.54,67.27) 150.26,66.98 149.14,66.98 149,67.13 148.66,67.13 148.48,67.31 148.02,67.31 146.24,69.08 144.64,69.08 U400.DV38 ; CON4202.75 183.92,9.86 183.72,10.06 182.04,10.06 181.79,10.31 181.79,12.18 v2(181.92,12.32)
WWAN_CONFIG_3: length 130.5
  TOP w0.109: v1(196.77,7.59) 197.25,8.07 197.84,8.07 198.05,8.29 Q4200.2
  IN2 w0.089: v1(208.23,8.74) 208.23,9.57 209.88,11.22 209.88,11.88 211.29,13.29 211.29,16.36 210.63,17.02 210.63,20.63 209.15,22.11 209.15,22.47 208.1,23.52 208.1,23.85 207.74,24.2 207.41,24.2 207.03,23.82 206.58,23.82 206.13,24.27 206.13,24.83 204.54,26.42 203.92,26.42 203.12,27.22 202.28,27.22 201.15,28.35 198.94,28.35 197.85,29.44 197.73,29.49 197.52,29.7 193.79,29.7 193.18,30.31 192.88,30.31 190.86,32.32 190.86,33.89 187.74,37.01 187.74,37.79 v1(186.74,38.78)
  IN3 w0.089: v1(186.74,38.78) 186.74,39.29 186.23,39.8 185.62,39.8 184.41,38.59 183.74,38.59 182.75,39.58 182.75,43.21 182.2,43.75 182.2,44.18 181.83,44.56 179.33,44.56 175.17,48.72 173.74,48.72 173.28,49.18 172.6,49.18 171.43,50.35 170.93,50.35 168.44,52.85 167.74,52.85 166.82,53.77 165.85,53.77 162.19,57.43 162.19,58 161.47,58.72 161.02,58.72 160.36,58.06 158.72,58.06 158.36,58.42 157.61,58.42 155.89,60.14 155.89,61.8 157.07,62.97 157.07,63.28 156.61,63.73 153.43,63.73 152.61,64.55 152.61,64.99 152.46,65.36 152.17,65.64 151.8,65.79 150.6,65.79 149.67,65.41 148.99,65.41 148.28,66.12 148.28,67.9 v2(148.13,68.04)
  BOTTOM w0.079: U400.DT38 143.93,69.69 145.08,69.69 145.32,69.44 146.56,69.44 147.11,68.89
  BOTTOM w0.109: 147.11,68.89 147.96,68.04 v2(148.13,68.04) 148.36,67.81 R1511.2 ; v1(196.77,7.59) 197.46,6.91 200.02,6.91 200.73,6.2 203.3,6.2 203.62,6.52 204.66,6.52 204.76,6.56 205.33,7.12 205.65,7.12 206.8,8.27 207.33,8.27 207.67,8.61 208.1,8.61 v1(208.23,8.74) 208.23,9.93 208.18,9.98 D4200.2
WWAN_CONFIG_3_C: length 9.9
  BOTTOM w0.109: CON4202.1 202.41,9.53 202.99,10.11 v1(205.08,10.11) 205.84,10.11 206.04,10.31 D4200.1 205.91,10.74 202.79,10.74 202.66,10.87 R4203.2
WWAN_DET#: length 10.8
  TOP w0.076: v2(194.14,17.64) U4700.E6
  BOTTOM w0.076: v2(194.14,17.64) 194.06,17.73 193.32,17.73 193.06,17.99 192.35,17.99 192.17,18.16 R4800.1
  BOTTOM w0.109: R4800.1 191.97,18.05 191.69,17.78 191.44,17.78 191.23,17.57 190.88,17.57 190.69,17.39 190.69,16.83 190.19,16.33 190.19,15.47 190.45,15.21 190.45,14.22 190.65,14.02 v1(190.65,13.56) 190.73,13.56 191.16,13.12 191.16,12.28 191.22,12.23 191.22,12.1 R4212.2
WWAN_FWUPD#: length 98.8
  TOP w0.109: v2(180.27,16.2) 181.49,14.98 182.04,14.98 183.06,13.97 183.06,11.53 183.3,11.29 183.3,10.21 v1(183.91,9.6) 183.91,8.82 184.47,8.25 187.92,8.25 188.29,7.88 R4214.2 188.63,8.06 188.63,8.14 R1520.1 189.08,8.82 189.3,9.04 190.12,9.04 190.9,8.26 195.3,8.26 195.76,8.72 Q4200.1
  IN2 w0.089: v2(141.71,64.3) 141.7,64.3 141.69,64.29 141.69,62.35 142.52,61.52 142.52,60.85 142.36,60.69 142.36,58.69 142.74,58.31 142.74,57.44 141.87,56.57 141.87,54.33 146.4,49.8 147.4,49.8 149.31,47.89 151.31,47.89 151.97,47.23 153.29,47.23 153.82,46.69 153.82,46.39 155.75,44.46 156.78,44.46 157.11,44.13 157.66,44.13 158.72,43.06 158.72,42.05 159.92,40.85 160.96,40.85 161.66,40.15 162.11,40.15 162.28,40.33 165.41,40.33 165.88,39.85 166.59,39.85 166.77,40.03 167.12,40.03 168.57,38.58 169.34,38.58 169.73,38.96 171.06,38.96 171.91,38.11 171.91,37.51 172.29,37.13 172.29,36.06 172.57,35.79 172.57,35.31 174.75,33.12 174.75,31.77 178.05,28.46 178.05,25.01 179.33,23.73 179.33,17.14 v2(180.27,16.2)
  BOTTOM w0.109: U400.DL52 141.42,63.51 141.71,63.8 141.71,64.3 v2(141.71,64.3)
WWAN_OFF#: length 30.3
  TOP w0.076: 198.59,14.13 198.4,14.32 198.28,14.32 198.03,14.57 198.03,15.05 U4700.K2
  TOP w0.109: v2(204.51,11.28) 203.72,11.28 203.48,11.51 200.55,11.51 200.52,11.53 R4810.2 200.09,11.53 199.63,11.99 199.63,13.19 199.54,13.28 v1(199.54,13.54) 199.31,13.76 198.96,13.76 198.59,14.13 ; v1(205.97,3.99) 205.74,4.21 R4202.2
  IN1 w0.079: v1(205.97,3.99) 205.97,4.46 205.89,4.54 205.89,4.9 206.3,5.31 207.01,5.31 207.72,6.02 207.72,7.03 207.26,7.49 204.87,7.49 204.51,7.86 v2(204.51,11.28)
  BOTTOM w0.109: v1(205.97,3.99) 205.92,3.93 205.08,3.93 204.24,4.77 201.62,4.77 200.53,3.68 200.53,2.82 201.16,2.18 CON4202.6
WWAN_TRANSMIT_OFF#: length 131.4
  TOP w0.109: D4201.1 204.21,9.8 204.44,10.03 206.42,10.03 v2(207.01,10.62) 207.35,10.28 R4204.1 ; v1(137.64,57.71) 137.43,57.71 R811.1 137.42,58.61 137.42,58.99 137.62,59.19 137.62,59.93 137.48,60.07 137.48,60.84 137.96,61.32 137.96,62.59 137.88,62.67 137.88,64.75 v2(138.11,64.99)
  IN1 w0.079: v2(207.01,10.62) 207.01,11.76 208.36,13.11 208.36,21.8 207.04,23.13 205.39,23.13 203.58,24.94 203.58,25.6 202.62,26.56 202.05,26.56 201.63,26.73 201.33,27.03 200.96,27.03 199.85,28.13 195.99,28.13 195.15,28.98 193.63,28.98 192.85,29.76 192.44,29.76 190.23,31.97 190.23,34.07 189.15,35.15 189.15,37.62 188.39,38.38 188.39,41.02 188.52,41.14 188.52,44.17 188.67,44.32 188.67,44.8 188.44,45.02 186.47,45.02 185.07,46.43 185.07,47.38 184.61,47.84 184.1,47.84 183.91,47.66 183.42,47.66 182.2,48.88 179.8,48.88 178.69,49.99 177.52,49.99 176.68,50.83 176.08,50.83 175.44,51.46 174.54,51.46 174.3,51.22 172.66,51.22 171.75,50.31 168.98,50.31 168.39,49.72 166.46,49.72 166.28,49.55 165.37,49.55 164.34,48.52 163.94,48.52 163.41,47.98 163.01,47.98 161.32,46.3 161.32,45.96 160.07,44.7 159.56,44.7 159.18,45.08 157.08,45.08 156.76,44.76 154.68,44.76 153.49,45.95 152.91,45.95 151.43,47.44 150.5,47.44 149.48,48.45 149.48,48.94 149.02,49.39 147.9,49.39 147.19,50.11 146.82,50.11 142.24,54.69 142.24,55.81 141.33,56.71 140.81,56.71 140.22,57.3 140.22,57.92 140.05,58.1 140.05,62.89 139.01,63.93 139.01,64.48 138.5,64.99 v2(138.11,64.99)
  BOTTOM w0.109: v2(138.11,64.99) 137.72,64.59 U400.DC49
WWAN_TRANSMIT_OFF#_R: length 27.6
  TOP w0.109: v1(206.4,4.62) 206.4,3.76 206.14,3.5 206.14,3.12 205.89,2.87 205.89,2.64 205.61,2.36 R4201.2 206.15,1.6 208.28,1.6 v1(208.56,1.88) 208.56,2.23 209.12,2.79 209.12,7.64 208.66,8.1 208.66,9.29 208.4,9.55 207.19,9.55 207.03,9.4 206.38,9.4 D4201.2 206.76,9.83 R4204.2
  BOTTOM w0.109: CON4202.8 200.67,2.18 200.3,2.54 200.3,3.78 201.53,5 204.34,5 205.18,4.16 205.53,4.16 206,4.62 v1(206.4,4.62)
WWAN_WAKE#: length 163.5
  TOP w0.109: R4211.1 189.99,4.52 v1(189.74,4.76) R1132.2 188.87,6.04 v1(189.2,6.37)
  IN1 w0.079: v1(163.53,49.98) 164.2,49.98 164.9,50.68 165.72,50.68 166.61,51.58 168.96,51.58 169.9,52.52 172.58,52.52 172.93,52.87 173.97,52.87 174.59,52.25 175.77,52.25 176.19,51.83 176.84,51.83 177.3,52.29 177.86,52.29 178.47,52.9 180.11,52.9 180.36,52.66 180.36,52.34 182.23,50.48 184.45,50.48 185.09,49.83 v1(185.21,49.83)
  IN2 w0.089: v2(141.86,84.12) 141.86,84.17 143.13,85.44 144.61,85.44 145.64,84.41 147.63,84.41 148.09,84.87 149.27,84.87 150.81,83.34 152.98,83.34 153.63,83.99 154.01,83.99 154.49,83.51 156.18,83.51 158.98,80.72 158.98,76.39 158.48,75.88 158.48,75.16 159.2,74.43 159.2,72.52 158.51,71.82 158.51,70.6 158.56,70.55 158.56,69.01 158.17,68.62 158.17,67.64 159.7,66.11 159.7,64.52 160.29,63.93 160.29,60.76 161.41,59.63 161.41,58.74 160.81,58.14 160.81,56.72 161.88,55.65 161.88,55.05 163.05,53.89 163.05,50.47 v1(163.53,49.98) ; v1(189.2,6.37) 189.63,5.94 191.79,5.94 192.05,5.69 194.42,5.69 195.74,7.01 196.24,7.01 196.73,6.52 200.79,6.52 201.17,6.14 203.55,6.14 203.68,6.27 204.7,6.27 205.26,6.82 205.26,7.11 206.04,7.9 206.04,9.07 207.82,10.84 207.82,11.3 207.6,11.52 207.6,12.64 209.18,14.22 209.97,14.22 210.41,14.66 210.41,15.19 209.78,15.83 209.59,15.83 208.96,16.46 208.96,17.37 209.98,18.39 209.98,20.54 209.04,21.49 208.72,21.49 206.94,23.26 206.78,23.26 205.95,24.09 205.95,24.26 204.32,25.89 203.7,25.89 202.9,26.69 202.06,26.69 201.73,27.02 200.99,27.02 199.84,28.17 198.86,28.17 197.75,29.29 197.62,29.34 197.48,29.49 193.75,29.49 193.11,30.13 192.8,30.13 190.33,32.6 190.33,34.17 186.3,38.2 186.3,38.95 186.63,39.28 186.63,43.61 185.25,44.99 185.25,46.34 184.89,46.7 184.89,48.65 185.21,48.97 v1(185.21,49.83)
  BOTTOM w0.109: U400.DN5 142.15,84.42 v2(141.86,84.12)
WWAN_WAKE#_R: length 2.5
  TOP w0.109: R4211.2 189.99,3.2 v1(189.46,2.66)
  BOTTOM w0.109: v1(189.46,2.66) 189.16,2.37 CON4202.54
XDP_BPM0: length 100.2
  TOP w0.109: v2(109.65,88.39) 109.34,88.69 R1032.2 ; v1(43.94,45.32) 43.1,44.48 CON7703.22
  IN3 w0.089: v1(43.94,45.32) 44.71,45.32 46.36,46.96 51.08,46.96 51.51,47.39 59.33,47.39 67.61,55.67 67.61,61.31 69.74,63.44 77.94,63.44 80.16,65.66 80.16,66.57 86.01,72.42 86.01,74.84 86.55,75.39 86.55,76.21 89.42,79.08 89.42,79.42 91.49,81.49 91.49,82.95 92.97,84.44 94.2,84.44 101.02,91.26 103.56,91.26 103.99,90.83 105.59,90.83 106.44,89.98 108.7,89.98 109.65,89.02 v2(109.65,88.39)
  BOTTOM w0.109: U400.Y2 109.09,86 109.09,86.54 109.25,86.7 109.25,87.99 v2(109.65,88.39)
XDP_BPM1: length 101.4
  TOP w0.109: R1033.2 110.82,89.4 v2(110.56,89.15) ; CON7703.24 42.84,44.98 v1(43.24,45.39)
  IN3 w0.089: v1(43.24,45.39) 43.81,45.95 44.91,45.95 46.88,47.92 49.38,47.92 49.5,47.8 59.45,47.8 67.43,55.78 67.43,61.39 69.67,63.62 77.87,63.62 79.96,65.71 79.96,66.65 85.83,72.52 85.83,74.92 86.36,75.45 86.36,76.29 89.23,79.16 89.23,79.48 91.3,81.55 91.3,83.03 92.9,84.63 94.13,84.63 100.95,91.45 103.62,91.45 104.06,91.01 105.69,91.01 106.54,90.16 109.56,90.16 v2(110.56,89.15)
  BOTTOM w0.079: 109.87,87.82 109.64,87.6 109.64,85.5 U400.AB4
  BOTTOM w0.109: v2(110.56,89.15) 110.56,88.52 109.87,87.82
XDP_PCH_SPI0_SI: length 3
  TOP w0.109: R1238.2 159.94,73.89 160.26,73.57 R1236.2 160.54,73.57 160.82,73.85 160.82,74.35 TP1200.1 161.26,74.8 R1239.1
XDP_TCK: length 79
  TOP w0.109: v1(49.53,53.98) 49.03,53.48 CON7703.57
  IN2 w0.089: v1(49.53,53.98) 49.87,53.98 50.47,54.58 52.1,54.58 54.14,52.54 56.26,52.54 58.93,49.86 66.01,49.86 70.38,54.23 71.52,54.23 75.76,58.47 76.6,58.47 81.16,63.02 81.16,63.37 83.23,65.44 83.23,68.57 87.27,72.61 87.27,75.5 91.3,79.53 91.81,79.53 92.15,79.86 92.15,81.93 93.55,83.34 v1(93.72,83.34)
  BOTTOM w0.109: v1(93.72,83.34) 93.19,83.86 R609.2 93.19,84.66 93.38,84.85 93.85,84.85 94.29,84.4 R617.1 94.72,84.63 94.85,84.76 95.3,84.76 95.34,84.8 95.44,84.9 95.44,84.9 95.96,85.42 TP604.1 98.55,85.42 100.31,83.66 101.14,83.66 U400.B6
XDP_TDI_CPU: length 99.7
  TOP w0.109: CON7703.56 43.51,52.98 43.82,52.66 43.82,52.49 44.58,51.74 44.58,50.03 45.34,49.27 45.34,38.66 46.64,37.35 50.82,37.35 53.83,40.36 55.47,40.36 57.36,42.26 58.01,42.26 v1(58.65,42.89)
  IN3 w0.089: v1(58.65,42.89) 59.24,43.48 67.1,43.48 78.29,54.68 78.73,54.68 80.29,56.24 81.18,56.24 86.23,61.3 86.68,61.3 90.14,64.76 90.14,66.34 91.74,67.94 91.74,68.52 92.75,69.52 92.75,70.12 95.21,72.59 97.15,72.59 97.44,72.88 97.44,73.23 98.48,74.27 98.48,78.31 98.14,78.65 v1(98.14,78.96)
  BOTTOM w0.109: U400.A12 99.64,81.23 98.91,80.5 98.91,80.08 98.14,79.32 v1(98.14,78.96) 97.78,78.6 TP603.1 98.17,77.94 98.17,76.63 98,76.46 R613.2
XDP_TDO_CPU: length 107.3
  TOP w0.109: v1(59.28,42.89) 58.33,41.94 57.37,41.94 55.56,40.13 53.93,40.13 50.92,37.12 46.55,37.12 45.09,38.58 45.09,49.19 44.35,49.94 44.35,51.58 43.95,51.98 CON7703.52
  IN3 w0.089: v1(59.28,42.89) 59.67,43.28 67.19,43.28 78.38,54.48 78.78,54.48 80.36,56.07 81.29,56.07 86.32,61.09 86.79,61.09 90.35,64.65 90.35,66.24 91.92,67.82 91.92,68.45 92.92,69.45 92.92,70.01 95.25,72.34 98.63,72.34 99.21,72.92 99.21,74.42 98.69,74.94 98.69,78.88 v1(98.78,78.97)
  BOTTOM w0.109: U400.D12 101.87,81.25 101.52,80.91 99.76,80.91 99.16,80.31 99.16,79.72 98.78,79.34 v1(98.78,78.97) 98.47,78.66 98.47,76.19 98.34,76.06 98.34,73.65 98.15,73.46 R612.2 97.78,73.47 TP602.1 97.51,74.21 97.43,74.13 96.83,74.13 96.64,74.32 96.64,74.68 R616.1
XDP_TMS_CPU: length 83.1
  TOP w0.109: CON7703.58 42.78,53.48 43.05,53.21 43.72,53.21 v1(44.41,52.53)
  IN2 w0.089: v1(44.41,52.53) 45.28,52.53 45.74,52.99 52.63,52.99 56.28,49.34 57.7,49.34 58.33,48.71 66.76,48.71 70.89,52.85 71.84,52.85 76.31,57.32 78.51,57.32 80.53,59.33 80.53,60.14 84.38,63.99 84.38,65.78 86.4,67.8 86.9,67.8 87.4,68.3 87.4,68.8 87.61,69.02 88.96,69.02 92.3,72.36 92.3,75.62 97.02,80.34 97.02,80.83 97.79,81.6 v1(97.79,82.09)
  BOTTOM w0.109: R611.2 96.21,82.62 TP601.1 96.75,82.09 v1(97.79,82.09) 98.58,82.09 98.93,82.45 100.16,82.45 100.41,82.7 101.1,82.7 U400.B9
XDP_TRST#: length 96.4
  TOP w0.109: v2(104.06,87.87) 104.06,87.88 104.03,87.9 104.03,88.65 TP600.1 ; v1(43.17,52.48) CON7703.54
  IN2 w0.089: v2(105.07,84.55) 104.9,84.55 104.03,85.42 101.14,85.42 100.85,85.13 99.32,85.13 99.03,85.42 98.48,85.42 96.46,83.4 96.46,82.04 96.06,81.64 96.06,80.24 93.67,77.86 92.86,77.86 92.64,77.77 90.96,76.08 90.96,71.85 88.65,69.55 87.33,69.55 86.97,69.19 86.36,69.19 83.79,66.62 83.79,65.26 81.68,63.15 81.68,62.68 76.93,57.93 76,57.93 71.68,53.61 70.87,53.61 66.59,49.32 58.73,49.32 57.7,50.36 57.37,50.36 56.76,49.75 56.44,49.75 51.81,54.38 51,54.38 50.11,53.49 45.87,53.49 45.31,52.93 43.62,52.93 v1(43.17,52.48)
  BOTTOM w0.109: R615.2 104.07,90.37 103.96,90.27 103.96,87.98 104.06,87.88 v2(104.06,87.87) 104.06,87.76 105.33,86.49 105.33,85.33 105.08,85.09 104.74,85.09 U400.K4 104.65,84.97 v2(105.07,84.55)
XTAL_38P4M_IN: length 4.2
  BOTTOM w0.109: R1424.2 142.32,88.89 142.32,88.07 142.11,87.86 142.11,87.07 U400.DL1
XTAL_38P4M_IN_R: length 6.7
  BOTTOM w0.109: R1424.1 141.84,90.09 v1(141.84,90.68) R1426.1 141.84,92.01 C1404.2 141.9,93.25 141.9,95.08 Y1401.1
XTAL_38P4M_OUT: length 3.9
  BOTTOM w0.109: R1429.2 142.64,88.03 142.39,87.78 142.39,86.92 141.74,86.27 U400.DM1
XTAL_38P4M_OUT_R: length 6.3
  BOTTOM w0.109: R1429.1 142.29,90.35 R1426.2 142.29,91.88 C1406.2 142.18,92.6 v1(142.09,92.69) 142.4,93 142.4,94.67 Y1401.3
XTAL_SSIN: length 6.5
  BOTTOM w0.109: R6805.1 75.33,92.1 75.33,91.79 74.39,90.85 74,90.85 73.75,90.6 73.64,90.6 73,89.96 72.61,89.96 71.57,88.92 71.57,88.61 71.16,88.2 U6600.A10
XTAL_TCP0_25MHZ_IN: length 4.4
  BOTTOM w0.109: U5900.L9 186.65,98.39 186.65,99.63 187.32,100.3 v1(187.73,100.3) 187.95,100.52 188.26,100.52 188.71,100.98 R5964.1
XTAL_TCP0_25MHZ_IN_R: length 4.2
  BOTTOM w0.109: Y5900.1 188.83,103.69 188.71,103.56 188.71,103.09 C5916.2 189.3,101.43 R5964.2
XTAL_TCP0_25MHZ_OUT: length 3.5
  BOTTOM w0.109: R5965.1 187.42,100.98 v1(186.47,100.02) 186.42,99.97 U5900.M9
XTAL_TCP0_25MHZ_OUT_R: length 4.5
  BOTTOM w0.109: Y5900.3 188.48,104.41 188.48,102.38 C5917.2 188.17,102.08 R5965.2
N16923117: length 1.7
  TOP w0.109: R3300.2 23.42,45.11 23.59,45.28 C3300.2 23.46,45.67 R3301.1
N17285542: length 1.4
  TOP w0.109: R5111.1 163.29,59.03 162.89,59.43 U5100.2
N17285546: length 1.2
  TOP w0.109: R5112.1 167.2,60.55 167.14,60.62 U5100.9

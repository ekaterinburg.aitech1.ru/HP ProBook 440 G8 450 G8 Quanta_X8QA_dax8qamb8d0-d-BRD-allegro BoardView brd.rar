# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC2#: length 13.2
  TOP w0.109: v2(141.11,66.93) 141.11,66.91 141.62,66.4 142.75,66.4 142.94,66.21 142.94,65.81 142.64,65.51 142.32,65.51 141.94,65.13 141.94,64.67 142.18,64.42 142.18,63.26 142.63,62.81 143.14,62.81 143.62,62.34 143.62,58.35 143.53,58.26 143.53,57.87 143.81,57.59 R407.2
  BOTTOM w0.109: v2(141.11,66.93) 140.87,66.7 U400.DK45
USB_OC3#: length 10.8
  TOP w0.109: v2(140.54,66.89) 140.54,66.89 140.4,66.76 140.4,64.33 142.15,62.58 142.92,62.58 143.15,62.36 143.15,60.7 142.54,60.09 142.54,59.1 142.37,58.92 R1306.2
  BOTTOM w0.079: v2(140.54,66.89) 140.54,66.79 U400.DJ45
USB_VBUSSENSE: length 1.4
  TOP w0.109: v2(137.09,80.58) 136.82,80.85 R1301.2
  BOTTOM w0.109: U400.DC12 v2(137.09,80.58)
USBC_ALT_AUX_NBIAS: length 80.3
  TOP w0.109: R6117.2 196.26,97.53 196.7,97.97 196.7,98.42 v1(196.43,98.69)
  IN1 w0.079: v1(148.8,91.46) 148.49,91.46 148.43,91.52 148.43,91.86 148.81,92.24 150.65,93 154.62,93 156.34,91.29 167.27,91.29 169.02,89.54 175.34,89.54 176.11,90.3 179.34,90.3 180.31,91.27 182.21,91.27 183.07,92.12 185.28,92.12 185.4,92.07 186.76,92.07 187.03,92.18 188.89,92.18 189.68,92.97 189.68,99.68 191.46,101.47 194.74,101.47 196.71,99.5 196.71,98.96 v1(196.43,98.69)
  BOTTOM w0.079: 146.45,85.04 146.44,85.03 146.39,85.03 145.3,83.93 145.3,83.83 145.11,83.64 144.7,83.64 144.61,83.73 144.61,84.11 144.47,84.25 144.35,84.25 144.25,84.15 144.08,84.15 144.02,84.08 144.02,83.87 144,83.84 143.67,83.84 U400.DT6
  BOTTOM w0.109: v1(148.8,91.46) 148.61,91.46 148.46,91.3 148.46,91.09 148.74,90.8 149.2,90.8 149.86,90.14 149.86,87.21 150.64,86.43 150.64,85.39 150.12,84.86 148.35,84.86 147.86,85.35 146.76,85.35 146.5,85.09 146.45,85.04
USBC_ALT_AUX_PBIAS: length 81.1
  TOP w0.109: R6119.2 197.33,97.56 196.92,97.97 196.92,98.42 v1(197.19,98.69)
  IN1 w0.079: v1(197.19,98.69) 196.87,99.01 196.87,99.57 194.81,101.64 191.39,101.64 189.51,99.75 189.51,93.04 188.82,92.35 186.99,92.35 186.73,92.24 185.44,92.24 185.31,92.29 183,92.29 182.14,91.44 180.24,91.44 179.27,90.47 176.04,90.47 175.27,89.71 169.09,89.71 167.34,91.46 156.41,91.46 154.69,93.17 150.61,93.17 148.71,92.39 148.26,91.93 148.26,91.68 v1(148.04,91.46)
  BOTTOM w0.079: U400.DN4 142.47,85.06 142.74,85.33 143.79,85.33 144.04,85.08 144.04,84.95 144.77,84.22 145.36,84.22 146.28,85.14 146.28,85.19 146.29,85.2
  BOTTOM w0.109: v1(148.04,91.46) 148.23,91.26 148.23,90.99 148.65,90.58 149.11,90.58 149.63,90.05 149.63,87.11 150.42,86.33 150.42,85.48 150.02,85.09 148.44,85.09 147.96,85.57 146.66,85.57 146.29,85.2
USBP1+: length 73.1
  TOP w0.109: v1(194.83,78.86) 195.05,79.08 198.06,79.08 198.73,79.76 198.73,80.58 197.89,81.42 U6203.3
  IN1 w0.079: v2(138.06,82.42) 137.47,83.01 137.1,83.01 136.93,83.18 136.93,84.17 137.29,84.52 137.86,84.52 138.73,85.39 139.62,85.39 140.16,85.93 146.75,85.93 147.49,86.67 148.07,86.67 150.05,84.69 156.35,84.69 156.67,84.38 157.36,84.38 158.08,85.09 163.32,85.09 164.08,84.33 165.05,84.33 165.95,83.42 171,83.42 171.3,83.12 171.55,83.12 172.97,81.7 178.42,81.7 180.17,79.94 180.32,79.94 180.88,79.39 190.76,79.39 190.9,79.53 192.36,79.53 192.72,79.38 193.17,79.38 193.48,79.08 194.61,79.08 v1(194.83,78.86)
  BOTTOM w0.109: U400.DC11 138.06,82.21 v2(138.06,82.42)
USBP1+_C: length 8.4
  BOTTOM w0.109: CON6201.3 203.92,92.39 203.73,92.2 203.27,92.2 202.89,92.58 201.93,92.58 201.83,92.68 v1(201.83,93.09) 201.27,92.53 201.05,92.53 200.67,92.15 200.25,92.15 200.05,91.95 200.05,91.71 C6210.1 199.63,91.29 199.63,90.11 199.91,89.82 L6200.1
USBP1+_CHA: length 6.3
  TOP w0.109: v1(198.95,85.73) 199.22,85.73 199.28,85.79 199.28,86 199.12,86.15 197.86,86.15 197.72,86.01 197.72,85.91 197.89,85.74 U6203.10
  BOTTOM w0.109: L6200.2 200.32,87.53 200.4,87.45 200.4,86.78 200.05,86.43 199.61,86.43 199.3,86.11 199.3,85.83 199.2,85.73 v1(198.95,85.73)
USBP1-: length 73
  TOP w0.109: v1(194.89,79.56) 194.89,79.38 194.96,79.31 197.96,79.31 198.51,79.85 198.51,80.48 197.39,81.6 U6203.2
  IN1 w0.079: v2(137.22,82.66) 137.22,82.67 136.77,83.12 136.77,84.23 137.22,84.68 137.79,84.68 138.66,85.55 139.56,85.55 140.01,86 140.01,86.02 140.09,86.1 146.68,86.1 147.42,86.84 148.14,86.84 150.12,84.86 156.42,84.86 156.74,84.55 157.29,84.55 158.01,85.26 163.39,85.26 164.15,84.49 165.12,84.49 166.02,83.59 171.07,83.59 171.37,83.29 171.62,83.29 173.04,81.87 178.49,81.87 180.24,80.11 180.39,80.11 180.95,79.55 190.69,79.55 190.83,79.7 192.39,79.7 192.76,79.55 193.24,79.55 193.55,79.25 194.84,79.25 194.89,79.29 v1(194.89,79.56)
  BOTTOM w0.109: U400.DC9 137.7,82.29 137.7,82.19 137.58,82.07 137.47,82.07 137.22,82.31 v2(137.22,82.66)
USBP1-_C: length 8.4
  BOTTOM w0.109: CON6201.2 203.92,91.86 203.8,91.98 203.17,91.98 202.79,92.36 202.03,92.36 201.83,92.15 v1(201.83,91.82) 201.34,92.31 201.15,92.31 200.76,91.93 200.34,91.93 200.27,91.86 200.27,91.71 C6210.2 200.69,91.29 200.69,89.93 200.92,89.71 L6200.4
USBP1-_CHA: length 6.3
  TOP w0.109: v1(199.71,85.71) 199.5,85.92 199.5,86.09 199.22,86.38 197.77,86.38 197.5,86.11 197.5,85.81 197.39,85.7 U6203.11
  BOTTOM w0.109: L6200.3 200.92,87.37 200.63,87.09 200.63,86.69 200.14,86.21 199.71,86.21 199.52,86.02 199.52,85.9 v1(199.71,85.71)
USBP2+: length 147
  TOP w0.109: v1(33.69,41.25) 33.43,41.51 32.5,41.51 32.25,41.76 31.58,41.76 R3410.2
  IN1 w0.079: v1(33.69,41.25) 33.69,41.46 33.79,41.56 34.56,41.56 34.85,41.27 38.39,41.27 39.06,41.95 47.43,41.95 48.11,42.62 49.96,42.62 50.85,43.52 51.36,43.52 55.02,47.17 58.88,47.17 63.31,51.61 63.31,52.89 65.65,55.22 65.65,56.75 67.63,58.73 67.63,62.23 74.05,68.65 75.73,68.65 76.48,69.4 76.48,70.11 77.68,71.32 77.68,71.93 78.57,72.82 78.8,72.82 81.03,75.05 81.03,75.78 81.41,76.16 81.72,76.16 83.26,77.7 83.26,79.63 86.74,83.11 89.77,83.11 90.4,83.74 91.23,83.74 92.38,84.89 94.47,84.89 98.22,88.64 102.97,88.64 103.76,89.43 107.49,89.43 109.9,87.02 111.11,87.02 112.57,85.56 112.57,83.64 113.29,82.92 115.34,82.92 115.49,83.07 117.13,83.07 118.42,84.36 118.8,84.36 119.4,84.97 119.58,84.97 122.14,87.52 122.14,88.06 122.9,88.82 122.9,89.26 123.53,89.89 124.65,89.89 126.27,91.51 130.65,91.51 131.14,92.01 131.79,92.01 132.28,91.51 134.68,91.51 136.25,89.94 136.25,89.79 v2(136.07,89.61)
  BOTTOM w0.079: 136.46,86.79 136.46,86.77 136.45,86.76 136.45,85.57 136.54,85.48 136.54,85.33 136.42,85.21 136.42,84.87 136.64,84.66 136.81,84.66 136.89,84.58 U400.DA5
  BOTTOM w0.109: v2(136.07,89.61) 136.09,89.61 136.2,89.49 136.2,89.11 136.46,88.85 136.46,86.79
USBP2+_C: length 2.7
  TOP w0.109: R3410.1 30.12,41.64 29.94,41.64 v1(29.57,41.27)
  BOTTOM w0.109: CON3400.32 28.95,41.25 29.23,41.53 29.51,41.53 29.57,41.46 v1(29.57,41.27)
USBP2-: length 146.9
  TOP w0.109: v1(33.69,42.01) 33.42,41.73 32.59,41.73 32.35,41.98 31.57,41.98 R3408.2
  IN1 w0.079: v2(136.61,89.59) 136.42,89.79 136.42,90.01 134.75,91.68 132.35,91.68 131.86,92.17 131.07,92.17 130.58,91.68 126.2,91.68 124.58,90.06 123.46,90.06 122.73,89.33 122.73,88.89 121.97,88.13 121.97,87.59 119.51,85.13 119.34,85.13 118.73,84.53 118.35,84.53 117.06,83.24 115.42,83.24 115.27,83.08 113.36,83.08 112.74,83.71 112.74,85.63 111.18,87.19 109.97,87.19 107.56,89.6 103.69,89.6 102.9,88.81 98.15,88.81 94.4,85.06 92.31,85.06 91.16,83.91 90.33,83.91 89.7,83.27 86.67,83.27 83.09,79.7 83.09,77.77 81.65,76.32 81.34,76.32 80.87,75.85 80.87,75.12 78.73,72.98 78.5,72.98 77.51,72 77.51,71.39 76.31,70.18 76.31,69.47 75.66,68.82 73.98,68.82 67.46,62.3 67.46,58.8 65.48,56.82 65.48,55.29 63.14,52.96 63.14,51.68 58.81,47.34 54.95,47.34 51.29,43.68 50.79,43.68 49.89,42.79 48.04,42.79 47.36,42.11 38.99,42.11 38.32,41.44 34.92,41.44 34.63,41.72 33.98,41.72 v1(33.69,42.01)
  BOTTOM w0.079: U400.DA4 136.89,84.9 136.81,84.82 136.7,84.82 136.58,84.94 136.58,85.14 136.7,85.26 136.7,85.54 136.61,85.63 136.61,86.69 136.66,86.73
  BOTTOM w0.109: 136.66,86.73 136.66,88.93 136.4,89.19 136.4,89.37 v2(136.61,89.59)
USBP2-_C: length 2.7
  TOP w0.109: R3408.1 30.4,41.99 30.28,41.86 29.91,41.86 v1(29.74,42.03)
  BOTTOM w0.109: CON3400.33 29.13,41.75 29.13,41.75 29.47,41.75 v1(29.74,42.03)
USBP4+: length 80.2
  IN1 w0.079: v1(200.22,64.44) 200,64.67 199.25,64.67 198.32,65.6 198.32,71.65 197.26,72.71 197.26,74.19 196.08,75.37 194.71,75.37 193.93,74.59 192.31,74.59 189.29,77.6 188.45,77.6 188.03,78.02 186.73,78.02 186.33,77.62 185.24,77.62 184.72,78.14 180.36,78.14 179.8,78.7 179.66,78.7 177.9,80.46 172.44,80.46 171.07,81.83 169.3,81.83 169.11,82.01 168.2,82.01 167.93,81.75 164.53,81.75 164,82.27 156.97,82.27 156.57,82.67 153.81,82.67 153.18,83.3 149.07,83.3 148.68,83.69 146.56,83.69 146.3,83.95 146.12,84.13 144.84,84.13 144.58,83.87 143.4,83.87 142.77,84.49 141.66,84.49 140.87,83.71 138.9,83.71 138.52,83.32 v2(138.52,83.29)
  BOTTOM w0.079: v2(138.52,83.29) 138.3,83.29 138.05,83.04 U400.DC8
  BOTTOM w0.109: L6201.2 199.49,66.36 199.49,64.91 199.71,64.7 199.97,64.7 v1(200.22,64.44)
USBP4+_C: length 9.1
  BOTTOM w0.109: L6201.1 199.16,68.96 199.06,69.07 199.06,70.6 C6211.1 199.34,71.17 200.51,72.34 200.94,72.34 v1(201.48,72.89) 202.03,72.34 202.85,72.34 203.21,72.69 203.76,72.69 203.92,72.85 CON6202.3
USBP4-: length 80.2
  IN1 w0.079: v2(137.95,83.43) 138.13,83.43 138.58,83.88 140.8,83.88 141.59,84.66 142.84,84.66 143.47,84.04 144.51,84.04 144.77,84.3 146.19,84.3 146.42,84.07 146.63,83.86 148.75,83.86 149.14,83.47 153.25,83.47 153.88,82.84 156.64,82.84 157.04,82.44 164.07,82.44 164.6,81.91 167.86,81.91 168.13,82.18 169.18,82.18 169.37,81.99 171.14,81.99 172.51,80.62 177.97,80.62 179.73,78.87 179.87,78.87 180.43,78.31 184.79,78.31 185.31,77.79 186.26,77.79 186.66,78.19 188.1,78.19 188.52,77.77 189.36,77.77 192.38,74.76 193.86,74.76 194.64,75.54 196.15,75.54 197.43,74.26 197.43,72.78 198.49,71.72 198.49,65.67 199.32,64.83 200.15,64.83 200.22,64.91 v1(200.22,65.2)
  BOTTOM w0.109: U400.DC7 137.86,83.43 v2(137.95,83.43) ; L6201.3 199.71,66.24 199.71,65.01 199.8,64.92 200.12,64.92 200.22,65.02 v1(200.22,65.2)
USBP4-_C: length 9.1
  BOTTOM w0.109: CON6202.2 203.92,72.36 203.81,72.47 203.3,72.47 202.95,72.11 201.98,72.11 v1(201.48,71.62) 200.98,72.12 200.6,72.12 199.66,71.18 199.66,71.01 C6211.2 200.16,70.51 L6201.4
USBP5+: length 73.2
  IN1 w0.079: v2(194.26,82.61) 194.01,82.36 193.9,82.36 193.39,82.88 187.79,82.88 186.81,82.47 186.34,82 185.86,82 185.37,82.5 185.15,82.5 184.39,83.26 183.36,83.26 182.8,83.82 180.76,83.82 180.56,83.62 174.8,83.62 171.95,86.47 170.56,86.47 169.64,87.4 167.47,87.4 166.65,88.21 158.52,88.21 158.48,88.25 157.85,88.25 154.18,91.93 151.25,91.93 149.04,89.72 142.28,89.72 141.3,88.74 141.3,88.1 139.23,86.03 138.64,86.03 137.7,85.09 137.11,85.09 136.44,84.42 136.44,82.93 136.62,82.75 136.62,82.5 136.75,82.37 136.75,81.96 136.68,81.89 136.56,81.89 v2(136.39,82.06)
  BOTTOM w0.109: v2(194.26,82.61) 194.26,82.5 194.31,82.44 194.7,82.44 195.2,82.94 195.2,83.54 195.11,83.63 194.98,83.63 194.84,83.49 U6100.23 ; U400.DA12 136.39,81.39 v2(136.39,82.06)
USBP5-: length 73.2
  IN1 w0.079: v2(137.1,81.94) 136.91,82.12 136.91,82.44 136.78,82.56 136.78,82.82 136.6,83 136.6,84.35 137.18,84.93 137.76,84.93 138.7,85.87 139.3,85.87 139.72,86.29 139.73,86.29 141.47,88.03 141.47,88.67 142.35,89.55 149.11,89.55 151.32,91.76 154.11,91.76 157.78,88.09 158.41,88.09 158.45,88.04 166.58,88.04 167.4,87.23 169.57,87.23 170.49,86.31 171.88,86.31 174.73,83.45 180.63,83.45 180.83,83.65 182.73,83.65 183.29,83.09 184.32,83.09 185.08,82.33 185.3,82.33 185.79,81.84 186.41,81.84 186.9,82.33 187.82,82.71 193.32,82.71 193.84,82.19 194.13,82.19 v2(194.26,82.06)
  BOTTOM w0.109: v2(194.26,82.06) 194.41,82.22 194.79,82.22 195.42,82.85 195.42,83.63 195.2,83.85 194.96,83.85 194.92,83.89 U6100.22 ; v2(137.1,81.94) 137.1,81.49 136.99,81.38 136.78,81.38 136.68,81.48 U400.DA11
USBP6+: length 172.3
  TOP w0.109: v1(35.4,25.45) 35.13,25.72 34.96,25.72 34.59,25.34 31.01,25.34 30.2,24.53 30.2,23.99 29.86,23.66 28.95,23.66 28.44,23.14 26.81,23.14 25.69,24.26 21.56,24.26 21.02,23.73 17.87,23.73 14.31,20.17 11.73,20.17 11.09,20.81 10.68,20.81 10.55,20.68 CON7602.13
  IN1 w0.079: v2(137.91,89.36) 138.17,89.1 138.24,89.1 138.71,88.63 138.71,87.26 137.61,86.15 136.64,86.15 135.51,85.02 135.51,84.13 135.26,83.87 135.26,82 134.94,81.68 134.94,81.09 134.95,81.08 134.95,75.94 133.38,74.37 133.38,73.67 132.16,72.45 128.69,72.45 127.31,71.06 125.6,71.06 124.75,70.21 108.22,70.21 107.95,70.48 102.33,70.48 101.5,69.64 94.26,69.64 92.42,67.8 91.46,67.8 90.16,66.5 90.16,65.12 84.19,59.16 84.19,56.25 64.2,36.26 57.35,36.26 49.52,28.43 40.86,28.43 38.16,25.73 35.68,25.73 v1(35.4,25.45)
  BOTTOM w0.109: v2(137.91,89.36) 137.91,89.35 137.74,89.18 137.49,89.18 136.95,88.65 136.95,86.43 U400.DA1
USBP6-: length 172.3
  TOP w0.109: v1(35.4,26.21) 35.13,25.95 35.13,25.95 35.12,25.94 34.87,25.94 34.49,25.57 30.92,25.57 29.98,24.62 29.98,24.09 29.77,23.88 28.86,23.88 28.35,23.37 26.9,23.37 25.78,24.49 21.46,24.49 20.93,23.95 17.77,23.95 14.22,20.39 11.82,20.39 11.18,21.04 10.66,21.04 10.52,21.18 CON7602.12
  IN1 w0.079: v1(35.4,26.21) 35.4,26.01 35.51,25.9 38.09,25.9 40.79,28.6 49.45,28.6 57.28,36.43 64.13,36.43 84.03,56.32 84.03,59.23 89.99,65.19 89.99,66.57 91.39,67.97 92.35,67.97 94.19,69.81 101.43,69.81 102.26,70.65 108.02,70.65 108.29,70.38 124.68,70.38 125.53,71.23 127.24,71.23 128.62,72.61 132.09,72.61 133.21,73.74 133.21,74.44 134.78,76 134.78,81.75 135.1,82.07 135.1,83.94 135.35,84.19 135.35,85.09 136.58,86.31 137.54,86.31 138.55,87.32 138.55,88.57 138.18,88.94 138.04,88.94 137.91,88.82 v2(137.91,88.82)
  BOTTOM w0.109: v2(137.91,88.82) 137.91,88.92 137.84,88.99 137.57,88.99 137.15,88.57 137.15,85.97 U400.DA2
USBP7+: length 188.3
  IN3 w0.089: v2(139.06,88.96) 139.04,88.97 138.81,88.97 138.68,88.84 138.68,87.28 138.91,87.05 140.18,87.05 140.95,87.82 141.61,87.82 141.95,87.48 145.23,87.48 145.87,86.84 149.09,86.84 150.81,85.11 153.07,85.11 154.52,83.66 157.94,83.66 160.5,81.1 163.4,81.1 165.55,78.95 166.22,78.95 166.67,78.51 166.67,77.07 167.68,76.06 168.17,76.06 173.72,70.51 173.72,67.42 177.88,63.26 182.37,63.26 184.35,61.28 184.35,58.35 185.24,57.45 185.24,56.51 186.85,54.9 186.85,53.87 189.82,50.9 189.82,49.91 189.29,49.37 189.29,48.3 190.22,47.37 190.22,41.5 190.42,41.3 190.42,37.83 190.16,37.57 190.16,35.35 191.25,34.27 191.25,32.43 192.8,30.88 193.41,30.88 194.55,29.73 197.77,29.73 198.11,29.6 199.99,29.6 202.72,26.87 202.97,26.87 204.54,25.3 204.54,24.13 207.29,21.38 207.96,21.38 210.37,18.98 210.37,12.26 207.46,9.35 205.03,9.35 203.21,7.53 201.73,7.53 200.95,6.75 196.65,6.75 196.49,6.92 196.06,6.92 195.76,6.61 194.79,6.61 194.64,6.77 193.09,6.77 192.76,6.44 189.68,6.44 189.33,6.79 188.51,6.79 187.09,8.22 184.94,8.22 184.24,7.52 181.94,7.52 179.85,5.42 171.3,5.42 169.37,7.35 163.7,7.35 163.41,7.64 163.41,7.79 v1(163.09,8.1)
  BOTTOM w0.109: v2(139.06,88.96) 138.99,89.02 138.83,89.02 138.67,88.86 138.67,87.45 137.94,86.72 137.94,86.44 U400.DD1 ; v1(163.09,8.1) 163.37,8.1 163.43,8.04 163.43,7.76 163.23,7.55 162.82,7.55 162.48,7.89 162.48,8.89 161.87,9.5 161.87,10.39 161.59,10.67 161.26,10.67 161.14,10.78 R5201.2
USBP7+_C: length 5.1
  BOTTOM w0.109: CON5200.4 158.29,9.42 158.02,9.7 158.02,10.47 158.28,10.73 158.56,10.73 C5203.2 158.96,11.13 R5201.1
USBP7-: length 188.4
  IN3 w0.089: v1(163.86,8.1) 163.6,7.85 163.6,7.72 163.77,7.54 169.45,7.54 171.38,5.61 179.77,5.61 181.86,7.71 184.16,7.71 184.86,8.41 187.17,8.41 188.59,6.98 189.41,6.98 189.76,6.63 192.68,6.63 193.01,6.96 194.71,6.96 194.87,6.8 195.68,6.8 195.98,7.11 196.57,7.11 196.73,6.94 200.87,6.94 201.65,7.72 203.13,7.72 204.95,9.54 207.38,9.54 210.18,12.34 210.18,18.9 207.88,21.19 207.21,21.19 204.35,24.05 204.35,25.22 202.89,26.68 202.64,26.68 199.92,29.4 198.07,29.4 198.04,29.42 197.73,29.54 194.47,29.54 193.33,30.69 192.72,30.69 191.06,32.35 191.06,34.19 189.97,35.27 189.97,37.65 190.23,37.91 190.23,41.22 190.03,41.42 190.03,47.29 189.1,48.22 189.1,49.45 189.63,49.98 189.63,50.82 186.66,53.79 186.66,54.82 185.05,56.44 185.05,57.37 184.16,58.27 184.16,61.2 182.29,63.07 177.81,63.07 173.53,67.34 173.53,70.43 168.1,75.87 167.6,75.87 166.48,76.99 166.48,78.43 166.14,78.76 165.48,78.76 163.33,80.91 160.42,80.91 157.86,83.47 154.44,83.47 152.99,84.92 150.73,84.92 149.01,86.65 145.79,86.65 145.15,87.29 141.87,87.29 141.53,87.63 141.03,87.63 140.26,86.86 138.83,86.86 138.49,87.2 138.49,88.92 138.59,89.02 v2(138.59,89.26)
  BOTTOM w0.109: R5200.2 161.14,10.32 161.27,10.44 161.5,10.44 161.64,10.3 161.64,9.41 162.25,8.8 162.25,7.8 162.73,7.33 163.32,7.33 163.66,7.67 163.66,7.91 v1(163.86,8.1) ; U400.DD2 137.96,85.77 137.75,86.28 137.75,86.8 138.48,87.53 138.48,88.94 138.59,89.05 v2(138.59,89.26)
USBP7-_C: length 5
  BOTTOM w0.109: R5200.1 160.05,10.12 159.97,10.03 158.77,10.03 158.62,10.18 C5203.1 158.46,10.51 158.37,10.51 158.24,10.38 158.24,9.79 158.51,9.51 158.51,8.97 158.79,8.69 CON5200.3
USBP8+: length 164.4
  IN1 w0.079: v2(137.57,87.77) 137.6,87.77 137.76,87.61 137.76,87.54 137.59,87.37 137.05,87.37 134.9,85.21 134.9,84.34 134.72,84.17 134.72,82.51 134.22,82.01 134.22,80.55 133.58,79.91 133.58,77.25 130.69,74.36 130.69,73.91 130.08,73.3 126.61,73.3 124.24,70.94 108.92,70.94 108.59,71.27 99.96,71.27 99.13,70.43 94.04,70.43 92.33,68.73 91.36,68.73 89.36,66.72 89.36,65.41 83.44,59.5 83.44,56.51 63.99,37.06 57.14,37.06 49.28,29.21 40.62,29.21 38.84,27.43 33.64,27.43 33.4,27.19 33.4,25.72 34.11,25.01 34.11,24.38 35.67,22.82 35.67,20.8 35.03,20.16 35.03,15.33 33.37,13.67 33.37,11.94 32.18,10.74 31.42,10.74 v1(31.21,10.96)
  BOTTOM w0.079: v2(137.57,87.77) 137.6,87.77 137.77,87.6 137.77,87.47 137.38,87.07 137.38,85.93 137.14,85.69 137.14,85.29 137.45,84.98 U400.DB4
  BOTTOM w0.109: R4417.2 28.31,9.7 28.31,10.5 28.57,10.76 31.01,10.76 v1(31.21,10.96)
USBP8+_C: length 2.6
  BOTTOM w0.109: CON4400.6 28.09,6.8 28.23,6.94 28.23,7.33 28.37,7.47 28.37,8.26 R4417.1
USBP8-: length 164.4
  IN1 w0.079: v2(138.12,87.75) 137.99,87.75 137.92,87.68 137.92,87.48 137.65,87.21 137.11,87.21 135.05,85.15 135.05,84.28 134.88,84.1 134.88,82.43 134.39,81.94 134.39,80.48 133.75,79.84 133.75,77.18 130.85,74.29 130.85,73.84 130.15,73.14 126.68,73.14 124.31,70.77 108.85,70.77 108.52,71.1 100.03,71.1 99.2,70.27 94.11,70.27 92.4,68.56 91.43,68.56 89.52,66.65 89.52,65.34 83.61,59.43 83.61,56.44 64.06,36.9 57.21,36.9 49.35,29.04 40.69,29.04 38.91,27.26 33.71,27.26 33.57,27.12 33.57,25.79 34.28,25.08 34.28,24.45 35.84,22.89 35.84,20.73 35.2,20.09 35.2,15.26 33.54,13.6 33.54,11.87 32.25,10.58 31.27,10.58 31.21,10.51 v1(31.21,10.19)
  BOTTOM w0.079: U400.DB3 137.3,85.55 137.3,85.63 137.53,85.87 137.53,87.01 137.93,87.4 137.93,87.74 137.98,87.79 138.1,87.79 138.12,87.76 v2(138.12,87.75)
  BOTTOM w0.109: v1(31.21,10.19) 31.21,10.44 31.11,10.54 28.66,10.54 28.53,10.41 28.53,9.49 28.61,9.4 R4416.2
USBP8-_C: length 2.7
  BOTTOM w0.109: CON4400.5 28.59,6.8 28.45,6.94 28.45,7.23 28.6,7.38 28.6,8.24 R4416.1
USBP9+: length 202.1
  IN3 w0.089: v2(139.66,88) 139.51,87.85 139.51,87.77 139.64,87.63 139.9,87.63 140.25,87.99 140.25,88.35 140.8,88.91 142.23,88.91 142.95,88.18 146,88.18 146.56,87.63 149.25,87.63 151.18,85.7 155.63,85.7 156.99,84.33 158.22,84.33 158.39,84.16 159.05,84.16 161.51,81.69 163.65,81.69 165.78,79.55 166.48,79.55 167.36,78.67 167.36,77.29 167.83,76.82 168.35,76.82 174.39,70.78 174.39,68.4 178.05,64.74 180.18,64.74 181.05,63.87 182.58,63.87 184.93,61.52 184.93,58.65 185.82,57.76 185.82,56.76 187.46,55.12 187.46,54.13 190.46,51.13 190.46,49.68 189.89,49.11 189.89,48.68 190.8,47.77 190.8,42.67 191.97,41.5 191.97,39.81 191.04,38.89 191.04,35.33 191.9,34.48 191.9,32.61 193.04,31.46 193.65,31.46 194.8,30.32 197.89,30.32 198.23,30.18 200.36,30.18 202.23,28.32 202.35,28.32 205.56,25.11 205.56,24.83 210.95,19.44 210.95,12.02 207.7,8.77 206.75,8.77 205.61,7.63 204.57,7.63 203.02,6.08 197.34,6.08 196.33,5.07 195.75,5.07 195.09,5.73 187.7,5.73 186.59,6.84 182.09,6.84 179.47,4.21 171.51,4.21 168.95,6.77 163.31,6.77 162.93,7.15 162.46,7.15 162.29,6.98 160.94,6.98 160.55,6.6 159.03,6.6 158.8,6.83 151.23,6.83 150.91,6.52 147.07,6.52 146.21,7.38 v2(146.21,7.77)
  BOTTOM w0.079: U400.DD5 138.42,84.82 138.42,85.5 138.45,85.53 138.45,86.66 138.55,86.77 138.6,86.77 138.61,86.78
  BOTTOM w0.109: v2(139.66,88) 139.66,87.83 139.39,87.56 138.61,86.78 ; v2(146.21,7.77) 145.99,7.99 CON4402.13
USBP9-: length 202.1
  IN3 w0.089: v1(150.47,7.52) 150.47,7.22 150.38,7.12 148.74,7.12 148.63,7.02 148.63,6.77 148.7,6.71 150.83,6.71 151.15,7.02 158.88,7.02 159.11,6.79 160.48,6.79 160.86,7.18 162.21,7.18 162.38,7.34 163.01,7.34 163.39,6.96 169.03,6.96 171.59,4.4 179.39,4.4 182.01,7.03 186.67,7.03 187.78,5.92 195.17,5.92 195.83,5.26 196.25,5.26 196.47,5.48 196.47,5.48 197.26,6.27 202.94,6.27 204.49,7.82 205.53,7.82 206.56,8.85 206.67,8.96 207.62,8.96 210.76,12.1 210.76,19.36 205.37,24.75 205.37,25.03 202.27,28.13 202.15,28.13 200.29,29.99 198.19,29.99 197.85,30.13 194.72,30.13 193.57,31.27 192.96,31.27 191.71,32.53 191.71,34.4 190.85,35.25 190.85,38.97 191.78,39.89 191.78,41.42 190.61,42.59 190.61,47.69 189.7,48.6 189.7,49.18 190.27,49.76 190.27,51.05 187.27,54.05 187.27,55.04 185.63,56.68 185.63,57.68 184.74,58.57 184.74,61.44 182.5,63.68 180.97,63.68 180.1,64.55 177.97,64.55 174.2,68.32 174.2,70.7 168.27,76.63 167.75,76.63 167.17,77.21 167.17,78.6 166.4,79.36 165.71,79.36 163.57,81.5 161.43,81.5 158.97,83.97 158.31,83.97 158.14,84.14 156.91,84.14 155.55,85.51 151.1,85.51 149.17,87.44 146.48,87.44 145.93,87.99 142.87,87.99 142.15,88.71 140.88,88.71 140.44,88.28 140.44,87.91 139.98,87.44 139.57,87.44 139.32,87.69 139.32,87.79 v2(139.12,87.99)
  BOTTOM w0.079: U400.DD4 138.16,85.06 138.25,84.98 138.25,84.87 138.12,84.74 137.87,84.74 137.62,84.99 137.62,85.16 137.81,85.35 138.19,85.35 138.24,85.4 138.24,85.54 138.29,85.59 138.29,86.72 138.44,86.88 138.44,86.93 138.46,86.94
  BOTTOM w0.109: CON4402.4 150.47,8.46 150.47,7.52 v1(150.47,7.52) ; 138.46,86.94 139.23,87.71 139.23,87.88 v2(139.12,87.99)
USBP10+: length 45.2
  IN3 w0.089: v1(169.55,72.41) 169.31,72.65 169.31,73.48 165.47,77.32 165.47,77.44 165.45,77.56 165.24,78.06 164.73,78.57 164.36,78.57 162.58,80.35 160.42,80.35 157.69,83.08 153.64,83.08 153.01,83.7 150.39,83.7 148.55,85.54 145.36,85.54 144.48,86.42 138.59,86.42 138.32,86.7 138.02,86.7 136.71,88.01 136.17,88.01 v2(136.05,88.13)
  BOTTOM w0.079: U400.CV4 135.77,85.29 135.77,86.51 135.52,86.75 135.52,87.72 135.76,87.96 135.88,87.96 v2(136.05,88.13)
  BOTTOM w0.109: v1(169.55,72.41) 169.3,72.65 169.3,72.75 R4119.2
USBP10+_C: length 7.2
  BOTTOM w0.109: R4119.1 169.47,73.7 169.2,73.7 169.13,73.76 169.13,74.16 169.27,74.3 172.2,74.3 173.37,73.14 173.37,72.86 173.09,72.58 CON4100.3
USBP10-: length 45.2
  IN3 w0.089: v1(168.78,72.41) 168.95,72.41 169.12,72.59 169.12,73.4 165.28,77.24 165.28,77.42 165.27,77.5 165.08,77.95 164.65,78.38 164.28,78.38 162.5,80.16 160.34,80.16 157.61,82.89 153.56,82.89 152.93,83.51 150.31,83.51 148.47,85.35 145.28,85.35 144.4,86.23 138.51,86.23 138.24,86.51 137.94,86.51 136.63,87.82 136.26,87.82 136.07,87.63 v2(136.07,87.55)
  BOTTOM w0.079: U400.CY3 135.97,85.39 135.92,85.44 135.92,86.57 135.68,86.82 135.68,87.65 135.83,87.8 136.01,87.8 136.07,87.74 v2(136.07,87.55)
  BOTTOM w0.109: v1(168.78,72.41) 168.96,72.41 169.08,72.54 169.08,72.93 168.92,73.09 R4120.2
USBP10-_C: length 7.2
  BOTTOM w0.109: CON4100.5 173.59,73.23 172.3,74.52 169.18,74.52 168.91,74.25 168.91,74.09 R4120.1
USIM_DETECT: length 51.2
  TOP w0.109: 205.66,23.67 206.6,23.67 207.13,23.14 v2(207.77,23.14)
  IN2 w0.089: v1(186.92,2.82) 186.92,2.06 187.37,1.6 203.52,1.6 205.03,3.11 205.03,5.33 205.1,5.41 205.1,5.66 205.03,5.84 205.03,6.09 205.61,6.68 205.61,6.93 206.54,7.86 206.54,8.93 208.56,10.94 208.56,12.47 209.42,13.33 210.06,13.33 210.61,13.89 210.61,15.3 209.86,16.05 209.62,16.05 209.27,16.41 209.27,17.19 210.45,18.37 210.45,20.56 208.97,22.04 208.97,22.36 208.59,22.74 208.17,22.74 v2(207.77,23.14)
  BOTTOM w0.109: CON4202.66 186.16,2.19 186.4,2.42 186.52,2.42 v1(186.92,2.82) ; D4206.2 207.17,23.14 v2(207.77,23.14)
V_ADP_ADC4: length 110.2
  TOP w0.109: PR8401.1 172.92,84.53 173.02,84.43 PR8403.2 173.71,84.02 174.06,84.02 174.31,83.78 PC8401.2 173.68,83.39 173.43,83.64 173.18,83.64 172.41,84.4 172.41,85.42 171.85,85.98 169.57,85.98 168.31,87.23 166.87,87.23 v1(166.61,87.49) ; v1(174.49,41.85) 174.49,43.94 173.81,44.63 173.81,47.7 174.97,48.87 174.97,50.36 174.21,51.13 171.57,51.13 v1(171.4,50.95) ; R4717.2 191.06,10 191.24,10.18 191.24,10.54 191.34,10.63 v1(191.34,10.87) 191.5,11.03 191.73,11.03 192.48,11.78 v2(192.48,12.6)
  IN1 w0.076: 192.43,15.34 192.43,15.29
  IN1 w0.079: v1(174.49,41.85) 174.49,41.08 175.42,40.15 175.42,38.92 176.33,38.02 179.74,38.02 180.89,36.87 180.89,36.37 181.92,35.34 181.92,32.8 183.84,30.88 183.84,29.81 185.62,28.03 185.62,27.44 185.97,26.6 187.77,24.8 188.55,24.8 190.32,23.03 190.32,21.36 191.74,19.94 191.74,18.57 191.81,18.49 191.81,15.95 192.43,15.34 ; 192.43,15.29 192.43,12.65 v2(192.48,12.6)
  IN2 w0.089: v1(166.61,87.49) 166.09,86.98 166.09,84.58 166.7,83.97 166.7,83.04 168.43,81.32 168.43,78.48 169.07,77.83 169.07,75.67 171.02,73.72 171.02,70.42 170.74,70.15 170.74,69.38 170.38,69.02 170.15,69.02 169.81,68.69 169.81,67.47 170.56,66.73 170.56,65.22 170.39,65.05 170.39,64.14 170.76,63.77 170.76,58.24 171.71,57.29 171.71,55.7 171.4,55.39 v1(171.4,50.95)
V_ADP_ADC4_R: length 9.4
  TOP w0.076: 193,14.13 193.49,14.62 193.49,15.05 U4700.C2
  TOP w0.109: C4711.2 193.42,9.65 193.42,9.59 193.2,9.37 193.15,9.37 192.93,9.14 v1(192.17,9.14) 192.04,9.14 R4717.1 191.64,9.81 191.64,10.41 191.79,10.76 192.15,11.12 192.53,11.12 192.84,11.43 192.84,13.05 192.68,13.21 192.68,13.74 193,14.06 193,14.13
VADJ1: length 18.7
  TOP w0.109: v1(25.64,39.74) 26.02,40.12 R3434.1 26.55,40.12 26.87,40.43 v1(26.87,40.5) 26.93,40.43 27.61,40.43 C3427.1
  IN3 w0.089: v1(25.11,30.47) 25.11,30.59 24.15,31.54 24.15,34.75 24.87,35.47 24.87,35.98 24.36,36.49 24.36,39.76 24.71,40.1 25.28,40.1 v1(25.64,39.74)
  BOTTOM w0.109: v1(25.11,30.47) 26.14,29.44 27.33,28.25 CON3400.6
VADPBL: length 2.3
  BOTTOM w0.203: PR8214.2 169.55,101.74 169.55,101.09 PR8029.1 169.37,101.04 168.86,100.53 168.86,100.02
  vias: v1(171.09,94.08)
VGA_OVT#: length 50.4
  IN2 w0.089: v1(81.19,87.85) 82.19,86.85 82.19,85.58 81.25,84.65 81.25,82.04 80.29,81.07 80.29,75.38 76.4,71.5 76.4,70.13 76.15,69.87 75.37,69.87 74.73,69.23 74.73,68.95 73.4,67.63 73.4,66.52 73.81,66.11 74.55,66.11 74.77,65.9 75.15,65.9 75.31,65.73 75.38,65.73 v1(75.61,65.51)
  BOTTOM w0.109: U6600.A6 77.07,90.63 79,90.63 79.64,91.27 R6952.1 81.19,89.94 v1(81.19,87.85) ; v1(75.61,65.51) 75.74,65.51 77.3,63.95 79.77,63.95 80.45,64.63 82.61,64.63 83.08,64.16 83.08,63.95 83.61,63.42 83.87,63.42 v1(83.98,63.31) 84.65,62.64 Q6902.1
VMA_CLK0: length 32.9
  TOP w0.109: R7014.1 36.53,88.66 36.62,88.57 37.01,88.57 37.2,88.76 v2(37.2,88.89)
  IN1 w0.079: v2(37.2,88.89) 37.47,88.62 39.97,88.62 40.44,89.09 42.06,89.09 42.52,89.55 44.46,89.55 45.62,88.39 45.73,88.39 46.39,89.04 46.64,89.04 46.9,88.78 46.9,88.54 46.24,87.88 46.24,87.77 46.4,87.61 46.51,87.61 47.17,88.26 47.42,88.26 47.68,88 47.68,87.75 47.02,87.1 47.02,86.99 47.18,86.83 47.29,86.83 47.95,87.48 48.2,87.48 48.46,87.22 48.46,86.97 47.8,86.32 47.8,86.21 48,86 57.54,86 57.97,86.43 58.44,86.43 58.86,86.01 v2(59.15,86.01)
  BOTTOM w0.109: VRAM7000.J12 36.8,88.5 v2(37.2,88.89) ; U6600.D24 59.54,85.63 v2(59.15,86.01)
VMA_CLK0#: length 32.9
  TOP w0.109: v2(37.14,88.1) 37.14,88.26 37.06,88.34 36.62,88.34 36.53,88.25 R7015.1
  IN1 w0.079: v2(37.14,88.1) 37.02,88.1 36.93,88.19 36.93,88.42 37.03,88.52 37.33,88.52 37.4,88.45 40.04,88.45 40.51,88.93 42.13,88.93 42.59,89.38 44.39,89.38 45.55,88.22 45.8,88.22 46.46,88.88 46.57,88.88 46.73,88.72 46.73,88.6 46.07,87.95 46.07,87.7 46.33,87.44 46.58,87.44 47.24,88.1 47.35,88.1 47.51,87.94 47.51,87.82 46.85,87.17 46.85,86.92 47.11,86.66 47.36,86.66 48.02,87.32 48.13,87.32 48.29,87.15 48.29,87.04 47.63,86.39 47.63,86.14 47.93,85.83 57.61,85.83 58.04,86.27 58.28,86.27 58.33,86.22 v2(58.33,86.01)
  BOTTOM w0.109: VRAM7000.J11 37.54,88.5 v2(37.14,88.1) ; U6600.D25 58.77,85.63 58.77,85.93 58.65,86.05 58.37,86.05 v2(58.33,86.01)
VMA_CLK1: length 43.9
  TOP w0.109: R7008.1 36.66,70.59 36.83,70.59 v2(37.14,70.9)
  IN1 w0.079: v2(37.14,70.9) 37.14,70.57 37.25,70.47 38.45,70.47 38.56,70.36 39.57,70.36 40.64,69.29 40.64,65.13 42.66,63.11 45.21,63.11 52.04,69.94 52.04,71.97 52.94,72.87 54.62,72.87 55.08,73.33 58.68,73.33 60.17,73.95 60.33,74.11 60.33,74.62 60.66,74.94 60.96,74.94 62.18,76.16 62.36,76.6 62.36,78.73 62.12,78.97 61.77,78.97 61.58,78.78 v2(61.58,78.54)
  BOTTOM w0.109: v2(61.58,78.54) U6600.N22 ; v2(37.14,70.9) 36.75,70.5 VRAM7001.J12
VMA_CLK1#: length 43.8
  TOP w0.109: v2(37.15,70.11) 36.9,70.36 36.38,70.36 R7010.1
  IN1 w0.079: v2(37.15,70.11) 37.35,70.3 38.38,70.3 38.49,70.19 39.5,70.19 40.47,69.22 40.47,65.06 42.59,62.94 45.28,62.94 52.21,69.87 52.21,71.91 53.01,72.7 54.69,72.7 55.15,73.16 58.71,73.16 60.27,73.8 60.5,74.04 60.5,74.55 60.73,74.78 61.03,74.78 62.32,76.06 62.53,76.57 62.53,78.8 62.19,79.14 61.8,79.14 v2(61.58,79.36)
  BOTTOM w0.109: VRAM7001.J11 37.15,70.11 v2(37.15,70.11) ; v2(61.58,79.36) 61.18,78.96 U6600.M22
VMA_DQ0: length 30.3
  IN1 w0.102: v2(64.12,84.38) 64.53,84.79 64.53,86.17 64.13,86.56 64.13,86.95 63.6,87.49 63.6,89.56 63.03,90.13 61.72,90.13 61.13,90.72 60.16,90.72 59.91,90.97 50.33,90.97 46.73,94.57 45.73,94.57 45.24,94.08 43.1,94.08 v2(42.71,94.47)
  BOTTOM w0.14: v2(64.12,84.38) 64.12,84.4 U6600.E18 ; v2(42.71,94.47) VRAM7000.A4
VMA_DQ1: length 29.8
  IN1 w0.102: v2(64.94,83.54) 65.37,83.97 65.37,84.61 64.9,85.07 64.9,86.27 64.54,86.63 64.54,87.91 64.48,87.96 64.48,90.06 63.09,91.45 50.43,91.45 46.9,94.98 45.56,94.98 45.37,94.79 45.36,94.79 v2(45.08,94.51)
  BOTTOM w0.14: v2(64.94,83.54) U6600.F18 ; VRAM7000.A2 44.74,94.85 v2(45.08,94.51)
VMA_DQ2: length 32.7
  IN1 w0.102: v2(43.56,94.51) 43.56,95.09 44.26,95.79 47.59,95.79 51.12,92.27 63.43,92.27 65.22,90.47 65.53,90.47 65.76,90.24 66.2,90.24 66.48,89.97 66.48,88.55 66.19,88.26 66.19,87.67 65.86,87.35 65.86,86.48 66.19,86.15 66.19,85.61 v2(66.6,85.2)
  BOTTOM w0.14: v2(43.56,94.51) 43.55,94.51 VRAM7000.B4 ; v2(66.6,85.2) U6600.E16
VMA_DQ3: length 30.7
  IN1 w0.102: v2(65.78,84.38) 65.78,84.63 65.36,85.04 65.36,87.4 65.65,87.69 65.65,88.31 65.33,88.63 65.33,89.41 64.84,89.89 64.84,90.27 63.26,91.86 50.95,91.86 47.42,95.39 45.22,95.39 v2(44.34,94.5)
  BOTTOM w0.14: VRAM7000.B2 v2(44.34,94.5) ; U6600.F17 v2(65.78,84.38)
VMA_DQ4: length 25.9
  IN1 w0.102: v2(42.72,90.5) 42.72,90.7 42.88,90.86 45.03,90.86 45.33,90.56 45.73,90.16 46.11,90.16 49.67,86.59 57.55,86.59 58.19,87.23 58.59,87.23 59.43,86.39 60.16,86.39 60.42,86.13 60.42,84.87 60.55,84.75 62.02,84.75 v2(62.46,85.18)
  BOTTOM w0.14: v2(42.72,90.5) 42.72,91.01 43.14,91.42 VRAM7000.E4 ; U6600.D20 62.87,85.6 v2(62.46,85.18)
VMA_DQ5: length 21.3
  IN1 w0.102: v2(62.44,85.97) 60.45,87.97 59.12,87.97 58.95,88.14 50.65,88.14 50.35,88.43 49.18,88.43 46.68,90.93 46.68,91.58 46.28,91.98 45.31,91.98 v2(45.19,92.1)
  BOTTOM w0.14: VRAM7000.E2 45.14,92.1 v2(45.19,92.1) ; U6600.D21 62.41,85.97 v2(62.44,85.97)
VMA_DQ6: length 26
  IN1 w0.102: v2(62.45,84.39) 62.87,84.81 62.87,86.12 60.61,88.38 59.34,88.38 59.12,88.6 51.11,88.6 50.79,88.92 49.28,88.92 47.26,90.94 47.26,91.65 46.51,92.41 45.69,92.41 45.58,92.51 44.71,92.51 v2(43.54,91.34)
  BOTTOM w0.14: v2(62.45,84.39) U6600.F20 ; v2(43.54,91.34) 43.54,91.3 VRAM7000.F4
VMA_DQ7: length 21.3
  IN1 w0.102: v2(45.17,91.31) 45.9,90.59 46.25,90.59 49.75,87.08 57.44,87.08 58,87.65 58.83,87.65 59.28,87.2 60.2,87.2 60.38,87.02 60.38,86.55 60.53,86.4 61.04,86.4 61.24,86.19 61.24,85.6 v2(61.64,85.2)
  BOTTOM w0.14: U6600.E21 v2(61.64,85.2) ; VRAM7000.F2 44.76,90.9 v2(45.17,91.31)
VMA_DQ8: length 43.9
  IN1 w0.102: v2(67.42,84.38) 67.2,84.38 67,84.58 67,85.39 66.63,85.76 66.63,86.14 66.19,86.59 66.19,86.94 66.44,87.2 66.81,87.2 67.9,88.29 67.9,89.42 67.63,89.69 67.63,92.58 67.16,93.06 65.91,93.06 65.36,93.61 64.68,93.89 53.22,93.89 49.63,97.47 43.52,97.47 42.2,96.16 39.76,96.16 38.55,94.95 38.26,94.95 v2(37.92,95.28)
  BOTTOM w0.14: v2(67.42,84.38) U6600.E15 ; VRAM7000.A11 v2(37.92,95.28)
VMA_DQ9: length 45.3
  IN1 w0.102: v2(37.77,96.36) 37.98,96.16 38.95,96.16 39.36,96.56 42.03,96.56 43.35,97.88 49.8,97.88 53.38,94.3 64.76,94.3 65.6,93.95 66.08,93.47 67.36,93.47 68.03,92.8 68.03,89.86 68.26,89.62 68.26,88.22 66.98,86.95 66.98,85.83 67.42,85.39 v2(67.42,85.2)
  BOTTOM w0.14: v2(37.77,96.36) 37.57,96.56 v4(37.03,96.56) 36.48,96.56 35.94,96.03 VRAM7000.A13 ; v2(67.42,85.2) 67.4,85.2 U6600.D15
VMA_DQ10: length 49.7
  IN1 w0.102: v2(36.6,96.09) 36.6,96.38 37.61,97.39 41.58,97.39 42.88,98.69 50.15,98.69 53.73,95.11 64.92,95.11 65.99,94.67 67.49,94.67 68.86,93.3 68.86,90.35 69.75,89.45 69.75,87.78 67.84,85.87 67.84,83.98 v2(67.4,83.53)
  BOTTOM w0.14: VRAM7000.B11 37.11,94.53 37.11,95.58 v2(36.6,96.09) ; v2(67.4,83.53) 67.4,83.56 U6600.F15
VMA_DQ11: length 57
  IN1 w0.102: v2(35.54,93.7) 35.54,93.63 35.94,93.23 35.94,92.64 35.79,92.49 35.37,92.49 35.37,92.48 34.57,92.48 34.23,92.82 34.23,95.19 37.25,98.21 41.11,98.21 42.41,99.51 50.48,99.51 54.06,95.93 65.09,95.93 66.15,95.48 67.83,95.48 69.69,93.63 69.69,90.71 70.65,89.75 70.65,87.51 68.7,85.56 68.7,84.57 68.88,84.4 v2(69.12,84.4)
  BOTTOM w0.14: v2(69.12,84.4) U6600.F13 ; VRAM7000.B13 v2(35.54,93.7)
VMA_DQ12: length 45.5
  IN1 w0.102: v2(37.14,92.1) 37.14,92.31 37.33,92.5 38.48,92.5 39.12,93.15 39.12,94.94 39.93,95.75 42.37,95.75 43.69,97.07 48.05,97.07 50.06,95.06 50.19,95.06 50.36,95.24 50.36,95.78 50.47,95.88 50.65,95.88 50.77,95.76 50.77,94.54 50.87,94.44 51.08,94.44 51.18,94.54 51.18,94.87 51.28,94.97 51.48,94.97 51.58,94.87 51.58,94.54 51.69,94.44 52.09,94.44 53.05,93.49 64.6,93.49 65.12,93.27 66.29,92.1 v2(67.2,92.1)
  BOTTOM w0.079: 68.1,89.58 68.1,88.52 68.34,88.27 68.34,87.83 68.58,87.6 68.77,87.6 69.08,87.28 69.08,86.8 U6600.C13
  BOTTOM w0.14: v2(67.2,92.1) 66.78,91.68 66.78,91.22 68.1,89.9 68.1,89.58 ; VRAM7000.E11 v2(37.14,92.1)
VMA_DQ13: length 44.8
  IN1 w0.102: v2(65.9,91.44) 65.21,91.44 63.97,92.67 51.28,92.67 47.76,96.2 44.03,96.2 42.7,94.86 40.8,94.86 40.57,94.63 40.57,94 40.68,93.9 41.01,93.9 41.11,93.8 41.11,93.49 41.01,93.39 40.68,93.39 40.57,93.29 40.57,92.48 40.25,92.16 40.11,92.16 39.79,92.47 39.67,92.47 39.44,92.24 39.44,92.11 39.75,91.8 39.75,91.66 38.19,90.1 36.23,90.1 35.96,90.36 35.96,90.86 v2(35.56,91.26)
  BOTTOM w0.079: 67.88,89.48 67.89,89.47 67.89,88.47 68.18,88.18 68.18,87.7 U6600.B13
  BOTTOM w0.14: v2(35.56,91.26) 35.56,91.32 VRAM7000.E13 ; 67.88,89.48 67.69,89.67 67.67,89.67 v2(65.9,91.44)
VMA_DQ14: length 57.9
  IN1 w0.102: v2(69.1,85.2) 69.24,85.34 69.85,85.6 70.05,85.6 70.28,85.82 71.06,87.7 71.06,89.77 70.49,91.15 70.09,91.55 70.09,93.79 68,95.89 66.24,95.89 65.17,96.33 54.79,96.33 53.84,96.72 50.71,99.86 50.57,99.91 42.32,99.91 39.95,98.93 37.88,98.93 37.05,98.59 33.79,95.33 33.79,92.39 34.49,91.69 36.48,91.69 37.03,91.46 v2(37.15,91.34)
  BOTTOM w0.14: U6600.E13 68.69,84.8 v2(69.1,85.2) ; v2(37.15,91.34) 37.15,91.29 VRAM7000.F11
VMA_DQ15: length 45.3
  IN1 w0.102: v2(36.34,91.3) 36.67,90.96 38.08,90.96 38.67,91.56 38.67,92.13 39.87,93.32 39.87,94.93 40.29,95.35 42.54,95.35 43.86,96.66 47.88,96.66 50.51,94.03 51.15,94.03 51.23,93.96 51.23,93.35 51.32,93.25 51.58,93.25 51.64,93.31 51.64,93.93 51.74,94.03 51.93,94.03 52.04,93.92 52.04,93.57 52.12,93.49 52.47,93.49 52.88,93.08 64.14,93.08 65.28,91.94 65.97,91.94 66.83,91.08 66.83,90.57 67.02,90.38 67.02,88.81 67.14,88.68 v2(67.44,88.68)
  BOTTOM w0.14: U6600.D13 68.31,85.97 68.31,87.26 67.94,87.63 67.69,87.63 67.44,87.87 v2(67.44,88.68) ; VRAM7000.F13 v2(36.34,91.3)
VMA_DQ16: length 51.3
  IN3 w0.114: v2(37.14,82.5) 36.72,82.92 36.23,82.92 36.17,82.86 35.05,82.86 34.36,83.56 33.52,84.82 33.48,84.92 33.48,86.32 33.9,87.34 34.16,87.73 35.94,89.51 35.94,89.84 36.14,90.04 36.42,90.04 36.73,90.35 36.73,90.65 36.98,90.9 38.3,90.9 39.53,92.13 39.53,92.47 41.59,94.54 42.57,94.94 43.9,94.94 43.97,94.88 46.6,94.88 46.88,95.17 63.6,95.17 65.23,94.37 66.59,93.01 66.59,92.58 66.75,92.2 66.75,89.85 66.62,89.53 v2(66.62,87.58)
  BOTTOM w0.14: U6600.B15 v2(66.62,87.58) ; VRAM7000.U11 v2(37.14,82.5)
VMA_DQ17: length 55.1
  IN3 w0.114: v2(35.54,81.7) 34.52,82.12 34.52,82.12 33.63,82.45 32.64,84.31 32.64,86.51 33.18,87.81 33.44,88.31 34.16,89.38 35.1,90.32 35.15,90.44 35.15,90.6 35.19,90.69 35.32,90.82 35.47,90.88 35.69,90.88 35.77,90.91 35.9,91.04 35.94,91.14 35.94,91.33 36.02,91.52 36.16,91.66 36.24,91.69 36.35,91.69 36.56,91.78 36.66,91.88 36.73,92.04 36.73,92.09 36.84,92.37 36.91,92.44 37.02,92.48 37.92,92.48 38.65,92.78 41.29,95.42 42.09,95.82 43.95,96.16 45.18,96.16 46.91,96.01 64.17,96.01 65.63,95.16 67.73,93.06 68,92.45 68,91.65 67.05,89.35 67.05,87.53 66.86,87.06 v2(66.6,86.8)
  BOTTOM w0.14: U6600.C16 v2(66.6,86.8) ; VRAM7000.U13 v2(35.54,81.7)
VMA_DQ18: length 54.2
  IN3 w0.114: v2(67.21,91.42) 67.59,91.8 67.59,92.36 67.36,92.84 65.48,94.72 63.7,95.59 46.89,95.59 45.23,95.74 44.74,95.74 43.96,95.74 42.93,95.55 42.23,95.41 41.33,94.87 38.18,91.72 36.98,91.72 36.73,91.46 36.73,91.13 36.5,90.9 36.17,90.9 35.94,90.68 35.94,90.35 35.68,90.09 35.38,90.09 35.15,89.86 35.15,89.34 33.88,88.07 33.53,87.54 33.06,86.41 33.06,84.42 33.88,82.88 33.98,82.78 34.85,82.45 35.21,82.45 36.01,82.12 37.47,82.12 v2(37.86,82.51)
  BOTTOM w0.102: v2(67.21,91.42) 67.21,91.14 68.32,90.03 68.32,88.57 68.56,88.33 68.56,88.12 U6600.A13
  BOTTOM w0.14: v2(37.86,82.51) VRAM7000.T11
VMA_DQ19: length 45.9
  IN3 w0.114: v2(65.9,90.65) 65.9,90.89 65.49,91.3 65.49,91.82 65.76,92.09 65.76,92.66 64.99,93.43 64.31,93.43 63.48,94.26 47.73,94.26 46.78,93.32 42.4,93.32 42.35,93.27 41.76,93.27 40.54,92.05 40.54,91.73 38.18,89.38 37.15,89.38 35.55,87.78 35.46,87.78 35.15,87.48 35.15,86.79 34.31,85.96 34.31,85.25 34.88,84.3 35.23,83.87 35.39,83.72 36,83.72 v2(36.38,83.34)
  BOTTOM w0.14: v2(65.9,90.65) 66.83,89.73 66.83,88.42 67,88.25 U6600.A15 ; v2(36.38,83.34) VRAM7000.T13
VMA_DQ20: length 44.5
  IN3 w0.114: v2(64.93,86.79) 64.93,86.95 64.8,87.09 63.88,87.09 63.57,87.4 63.57,89.69 63.12,90.14 63.12,91.59 62.58,92.12 51.87,92.12 51.65,91.91 51.65,91.75 52.58,90.83 52.58,90.64 52.42,90.48 52.28,90.48 51.31,91.45 51.14,91.45 50.98,91.29 50.98,91.13 51.66,90.45 51.66,90.29 51.5,90.13 51.34,90.13 50.66,90.81 50.5,90.81 50.34,90.65 50.34,90.48 51.01,89.81 51.01,89.65 50.85,89.48 50.69,89.48 50.01,90.16 49.85,90.16 49.69,90 49.69,89.84 50.06,89.47 50.06,89.3 49.9,89.14 49.76,89.14 49.42,89.49 49.26,89.49 48.58,88.82 43.35,88.82 43.02,88.48 42.43,88.48 41.43,87.48 41.43,85.99 41.11,85.67 v2(37.95,85.67)
  BOTTOM w0.14: VRAM7000.N11 37.56,85.3 37.93,85.67 v2(37.95,85.67) ; U6600.B18 v2(64.93,86.79)
VMA_DQ21: length 42.7
  IN3 w0.114: v2(64.92,88.68) 64.53,89.07 64.53,91.96 63.07,93.42 48.36,93.42 46.93,91.99 45.76,91.99 45.66,91.89 45.66,91.03 45.56,90.92 42.88,90.92 42.75,91.06 42.25,91.06 42.11,90.92 41.04,90.92 39.98,89.86 39.98,89.55 39.86,89.44 39.69,89.44 39.57,89.32 39.57,89.13 39.69,89.02 39.86,89.02 39.98,88.9 39.98,87.83 39.85,87.71 39.46,87.71 39.34,87.82 39.34,88.55 39.23,88.67 39.04,88.67 38.92,88.55 38.92,87.82 38.81,87.71 37.77,87.71 37.56,87.5 37.56,87.17 37.29,86.89 36.9,86.89 36.73,86.71 36.73,86.28 36.55,86.1 36.19,86.1 35.96,85.88 35.96,85.35 v2(35.54,84.93)
  BOTTOM w0.14: v2(64.92,88.68) 64.92,88.4 U6600.A18 ; v2(35.54,84.93) 35.57,84.93 VRAM7000.N13
VMA_DQ22: length 43
  IN3 w0.114: v2(37.13,85.7) 37.42,85.7 37.81,86.09 40.31,86.09 40.87,86.65 40.87,88.99 41.02,89.14 41.44,89.14 41.66,88.92 42.18,88.92 42.78,89.51 43.86,89.51 44.07,89.3 47,89.3 47.42,89.72 47.76,89.72 47.9,89.86 47.9,90.37 48.07,90.54 48.23,90.54 48.89,89.89 49.02,89.89 49.2,90.06 49.2,90.23 48.56,90.87 48.56,91.03 48.72,91.19 48.88,91.19 49.52,90.55 49.68,90.55 49.83,90.7 49.83,90.89 49.2,91.51 49.2,91.68 49.37,91.84 49.53,91.84 50.16,91.21 50.29,91.21 50.48,91.4 50.48,91.53 49.74,92.27 49.74,92.4 49.9,92.57 50.13,92.57 50.84,91.85 50.98,91.85 51.71,92.58 62.72,92.58 63.73,91.57 63.73,89.99 63.85,89.87 63.85,88.7 v2(63.98,88.57)
  BOTTOM w0.14: U6600.A19 63.98,88.26 v2(63.98,88.57) ; v2(37.13,85.7) 37.14,85.7 VRAM7000.M11
VMA_DQ23: length 41.3
  IN3 w0.114: v2(64.13,87.58) 64.39,87.83 64.39,88.82 64.11,89.1 64.11,91.78 62.89,93 49.03,93 48.78,92.75 48.78,92.59 49.03,92.35 49.03,92.18 48.87,92.02 48.71,92.02 48.47,92.26 47.96,92.26 47.17,91.47 47.17,90.55 46.91,90.29 44.02,90.29 43.79,90.07 42.6,90.07 42.47,89.93 41.03,89.93 40.41,89.31 40.41,87.25 40.29,87.12 39.93,87.12 39.82,87.01 39.82,86.67 39.7,86.56 39.41,86.56 39.3,86.67 39.3,87.01 39.18,87.12 38.54,87.12 38.33,86.91 37.81,86.91 37.54,86.64 37.54,86.31 37.32,86.09 36.94,86.09 36.55,85.7 v2(36.34,85.7)
  BOTTOM w0.14: v2(64.13,87.58) 64.13,86.81 U6600.C19 ; VRAM7000.M13 v2(36.34,85.7)
VMA_DQ24: length 22.2
  IN3 w0.114: v2(42.74,82.5) 44.7,80.54 51.12,80.54 57.79,87.2 58.5,87.2 58.93,86.77 v2(59.97,86.77)
  BOTTOM w0.14: v2(59.97,86.77) U6600.B24 ; v2(42.74,82.5) 43.14,82.1 VRAM7000.U4
VMA_DQ25: length 22
  IN3 w0.114: v2(44.34,82.5) 45.31,81.53 49.43,81.53 55.99,88.1 58.2,88.1 59.1,87.2 60.25,87.2 60.4,87.05 60.4,86.4 v2(60.81,85.99)
  BOTTOM w0.14: v2(44.34,82.5) 44.74,82.1 VRAM7000.U2 ; U6600.C23 60.39,86.4 v2(60.81,85.99)
VMA_DQ26: length 19.7
  IN3 w0.114: v2(43.54,82.5) 45.08,80.96 50.08,80.96 v2(56.84,87.72)
  BOTTOM w0.14: VRAM7000.T4 43.14,82.9 v2(43.54,82.5) ; v2(56.84,87.72) 57.57,88.45 58.29,88.45 U6600.A25
VMA_DQ27: length 19.1
  IN3 w0.114: v2(45.14,82.5) 45.55,82.09 49.39,82.09 55.82,88.52 58.37,88.52 58.91,87.98 59.57,87.98 59.9,87.65 v2(59.9,87.59)
  BOTTOM w0.14: U6600.A24 59.9,87.64 v2(59.9,87.59) ; VRAM7000.T2 v2(45.14,82.5)
VMA_DQ28: length 24.1
  IN3 w0.114: v2(43.54,85.7) 43.94,86.1 50.44,86.1 55,90.66 61.01,90.66 v2(61.45,91.1)
  BOTTOM w0.14: VRAM7000.N4 43.14,85.3 v2(43.54,85.7) ; U6600.A21 62.04,88.17 61.46,88.75 61.46,90.16 61.45,90.17 v2(61.45,91.1)
VMA_DQ29: length 23.6
  IN3 w0.114: v2(45.14,85.7) 45.75,85.09 50.02,85.09 55.17,90.24 61.6,90.24 v2(61.86,90.5)
  BOTTOM w0.079: 62.17,88.37 62.38,88.16 62.38,87.75 62.04,87.41 U6600.B21
  BOTTOM w0.102: 62.17,88.37 61.69,88.86 61.69,89.69 61.86,89.86 v2(61.86,90.5)
  BOTTOM w0.14: VRAM7000.N2 45.14,85.7 v2(45.14,85.7)
VMA_DQ30: length 25.9
  IN3 w0.114: v2(42.73,85.65) 43.09,85.29 44.22,85.29 44.91,84.6 50.13,84.6 55.34,89.82 60.8,89.82 62.17,88.46 62.61,88.46 62.61,88.46 v2(62.62,88.46)
  BOTTOM w0.079: U6600.C20 62.56,86.72 62.56,88.4 v2(62.62,88.46)
  BOTTOM w0.14: v2(42.73,85.65) 43.14,86.06 VRAM7000.M4
VMA_DQ31: length 23
  IN3 w0.114: v2(45.14,86.5) 45.54,86.9 50.64,86.9 54.82,91.08 v2(60.31,91.08)
  BOTTOM w0.14: v2(45.14,86.5) 45.14,86.5 VRAM7000.M2 ; v2(60.31,91.08) 60.31,90.66 61.07,89.9 61.07,88.67 61.39,88.35 61.42,88.35 61.62,88.16 61.62,86.82 U6600.C21
VMA_DQ32: length 24.7
  IN1 w0.102: v2(60.74,76.06) 60.32,76.47 58.95,76.47 58.76,76.66 58.76,77.88 56.58,80.07 52.52,80.07 51.43,78.98 50.23,78.98 48.46,77.21 48.46,76.78 47.02,75.33 46.56,75.33 46.2,75.69 45.63,75.69 45.51,75.81 45.51,76.21 44.75,76.97 43.07,76.97 v2(42.76,77.28)
  BOTTOM w0.14: v2(60.74,76.06) 60.78,76.06 U6600.R22 ; VRAM7001.A4 v2(42.76,77.28)
VMA_DQ33: length 21.3
  IN1 w0.102: v2(59.13,76.07) 59.05,76.15 58.54,76.15 57.99,76.71 57.99,78.05 56.62,79.42 56.52,79.52 52.57,79.52 51.58,78.53 50.79,78.53 47.07,74.81 45.15,74.81 44.95,75.01 44.95,75.85 v2(44.32,76.48)
  BOTTOM w0.14: v2(59.13,76.07) 59.15,76.07 U6600.R24 ; v2(44.32,76.48) 44.73,76.9 VRAM7001.A2
VMA_DQ34: length 27.3
  IN1 w0.102: v2(61.6,76.08) 61.16,76.52 61.16,80.34 60.91,80.59 59.41,80.59 56.5,82.75 54.72,82.75 54.5,82.53 51.03,82.53 46.86,78.36 44.21,78.36 43.71,77.86 v2(43.71,77.54)
  BOTTOM w0.14: U6600.T22 61.6,76.08 v2(61.6,76.08) ; v2(43.71,77.54) 43.71,77.42 43.53,77.24 43.53,76.49 VRAM7001.B4
VMA_DQ35: length 23.1
  IN1 w0.102: v2(45.58,77.66) 46.74,77.66 51.16,82.08 54.76,82.08 54.91,82.23 56.48,82.23 58.91,79.8 60.17,79.8 60.35,79.62 60.35,78.08 60.36,78.07 60.36,77.28 v2(60.71,76.92)
  BOTTOM w0.14: U6600.R23 60.71,76.83 v2(60.71,76.92) ; VRAM7001.B2 44.74,76.36 45.14,76.77 45.14,77.23 v2(45.58,77.66)
VMA_DQ36: length 20.1
  IN1 w0.102: v2(43.54,73.3) 43.55,73.3 43.97,72.88 43.97,72.26 44.12,72.11 45.34,72.11 46.19,71.25 47.83,71.25 53.18,76.61 55.7,76.61 56,76.91 56,77.21 v2(56.5,77.72)
  BOTTOM w0.079: U6600.N25 58.53,78.14 58.19,77.8 57.61,77.8 57.43,77.62 56.6,77.62 v2(56.5,77.72)
  BOTTOM w0.14: VRAM7001.E4 v2(43.54,73.3)
VMA_DQ37: length 17.5
  IN1 w0.102: v2(54.79,77.49) 54.76,77.46 54.62,77.46 54.28,77.8 53.88,77.8 53.53,77.44 52.87,77.44 47.91,72.49 47.72,72.49 47.62,72.39 47.62,72.22 47.52,72.12 46.82,72.12 46.71,72.23 46.71,72.9 46.58,73.02 45.36,73.02 45.15,73.22 v2(45.15,73.33)
  BOTTOM w0.102: U6600.N26 57.64,78.14 57.3,77.8 56.98,77.8 56.65,78.13 56.35,78.13 55.85,77.63
  BOTTOM w0.14: 55.85,77.63 54.93,77.63 v2(54.79,77.49) ; v2(45.15,73.33) 45.11,73.33 VRAM7001.E2
VMA_DQ38: length 23.6
  IN1 w0.102: v2(43.57,72.5) 43.07,72 43.07,70.76 43.33,70.5 47.99,70.5 49.3,71.8 49.3,72.14 53.35,76.19 55.86,76.19 56.4,76.74 v2(56.4,76.87)
  BOTTOM w0.079: U6600.N23 60.06,78.14 59.64,77.72 58.62,77.72 58.52,77.62 57.78,77.62 57.55,77.39 57.55,77.06 57.45,76.96 56.49,76.96 v2(56.4,76.87)
  BOTTOM w0.14: VRAM7001.F4 43.17,72.9 v2(43.57,72.5)
VMA_DQ39: length 19
  IN1 w0.102: v2(55.8,78.52) 55.8,77.69 55.7,77.59 55.4,77.59 55.3,77.48 55.3,77.32 55,77.02 53.01,77.02 47.66,71.66 46.42,71.66 45.56,72.52 45.4,72.52 45.39,72.52 v2(45.18,72.52)
  BOTTOM w0.14: U6600.N24 59.12,78.56 56.95,78.56 56.83,78.67 55.96,78.67 v2(55.8,78.52) ; VRAM7001.F2 45.12,72.52 v2(45.18,72.52)
VMA_DQ40: length 48.3
  IN3 w0.114: v2(37.94,77.3) 37.52,76.88 37.52,76.48 37.61,76.39 38,76.39 38.37,76.76 38.79,76.76 39.84,75.71 39.84,75.29 39.72,75.18 39.32,75.18 39.2,75.07 39.2,74.84 39.32,74.72 39.72,74.72 39.84,74.61 39.84,74.09 40.25,73.68 40.25,73.27 40.13,73.15 39.95,73.15 39.84,73.04 39.84,72.81 39.95,72.69 40.13,72.69 40.25,72.58 40.25,63.81 42.44,61.62 46.55,61.62 51.65,66.72 53,66.72 53.58,67.3 53.74,67.3 53.88,67.15 54.04,67.15 54.21,67.32 54.21,67.48 54.06,67.62 54.06,67.78 54.23,67.94 54.39,67.94 54.53,67.8 54.69,67.8 54.85,67.96 54.85,68.12 54.71,68.27 54.71,68.43 55.01,68.72 55.17,68.72 55.4,68.49 55.56,68.49 55.73,68.65 55.73,68.82 55.57,68.97 55.57,69.13 56.74,70.3 57.09,70.3 57.3,70.52 57.3,71.02 57.19,71.13 57.19,71.29 57.36,71.45 57.52,71.45 57.7,71.27 57.86,71.27 58.03,71.45 58.41,71.45 58.72,71.76 58.72,72.06 59.02,72.36 60.37,72.36 v2(60.74,72.73)
  BOTTOM w0.14: U6600.V23 60.74,73.58 v2(60.74,72.73) ; v2(37.94,77.3) 37.54,76.9 VRAM7001.A11
VMA_DQ41: length 50.9
  IN3 w0.114: v2(61.57,73.59) 61.52,73.59 61.16,73.22 57.63,73.22 57.49,73.09 57.49,72.57 57.18,72.26 57.18,71.77 56.97,71.56 56.97,71.28 56.85,71.16 56.31,71.16 56.01,70.86 56.01,70.35 53.98,68.31 53.81,68.31 53.47,68.65 53.31,68.65 53.15,68.49 53.15,68.33 53.49,67.98 53.49,67.82 52.82,67.16 51.5,67.16 46.39,62.05 46.1,62.05 45.92,62.23 45.68,62.23 45.5,62.05 45.26,62.05 45.08,62.23 44.84,62.23 44.66,62.05 44.42,62.05 44.25,62.23 44,62.23 43.83,62.05 43.58,62.05 43.41,62.23 43.17,62.23 42.99,62.05 42.6,62.05 40.66,63.99 40.66,73.88 40.26,74.29 40.26,74.53 40.37,74.65 40.55,74.65 40.66,74.76 40.66,74.99 40.55,75.1 40.37,75.1 40.26,75.22 40.26,75.45 40.37,75.56 40.55,75.56 40.66,75.68 40.66,75.9 40.55,76.02 40.16,76.02 40.04,76.13 40.04,76.29 40.24,76.49 40.24,76.65 40.1,76.79 39.94,76.79 39.75,76.59 39.58,76.59 39.45,76.73 39.45,76.89 39.64,77.08 39.64,77.24 39.51,77.38 39.35,77.38 39.15,77.18 38.99,77.18 38.84,77.33 38.84,77.5 38.93,77.59 38.93,77.75 38.8,77.89 38.64,77.89 38.54,77.79 38.38,77.79 38.29,77.89 36.51,77.89 36.4,77.77 v2(36.4,77.3)
  BOTTOM w0.14: v2(36.4,77.3) 36.34,77.3 VRAM7001.A13 ; v2(61.57,73.59) U6600.V22
VMA_DQ42: length 49.8
  IN3 w0.114: v2(60.76,75.3) 60.32,74.86 60.32,74.07 60.2,73.95 56.7,73.95 56.39,73.63 56.18,73.63 55.91,73.9 55.73,73.9 55.57,73.74 55.57,73.59 55.9,73.26 55.9,73.15 55.06,72.31 55.06,71.47 54.82,71.23 54.82,70.82 53.49,69.49 52.64,69.49 46.25,63.1 43.32,63.1 43.15,63.28 43.15,63.44 43.44,63.74 43.44,63.9 43.28,64.06 43.12,64.06 42.82,63.76 42.66,63.76 41.89,64.53 41.89,69.61 42.01,69.73 42.01,74.01 42.19,74.19 42.19,75.92 41.65,76.45 41.65,76.62 41.91,76.87 41.91,77.03 41.76,77.18 41.57,77.18 41.33,76.94 41.17,76.94 41.01,77.1 41.01,77.26 41.21,77.46 41.21,77.62 41.06,77.77 40.86,77.77 40.68,77.59 40.52,77.59 39.26,78.85 v2(38.84,78.85)
  BOTTOM w0.14: U6600.T23 60.7,75.3 v2(60.76,75.3) ; VRAM7001.B11 37.94,76.5 38.68,76.5 38.84,76.65 v2(38.84,78.85)
VMA_DQ43: length 50.7
  IN3 w0.114: v2(61.52,74.41) 61.5,74.41 60.66,73.57 56.96,73.57 56.73,73.34 56.73,73.18 56.9,73.01 56.9,72.85 56.74,72.69 56.54,72.69 56.31,72.46 56.31,71.96 55.19,70.83 55.19,70.08 54.96,69.85 54.71,69.85 53.93,69.07 52.82,69.07 46.43,62.68 42.56,62.68 41.08,64.16 41.08,76.41 39.19,78.31 38.16,78.31 38.05,78.42 38.05,78.89 37.93,79 37.7,79 37.59,78.89 37.59,78.42 37.48,78.31 37.06,78.31 36.94,78.42 36.94,78.89 36.83,79 36.6,79 36.48,78.89 36.48,78.42 36.37,78.31 36.16,78.31 35.98,78.12 35.98,76.75 35.73,76.5 v2(35.54,76.5)
  BOTTOM w0.14: v2(35.54,76.5) 35.94,76.1 VRAM7001.B13 ; U6600.U22 61.52,74.48 v2(61.52,74.41)
VMA_DQ44: length 49
  IN3 w0.114: v2(37.14,74.1) 37.53,74.5 38.12,74.5 38.89,73.73 38.89,71.19 39.41,70.66 39.41,63.33 42.09,60.65 46.77,60.65 48.16,62.04 49.1,62.04 49.62,61.52 49.62,61.01 51.19,59.44 53.69,59.44 55.44,61.19 55.44,64.67 55.32,64.78 54.44,64.78 54.32,64.89 54.32,65.12 54.44,65.24 55.32,65.24 55.44,65.35 55.44,66.22 57.07,67.84 57.83,67.84 57.95,67.96 57.95,70.14 59.12,71.32 59.4,71.32 v2(59.94,71.85)
  BOTTOM w0.14: VRAM7001.E11 37.54,73.7 v2(37.14,74.1) ; v2(59.94,71.85) 59.94,71.94 U6600.Y24
VMA_DQ45: length 48.8
  IN3 w0.114: v2(35.54,73.3) 35.94,73.7 35.94,74.27 36.17,74.5 36.62,74.5 36.74,74.61 36.74,75.16 36.87,75.29 38.12,75.29 39.42,73.99 39.42,71.58 39.83,71.17 39.83,63.51 42.22,61.11 46.64,61.11 48.65,63.13 48.85,63.13 49.13,63.4 49.13,63.6 49.3,63.78 49.53,63.78 49.78,64.02 49.78,64.25 51.02,65.5 51.18,65.5 51.41,65.27 51.58,65.27 51.74,65.43 51.74,65.59 51.51,65.82 51.51,65.98 51.73,66.2 52.76,66.2 52.88,66.09 52.88,65.51 52.99,65.4 53.22,65.4 53.33,65.51 53.33,66.09 53.45,66.2 53.87,66.2 54,66.34 54.16,66.34 54.49,66.02 54.65,66.02 54.81,66.18 54.81,66.34 54.41,66.74 54.41,66.89 54.57,67.06 54.74,67.06 55.13,66.66 55.29,66.66 55.46,66.83 55.46,66.99 55.08,67.37 55.08,67.52 55.24,67.69 55.41,67.69 55.78,67.31 55.94,67.31 56.1,67.47 56.1,67.63 55.78,67.96 55.78,68.12 56.33,68.66 56.33,68.69 57,69.36 57,69.68 59.14,71.82 59.14,71.9 v2(59.13,71.91)
  BOTTOM w0.14: VRAM7001.E13 35.94,73.7 v2(35.54,73.3) ; v2(59.13,71.91) U6600.AA24

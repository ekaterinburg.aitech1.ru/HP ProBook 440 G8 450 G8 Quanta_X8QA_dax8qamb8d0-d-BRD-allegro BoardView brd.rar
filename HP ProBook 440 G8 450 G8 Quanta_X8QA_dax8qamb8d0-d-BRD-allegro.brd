# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_0_DQ_4<3>: length 51.6
  IN1 w0.079: v1(128.68,22.8) 128.49,22.98 128.04,23.66 127.13,25.86 127.13,30.46 125.89,33.44 120.84,38.49 120.84,45.28 121.31,45.74 121.31,51.79 119.62,53.48 119.62,61.11 121.16,62.65 121.84,62.65 122.32,62.16 122.32,61.7 122.48,61.33 v2(122.77,61.04)
  BOTTOM w0.109: v1(128.68,22.8) 127.68,21.8 JDIM2800.46 ; U400.BH53 122.15,61.65 v2(122.77,61.04)
M_0_DQ_4<4>: length 54.2
  IN1 w0.079: v1(131.93,27.12) 131.93,30.17 125.5,36.6 125.5,36.86 126.01,37.37 126.01,37.48 125.9,37.59 125.79,37.59 125.2,37.01 125.09,37.01 124.98,37.12 124.98,37.23 125.54,37.79 125.54,37.9 125.43,38.01 125.32,38.01 124.76,37.45 124.65,37.45 124.54,37.56 124.54,37.67 125.1,38.24 125.1,38.35 124.99,38.46 124.88,38.46 124.31,37.9 124.2,37.9 124.09,38.01 124.09,38.12 124.65,38.68 124.65,38.79 124.54,38.9 124.43,38.9 123.87,38.34 123.76,38.34 123.64,38.45 123.64,38.56 124.21,39.13 124.21,39.24 124.1,39.35 123.98,39.35 123.42,38.79 123.31,38.79 123.2,38.9 123.2,39.01 123.77,39.58 123.77,39.75 123.67,39.85 123.54,39.85 123.31,39.61 123.2,39.61 123.08,39.73 123.08,39.84 123.31,40.07 123.31,40.2 122.8,40.72 122.8,52.38 121.87,53.31 121.87,56.3 121.73,56.44 v2(121.5,56.44)
  BOTTOM w0.079: U400.BF49 120.94,64.37 120.53,63.95 120.53,63.07 120,62.54 120,59.87 119.85,59.72
  BOTTOM w0.109: v2(121.5,56.44) 119.85,58.09 119.85,59.72 ; v1(131.93,27.12) JDIM2800.63
M_0_DQ_4<5>: length 53.6
  IN1 w0.079: v2(121.5,57) 121.7,57 122.13,56.58 122.13,53.46 123.08,52.5 123.08,40.84 126.41,37.5 126.41,37.34 126.03,36.96 126.03,36.85 126.15,36.74 126.26,36.74 126.63,37.11 126.77,37.11 126.9,36.98 126.9,36.86 126.32,36.28 126.32,36.17 126.44,36.06 126.55,36.06 127.14,36.65 127.25,36.65 127.36,36.54 127.36,36.43 127,36.07 126.77,35.84 126.77,35.73 126.88,35.62 126.99,35.62 127.44,36.07 127.58,36.21 127.69,36.21 127.81,36.1 127.81,35.98 127.22,35.39 127.22,35.28 127.33,35.17 127.44,35.17 128,35.74 128.11,35.74 128.23,35.62 128.23,35.51 127.71,35 127.71,34.79 132.3,30.2 132.3,26.22 v1(131.93,25.85)
  BOTTOM w0.079: 120.18,59.59 120.18,62.49 120.71,63.02 120.71,63.7 U400.BF50
  BOTTOM w0.109: 120.18,59.59 120.18,58.32 v2(121.5,57) ; JDIM2800.59 130.93,26.85 v1(131.93,25.85)
M_0_DQ_4<6>: length 52.7
  IN1 w0.079: v1(131.68,22.79) 132.58,23.7 132.58,30.32 129.78,33.11 129.06,33.84 129.06,34.04 129.44,34.43 129.44,34.54 129.33,34.65 129.22,34.65 128.79,34.22 128.68,34.22 128.56,34.33 128.56,34.44 129.15,35.02 129.15,35.14 129.04,35.25 128.92,35.25 128.34,34.67 128.23,34.67 128.12,34.78 128.12,34.89 128.6,35.37 128.6,35.72 123.36,40.95 123.36,52.65 122.42,53.6 122.42,57.35 121.65,58.12 v2(121.5,58.12)
  BOTTOM w0.079: 120.41,62.29 120.41,62.47 120.94,63 U400.BF52
  BOTTOM w0.109: v1(131.68,22.79) 130.68,21.79 JDIM2800.58 ; 120.41,62.29 120.41,59.21 v2(121.5,58.12)
M_0_DQ_4<7>: length 51.8
  IN1 w0.079: v2(121.5,58.68) 121.63,58.68 122.71,57.59 122.71,53.74 123.65,52.8 123.65,41.07 129.78,34.94 129.78,33.52 132.71,30.58 132.86,30.43 132.86,29.62 133.02,29.46 133.5,29.46 133.58,29.38 133.58,29.22 133.5,29.14 132.94,29.14 132.86,29.06 132.86,28.9 132.94,28.83 133.5,28.83 133.58,28.75 133.58,28.59 133.5,28.51 132.94,28.51 132.86,28.43 132.86,28.27 132.94,28.2 133.5,28.2 133.58,28.12 133.58,27.96 133.5,27.88 133.04,27.88 132.86,27.71 132.86,22.71 v1(131.68,21.52)
  BOTTOM w0.109: U400.BF53 120.64,62.33 120.64,59.54 v2(121.5,58.68) ; v1(131.68,21.52) JDIM2800.62
M_0_DQ_5<0>: length 48.4
  IN3 w0.089: v1(126.68,22.79) 126.27,23.19 126.27,45.11 123.06,48.33 123.06,52.6 120.8,54.86 120.8,59.73 v2(118.96,61.57)
  BOTTOM w0.079: v2(118.96,61.57) 119.29,61.91 119.29,62.31 119.2,62.4 119.2,62.84 119.37,63.01 119.37,63.78 119.32,63.83 119.32,64.3 U400.BC49
  BOTTOM w0.109: JDIM2800.38 125.68,21.79 v1(126.68,22.79)
M_0_DQ_5<1>: length 48
  IN3 w0.089: v1(125.42,25.82) 124.83,26.41 124.83,37.97 124.92,38.05 125,38.05 125.09,38.14 125.09,38.31 124.99,38.41 124.92,38.41 124.83,38.5 124.83,38.79 124.92,38.88 125.04,38.88 125.13,38.97 125.13,39.15 125.04,39.24 124.92,39.24 124.83,39.32 124.83,39.5 124.92,39.59 125.04,39.59 125.13,39.68 125.13,39.86 125.04,39.95 124.92,39.95 124.83,40.04 124.83,40.21 124.92,40.3 125.04,40.3 125.13,40.39 125.13,40.57 125.04,40.66 124.92,40.66 124.83,40.75 124.83,40.92 124.92,41.01 125.04,41.01 125.13,41.1 125.13,41.28 125.04,41.37 124.92,41.37 124.83,41.46 124.83,41.64 124.92,41.72 125.04,41.72 125.13,41.81 125.13,41.99 125.04,42.08 124.92,42.08 124.83,42.17 124.83,42.35 124.92,42.44 125.04,42.44 125.13,42.52 125.13,42.7 125.04,42.79 124.92,42.79 124.83,42.88 124.83,43.06 124.92,43.15 125.04,43.15 125.13,43.24 125.13,43.41 125.04,43.5 124.92,43.5 124.83,43.59 124.83,43.77 124.92,43.86 125.04,43.86 125.13,43.95 125.13,44.13 125.04,44.21 124.92,44.21 124.83,44.3 124.83,44.48 124.92,44.57 125.04,44.57 125.13,44.66 125.13,44.84 125.04,44.93 124.92,44.93 124.83,45.01 124.83,45.31 122.1,48.05 122.1,52.27 120.01,54.35 120.01,58.28 v2(118.96,59.34)
  BOTTOM w0.079: U400.BC50 119.82,63.71 119.82,60.2 119.66,60.04
  BOTTOM w0.109: JDIM2800.41 126.42,26.82 v1(125.42,25.82) ; 119.66,60.04 v2(118.96,59.34)
M_0_DQ_5<2>: length 46.8
  IN3 w0.089: v2(118.96,61.01) 120.55,59.43 120.55,54.68 122.76,52.47 122.76,48.22 125.98,44.99 125.98,32.61 125.8,32.43 125.8,27.69 125.98,27.5 125.98,22.21 v1(126.68,21.52)
  BOTTOM w0.079: 119.45,61.52 119.45,62.41 119.36,62.5 119.36,62.78 119.6,63.02 U400.BC52
  BOTTOM w0.109: v1(126.68,21.52) JDIM2800.42 ; v2(118.96,61.01) 119.45,61.51 119.45,61.52
M_0_DQ_5<3>: length 46.5
  IN3 w0.089: v1(125.42,27.09) 125.13,27.39 125.13,32.67 125.22,32.76 125.58,32.76 125.67,32.85 125.67,33.03 125.58,33.12 125.22,33.12 125.13,33.21 125.13,33.39 125.22,33.47 125.6,33.47 125.69,33.56 125.69,33.74 125.6,33.83 125.22,33.83 125.13,33.92 125.13,34.1 125.22,34.19 125.6,34.19 125.69,34.27 125.69,34.45 125.6,34.54 125.22,34.54 125.13,34.63 125.13,34.81 125.22,34.9 125.6,34.9 125.69,34.99 125.69,35.16 125.6,35.25 125.22,35.25 125.13,35.34 125.13,35.52 125.22,35.61 125.6,35.61 125.69,35.7 125.69,35.87 125.6,35.96 125.22,35.96 125.13,36.05 125.13,36.23 125.22,36.32 125.6,36.32 125.69,36.41 125.69,36.59 125.6,36.67 125.22,36.67 125.13,36.76 125.13,36.94 125.22,37.03 125.6,37.03 125.69,37.12 125.69,37.3 125.6,37.39 125.22,37.39 125.13,37.47 125.13,37.77 125.42,38.07 125.42,45.14 122.43,48.13 122.43,52.37 120.29,54.51 120.29,58.56 v2(118.96,59.9)
  BOTTOM w0.079: U400.BC53 119.64,62.59 119.64,61.12 119.56,61.03
  BOTTOM w0.109: v1(125.42,27.09) JDIM2800.37 ; v2(118.96,59.9) 119.5,60.44 119.5,60.98 119.56,61.03
M_0_DQ_5<4>: length 49.5
  IN3 w0.089: v2(118.96,53.75) 119.11,53.75 121.05,51.81 121.05,47.08 123.42,44.71 123.42,35.9 123.34,35.81 123.11,35.81 123.02,35.72 123.02,35.54 123.11,35.45 123.34,35.45 123.42,35.36 123.42,35.19 123.34,35.1 123.11,35.1 123.02,35 123.02,34.83 123.11,34.74 123.34,34.74 123.42,34.65 123.42,34.47 123.34,34.38 123.11,34.38 123.02,34.29 123.02,34.12 123.11,34.03 123.34,34.03 123.42,33.94 123.42,33.76 123.34,33.67 123.11,33.67 123.02,33.58 123.02,33.41 123.11,33.32 123.34,33.32 123.42,33.23 123.42,33.05 123.34,32.96 123.11,32.96 123.02,32.87 123.02,32.7 123.11,32.61 123.34,32.61 123.42,32.52 123.42,32.34 123.34,32.25 123.11,32.25 123.02,32.16 123.02,31.98 123.11,31.9 123.34,31.9 123.42,31.81 123.42,31.63 123.34,31.54 123.11,31.54 123.02,31.45 123.02,31.27 123.11,31.18 123.34,31.18 123.42,31.1 123.42,30.92 123.34,30.83 123.11,30.83 123.02,30.74 123.02,30.56 123.11,30.47 123.34,30.47 123.42,30.38 123.42,30.21 123.34,30.12 123.11,30.12 123.02,30.03 123.02,29.85 123.11,29.76 123.34,29.76 123.42,29.67 123.42,29.5 123.34,29.41 123.08,29.41 122.99,29.32 122.99,29.14 123.08,29.05 123.34,29.05 123.42,28.96 123.42,28.78 123.34,28.7 123.06,28.7 122.97,28.61 122.97,28.43 123.07,28.34 123.34,28.34 123.42,28.25 123.42,28.07 123.34,27.98 123.06,27.98 122.97,27.9 122.97,27.73 123.07,27.63 123.34,27.63 123.42,27.54 v1(123.42,27.12)
  BOTTOM w0.079: U400.AY49 118.38,64.52 117.97,64.11 117.97,63.07 117.52,62.61 117.52,61.07 117.31,60.86
  BOTTOM w0.109: v1(123.42,27.12) JDIM2800.29 ; v2(118.96,53.75) 117,55.71 117,60.56 117.31,60.86
M_0_DQ_5<5>: length 48.9
  IN3 w0.089: v1(123.42,25.85) 122.63,26.64 122.63,36.31 122.79,36.47 122.79,36.7 122.55,36.95 122.55,37.13 122.63,37.22 122.95,37.22 123.04,37.3 123.04,37.48 122.95,37.57 122.63,37.57 122.55,37.66 122.55,37.84 122.63,37.93 122.95,37.93 123.04,38.02 123.04,38.19 122.95,38.28 122.63,38.28 122.55,38.37 122.55,38.55 122.63,38.64 122.95,38.64 123.04,38.73 123.04,38.9 122.95,38.99 122.63,38.99 122.55,39.08 122.55,39.26 122.63,39.35 122.95,39.35 123.04,39.44 123.04,39.62 122.95,39.71 122.63,39.71 122.55,39.79 122.55,39.97 122.63,40.06 122.95,40.06 123.04,40.15 123.04,40.33 122.95,40.42 122.63,40.42 122.55,40.51 122.55,40.68 122.63,40.77 122.95,40.77 123.04,40.86 123.04,44.69 120.75,46.97 120.75,51.41 118.57,53.59 118.57,54.47 v2(118.96,54.87)
  BOTTOM w0.079: 117.56,60.61 117.67,60.72 117.67,62.54 118.15,63.02 118.15,63.7 U400.AY50
  BOTTOM w0.109: 117.56,60.61 117.36,60.4 117.36,56.47 v1(117.6,56.22) v2(118.96,54.87) ; v1(123.42,25.85) 122.42,26.85 JDIM2800.25
M_0_DQ_5<6>: length 47.8
  IN3 w0.089: v1(123.18,22.84) 122.99,22.84 122.25,23.58 122.25,41.22 122.34,41.31 122.59,41.31 122.68,41.4 122.68,41.58 122.59,41.66 122.34,41.66 122.25,41.75 122.25,41.93 122.34,42.02 122.59,42.02 122.68,42.11 122.68,44.63 120.47,46.84 120.47,51.38 118.31,53.54 118.31,55.34 v2(118.96,55.99)
  BOTTOM w0.079: 117.71,60.25 117.85,60.39 117.85,62.47 118.38,63 U400.AY52
  BOTTOM w0.109: 117.71,60.25 117.71,57.26 118.96,56.01 v2(118.96,55.99) ; v1(123.18,22.84) 122.18,21.84 JDIM2800.24
M_0_DQ_5<7>: length 47.1
  IN3 w0.089: v1(123.18,21.57) 121.96,22.78 121.96,42.34 122.05,42.42 122.18,42.42 122.27,42.52 122.27,42.69 122.18,42.78 122.05,42.78 121.96,42.87 121.96,43.05 122.05,43.14 122.3,43.14 122.39,43.22 122.39,43.4 122.3,43.49 122.05,43.49 121.96,43.58 121.96,43.76 122.05,43.85 122.3,43.85 122.39,43.94 122.39,44.11 122.3,44.2 122.05,44.2 121.96,44.29 121.96,44.94 120.14,46.76 120.14,51.41 118.03,53.52 118.03,55.62 v2(118.96,56.54)
  BOTTOM w0.109: U400.AY53 118.07,62.32 118.07,57.43 v2(118.96,56.54) ; v1(123.18,21.57) JDIM2800.28
M_0_DQ_6<0>: length 56.6
  IN3 w0.089: v1(133.68,21.53) 132.43,22.78 132.43,36.62 132.52,36.71 132.67,36.71 132.76,36.8 132.76,36.98 132.67,37.07 132.52,37.07 132.43,37.16 132.43,37.33 132.52,37.42 132.77,37.42 132.86,37.51 132.86,37.69 132.77,37.78 132.52,37.78 132.43,37.87 132.43,38.04 132.52,38.13 132.77,38.13 132.86,38.22 132.86,38.4 132.77,38.49 132.52,38.49 132.43,38.58 132.43,38.76 132.52,38.84 132.77,38.84 132.86,38.93 132.86,39.11 132.77,39.2 132.52,39.2 132.43,39.29 132.43,39.8 123.39,48.84 123.39,52.79 121.07,55.11 121.07,62.9 120.62,63.35 120.62,64.56 120.44,64.74 120.44,65.6 120.83,65.98 120.83,67.44 v2(121.36,67.97)
  BOTTOM w0.109: U400.BH41 121.64,68.26 v2(121.36,67.97) ; v1(133.68,21.53) JDIM2800.70
M_0_DQ_6<1>: length 55.4
  IN3 w0.089: v2(122.27,67.97) 122.86,67.39 122.86,67.05 123.62,66.29 123.62,64.82 125.07,63.37 125.07,56.59 126.39,55.27 126.39,50.33 137.25,39.47 137.25,24.98 138.21,24.01 138.21,22.57 v1(137.17,21.54)
  BOTTOM w0.109: U400.BK41 122.56,68.26 v2(122.27,67.97) ; v1(137.17,21.54) JDIM2800.84
M_0_DQ_6<2>: length 54.9
  IN3 w0.089: v2(122.27,67.32) 122.65,66.94 122.65,66.09 123.16,65.58 123.16,64.84 124.76,63.24 124.76,56.46 126.08,55.14 126.08,50.22 136.95,39.35 136.95,24.85 137.92,23.89 137.92,23.55 v1(137.17,22.81)
  BOTTOM w0.109: JDIM2800.80 136.17,21.81 v1(137.17,22.81) ; U400.BK42 122.56,67.61 v2(122.27,67.32)
M_0_DQ_6<3>: length 56.1
  IN3 w0.089: v2(121.36,67.32) 121,66.97 121,65.83 120.75,65.58 120.75,64.86 120.88,64.73 120.88,64.05 121.88,63.05 121.88,54.73 123.7,52.91 123.7,48.95 133.15,39.49 133.15,36.33 133.06,36.24 132.81,36.24 132.72,36.15 132.72,35.97 132.81,35.88 133.06,35.88 133.15,35.79 133.15,35.61 133.06,35.52 132.81,35.52 132.72,35.44 132.72,35.26 132.81,35.17 133.06,35.17 133.15,35.08 133.15,34.9 133.06,34.81 132.81,34.81 132.72,34.72 132.72,34.55 132.81,34.46 133.06,34.46 133.15,34.37 133.15,34.19 133.06,34.1 132.81,34.1 132.72,34.01 132.72,23.76 v1(133.68,22.8)
  BOTTOM w0.109: U400.BH42 121.64,67.61 v2(121.36,67.32) ; v1(133.68,22.8) 132.68,21.8 JDIM2800.66
M_0_DQ_6<4>: length 54.3
  IN3 w0.089: v2(121.36,66.02) 121.36,65.91 120.98,65.53 120.98,64.92 121.11,64.79 121.11,64.11 122.12,63.09 122.12,59.66 122.27,59.51 122.27,54.77 124,53.04 124,49.06 133.44,39.62 133.44,34.07 133.01,33.64 133.01,33.35 133.1,33.26 133.35,33.26 133.44,33.17 133.44,32.99 133.35,32.9 133.1,32.9 133.01,32.82 133.01,32.64 133.1,32.55 133.35,32.55 133.44,32.46 133.44,32.28 133.35,32.19 133.1,32.19 133.01,32.1 133.01,31.93 133.1,31.84 133.35,31.84 133.44,31.75 133.44,31.57 133.35,31.48 133.1,31.48 133.01,31.39 133.01,31.22 133.1,31.13 133.35,31.13 133.44,31.04 133.44,30.86 133.35,30.77 133.1,30.77 133.01,30.68 133.01,30.5 133.1,30.42 133.35,30.42 133.44,30.33 133.44,30.15 133.35,30.06 133.1,30.06 133.01,29.97 133.01,29.79 133.1,29.7 133.35,29.7 133.44,29.62 133.44,29.44 133.35,29.35 133.1,29.35 133.01,29.26 133.01,25.79 133.19,25.61 133.69,25.61 v1(133.93,25.84)
  BOTTOM w0.109: U400.BH45 121.64,66.31 v2(121.36,66.02) ; v1(133.93,25.84) 132.93,26.84 JDIM2800.67
M_0_DQ_6<5>: length 54.4
  IN3 w0.089: v2(121.36,65.37) 121.36,64.23 122.39,63.2 122.39,59.88 122.68,59.59 122.68,54.79 124.31,53.17 124.31,49.17 133.73,39.74 133.73,39.19 133.82,39.1 134.04,39.1 134.13,39.02 134.13,38.84 134.04,38.75 133.82,38.75 133.73,38.66 133.73,38.48 133.82,38.39 134.04,38.39 134.13,38.3 134.13,38.13 134.04,38.04 133.82,38.04 133.73,37.95 133.73,37.77 133.82,37.68 134.04,37.68 134.13,37.59 134.13,37.41 134.04,37.33 133.82,37.33 133.73,37.24 133.73,37.06 133.82,36.97 134.04,36.97 134.13,36.88 134.13,36.7 134.04,36.61 133.82,36.61 133.73,36.53 133.73,36.35 133.82,36.26 134.04,36.26 134.13,36.17 134.13,35.99 134.04,35.9 133.82,35.9 133.73,35.81 133.73,35.64 133.82,35.55 134.04,35.55 134.13,35.46 134.13,35.28 134.04,35.19 133.82,35.19 133.73,35.1 133.73,34.93 133.82,34.84 134.04,34.84 134.13,34.75 134.13,34.57 134.04,34.48 133.82,34.48 133.73,34.39 133.73,34.21 133.82,34.13 134.04,34.13 134.13,34.04 134.13,33.86 134.04,33.77 133.82,33.77 133.73,33.68 133.73,33.5 133.82,33.41 134.04,33.41 134.13,33.33 134.13,33.15 134.04,33.06 133.82,33.06 133.73,32.97 133.73,32.79 133.82,32.7 134.04,32.7 134.13,32.61 134.13,32.44 134.04,32.35 133.82,32.35 133.73,32.26 133.73,32.08 133.82,31.99 134.04,31.99 134.13,31.9 134.13,31.73 134.04,31.64 133.82,31.64 133.73,31.55 133.73,31.37 133.82,31.28 134.04,31.28 134.13,31.19 134.13,31.01 134.04,30.93 133.82,30.93 133.73,30.84 133.73,30.66 133.82,30.57 134.04,30.57 134.13,30.48 134.13,30.3 134.04,30.21 133.82,30.21 133.73,30.13 133.73,29.95 133.82,29.86 134.04,29.86 134.13,29.77 134.13,29.59 134.04,29.5 133.82,29.5 133.73,29.41 133.73,29.12 133.65,29.03 133.42,29.03 133.33,28.94 133.33,28.77 133.42,28.68 133.64,28.68 133.73,28.59 133.73,28.42 133.64,28.32 133.53,28.32 133.44,28.23 133.44,27.6 v1(133.93,27.11)
  BOTTOM w0.109: U400.BH47 121.64,65.66 v2(121.36,65.37) ; v1(133.93,27.11) JDIM2800.71
M_0_DQ_6<6>: length 52.6
  IN3 w0.089: v2(122.27,66.02) 122.86,65.44 122.86,64.72 124.46,63.11 124.46,56.33 125.78,55.01 125.78,50.12 136.52,39.37 136.52,35.82 136.43,35.74 135.93,35.74 135.84,35.65 135.84,35.47 135.93,35.38 136.43,35.38 136.52,35.29 136.52,35.11 136.43,35.02 135.93,35.02 135.84,34.93 135.84,34.76 135.93,34.67 136.43,34.67 136.52,34.58 136.52,34.4 136.43,34.31 135.93,34.31 135.84,34.22 135.84,34.05 135.93,33.96 136.43,33.96 136.52,33.87 136.52,33.69 136.43,33.6 135.93,33.6 135.84,33.51 135.84,33.33 135.93,33.25 136.43,33.25 136.52,33.16 136.52,32.98 136.43,32.89 135.93,32.89 135.84,32.8 135.84,32.62 135.93,32.53 136.28,32.53 136.37,32.45 136.37,32.28 136.27,32.18 136.01,32.18 135.93,32.09 v1(135.93,27.12)
  BOTTOM w0.109: v1(135.93,27.12) JDIM2800.79 ; v2(122.27,66.02) 122.56,66.31 U400.BK45
M_0_DQ_6<7>: length 53.1
  IN3 w0.089: v1(135.93,25.85) 135.54,26.23 135.54,36.03 135.63,36.12 135.99,36.12 136.08,36.2 136.08,36.38 135.99,36.47 135.63,36.47 135.54,36.56 135.54,36.74 135.63,36.83 135.99,36.83 136.08,36.92 136.08,37.09 135.99,37.18 135.63,37.18 135.54,37.27 135.54,37.45 135.63,37.54 135.99,37.54 136.08,37.63 136.08,37.81 135.99,37.89 135.63,37.89 135.54,37.98 135.54,38.16 135.63,38.25 135.99,38.25 136.08,38.34 136.08,38.52 135.99,38.61 135.63,38.61 135.54,38.69 135.54,38.87 135.63,38.96 135.99,38.96 136.08,39.05 136.08,39.23 135.99,39.32 135.63,39.32 135.54,39.41 135.54,39.94 125.47,50.01 125.47,54.89 124.18,56.18 124.18,62.96 122.55,64.59 122.55,65.09 v2(122.27,65.37)
  BOTTOM w0.109: v2(122.27,65.37) 122.56,65.66 U400.BK47 ; JDIM2800.83 136.93,26.85 v1(135.93,25.85)
M_0_DQ_7<0>: length 51.9
  IN1 w0.079: v1(121.42,25.83) 122.8,27.21 122.8,31.52 122.65,31.66 122.02,31.66 121.94,31.74 121.94,31.9 122.02,31.98 122.58,31.98 122.74,32.14 122.74,35.36 119.97,38.13 119.97,45.25 120.77,46.05 120.77,51.36 118.51,53.62 118.51,62.23 119.63,63.34 120.19,63.34 120.88,64.03 120.88,65.15 120.07,65.95 120.07,67.43 v2(119.53,67.97)
  BOTTOM w0.109: U400.BD41 119.81,68.26 v2(119.53,67.97) ; JDIM2800.17 120.42,26.83 v1(121.42,25.83)
M_0_DQ_7<1>: length 51.6
  IN1 w0.079: v2(119.53,67.32) 119.9,66.95 119.9,65.84 120.61,65.13 120.61,64.12 120.21,63.71 119.72,63.71 118.22,62.22 118.22,53.5 120.5,51.23 120.5,46.2 119.69,45.4 119.69,38.01 121.61,36.09 121.61,35.36 121.69,35.28 122.17,35.28 122.25,35.2 122.25,35.04 122.17,34.97 121.69,34.97 121.61,34.89 121.61,34.73 121.69,34.65 122.17,34.65 122.25,34.57 122.25,34.41 122.17,34.34 121.69,34.34 121.61,34.26 121.61,34.1 121.69,34.02 122.17,34.02 122.25,33.94 122.25,33.78 122.17,33.71 121.69,33.71 121.61,33.63 121.61,33.47 121.69,33.39 122.17,33.39 122.25,33.31 122.25,33.15 122.17,33.08 121.69,33.08 121.61,33 121.61,32.84 121.69,32.76 122.17,32.76 122.25,32.68 122.25,32.52 122.17,32.45 121.69,32.45 121.61,32.37 121.61,31.56 121.84,31.32 121.84,27.52 v1(121.42,27.1)
  BOTTOM w0.109: v1(121.42,27.1) JDIM2800.21 ; v2(119.53,67.32) 119.81,67.61 U400.BD42
M_0_DQ_7<2>: length 53.5
  IN1 w0.079: v2(118.61,67.97) 118.07,67.43 118.07,65.92 116.8,64.64 116.18,64.64 114.76,63.22 114.76,61.82 115.85,60.73 115.85,52.42 118.29,49.98 118.29,47.34 116.89,45.95 116.89,31.84 116.97,31.76 117.24,31.76 117.32,31.68 117.32,31.52 117.24,31.45 116.97,31.45 116.89,31.37 116.89,29.42 116.97,29.34 117.57,29.34 117.65,29.26 117.65,29.1 117.57,29.03 116.97,29.03 116.89,28.95 116.89,28.79 116.97,28.71 117.57,28.71 117.65,28.63 117.65,28.47 117.57,28.4 116.95,28.4 116.88,28.32 116.88,28.16 116.95,28.08 117.57,28.08 117.65,28 117.65,27.85 117.57,27.77 116.97,27.77 116.85,27.64 116.85,26.6 116.99,26.46 v1(117.42,26.46)
  BOTTOM w0.109: U400.BB41 118.9,68.26 v2(118.61,67.97) ; v1(117.42,26.46) 117.85,26.89 117.85,27.35 117.93,27.42 JDIM2800.7
M_0_DQ_7<3>: length 52.7
  IN1 w0.079: v1(117.42,25.19) 117.97,25.73 117.97,29.97 117.83,30.11 117.37,30.11 117.3,30.18 117.3,30.34 117.37,30.42 117.89,30.42 117.97,30.5 117.97,30.66 117.89,30.74 117.37,30.74 117.3,30.81 117.3,30.97 117.37,31.05 117.86,31.05 117.97,31.16 117.97,31.56 117.17,32.35 117.17,32.53 117.25,32.6 117.52,32.6 117.6,32.68 117.6,32.84 117.52,32.92 117.25,32.92 117.17,33 117.17,45.82 118.57,47.22 118.57,50.16 116.13,52.6 116.13,60.86 115.62,61.36 115.62,62.96 117.96,65.3 117.96,65.53 118.26,65.84 118.26,66.97 v2(118.61,67.32)
  BOTTOM w0.109: v1(117.42,25.19) 116.93,25.69 JDIM2800.3 ; v2(118.61,67.32) 118.9,67.61 U400.BB42
M_0_DQ_7<4>: length 51.3
  IN1 w0.079: v2(118.61,66.02) 118.61,65.92 118.23,65.53 118.23,64.29 117.03,63.09 116.25,63.09 115.82,62.65 115.82,61.56 116.42,60.96 116.42,52.72 118.82,50.32 118.82,47.09 117.46,45.73 117.46,34.15 117.53,34.07 117.78,34.07 117.85,33.99 117.85,33.83 117.78,33.75 117.53,33.75 117.46,33.68 117.46,33.49 118.25,32.7 118.25,24.57 117.7,24.03 117.7,23.45 117.95,23.21 v1(118.11,23.21)
  BOTTOM w0.109: v2(118.61,66.02) 118.9,66.31 U400.BB45 ; v1(118.11,23.21) 118.18,23.15 JDIM2800.8
M_0_DQ_7<5>: length 50.4
  IN1 w0.079: v1(121.18,22.79) 120.79,23.18 120.79,24.49 121.05,24.76 121.05,27.44 121.56,27.95 121.56,31.21 121.14,31.63 121.14,36.16 119.41,37.89 119.41,45.52 120.24,46.35 120.24,51.08 117.93,53.39 117.93,62.25 119.76,64.08 119.76,64.55 119.9,64.69 119.9,65.53 119.53,65.91 v2(119.53,66.02)
  BOTTOM w0.109: v1(121.18,22.79) 120.18,21.79 JDIM2800.16 ; U400.BD45 119.81,66.31 v2(119.53,66.02)
M_0_DQ_7<6>: length 50.9
  IN1 w0.079: v2(118.61,65.37) 118.61,64.41 116.98,62.78 116.3,62.78 116.08,62.56 116.08,61.57 116.61,61.04 116.61,52.93 119.07,50.47 119.07,46.91 117.74,45.58 117.74,34.61 118.53,33.81 118.53,33.62 118.45,33.54 118.21,33.54 118.13,33.46 118.13,33.3 118.21,33.22 118.45,33.22 118.53,33.14 118.53,22.8 118.4,22.67 v1(117.68,22.67)
  BOTTOM w0.109: JDIM2800.4 117.18,22.17 v1(117.68,22.67) ; U400.BB47 118.9,65.66 v2(118.61,65.37)
M_0_DQ_7<7>: length 49.4
  IN1 w0.079: v1(121.18,21.52) 120.5,22.2 120.5,24.61 120.77,24.89 120.77,27.55 121.28,28.06 121.28,31.09 120.68,31.69 120.68,36.22 119.13,37.78 119.13,45.62 119.96,46.45 119.96,50.98 117.58,53.36 117.58,62.21 119.53,64.16 v2(119.53,65.4)
  BOTTOM w0.109: v1(121.18,21.52) JDIM2800.20 ; v2(119.53,65.4) 119.79,65.66 U400.BD47
M_1_DQ_0<0>: length 55.4
  IN1 w0.079: v1(98.22,22.78) 97.79,23.21 97.79,26.46 96.95,27.3 96.95,35.84 106.7,45.59 106.7,51.7 109.66,54.66 113.08,54.66 v2(114.67,56.25)
  BOTTOM w0.079: U400.AP49 115.98,64.31 115.98,63.71 116.11,63.59 116.11,61.5 116.04,61.43 116.04,61.14
  BOTTOM w0.109: v1(98.22,22.78) 97.22,21.78 JDIM2900.224 ; v2(114.67,56.25) 116.04,57.62 116.04,61.14
M_1_DQ_0<1>: length 54.7
  IN1 w0.079: v1(98.47,25.86) 98.08,26.24 98.08,26.68 97.43,27.33 97.43,27.66 97.57,27.79 97.84,27.79 97.91,27.87 97.91,28.03 97.84,28.11 97.51,28.11 97.43,28.19 97.43,28.35 97.51,28.42 97.84,28.42 97.91,28.5 97.91,28.66 97.84,28.74 97.51,28.74 97.43,28.82 97.43,28.98 97.51,29.05 97.84,29.05 97.91,29.13 97.91,29.29 97.84,29.37 97.52,29.37 97.43,29.46 97.43,35.93 106.99,45.48 106.99,51.69 109.7,54.4 114.48,54.4 115.06,54.99 115.06,56.97 v2(114.67,57.36)
  BOTTOM w0.079: 115.76,61 115.76,61.43 115.95,61.62 115.95,63.44 115.71,63.68 U400.AP50
  BOTTOM w0.109: v2(114.67,57.36) 115.76,58.46 115.76,61 ; v1(98.47,25.86) 97.47,26.86 JDIM2900.225
M_1_DQ_0<2>: length 54
  IN1 w0.079: v1(98.22,21.51) 98.6,21.89 99,22.86 99,36.7 107.57,45.26 107.57,51.63 109.83,53.9 114.73,53.9 115.59,54.76 115.59,58.11 v2(114.67,59.04)
  BOTTOM w0.079: U400.AP52 115.71,63 115.4,62.69 115.4,62.39 115.53,62.26 115.53,61.75 115.1,61.31 115.1,60.76
  BOTTOM w0.109: v2(114.67,59.04) 115.1,59.47 115.1,60.76 ; v1(98.22,21.51) JDIM2900.228
M_1_DQ_0<3>: length 53.1
  IN1 w0.079: v1(98.47,27.13) 98.47,29.85 98.32,30 97.97,30 97.89,30.08 97.89,30.24 97.97,30.32 98.39,30.32 98.47,30.39 98.47,30.55 98.39,30.63 97.97,30.63 97.89,30.71 97.89,30.87 97.97,30.95 98.39,30.95 98.47,31.02 98.47,31.18 98.39,31.26 97.97,31.26 97.89,31.34 97.89,31.5 97.97,31.57 98.39,31.57 98.47,31.65 98.47,31.81 98.39,31.89 97.97,31.89 97.89,31.97 97.89,32.13 97.97,32.2 98.39,32.2 98.47,32.28 98.47,32.44 98.39,32.52 97.97,32.52 97.89,32.6 97.89,32.76 97.97,32.83 98.39,32.83 98.47,32.91 98.47,33.07 98.39,33.15 97.97,33.15 97.89,33.23 97.89,33.39 97.97,33.46 98.36,33.46 98.47,33.57 98.47,36.56 107.28,45.38 107.28,51.68 109.75,54.15 114.58,54.15 115.29,54.86 115.29,57.86 v2(114.67,58.48)
  BOTTOM w0.079: 115.43,60.91 115.43,61.36 115.78,61.72 115.78,62.56 U400.AP53
  BOTTOM w0.109: v1(98.47,27.13) JDIM2900.229 ; v2(114.67,58.48) 115.43,59.24 115.43,60.91
M_1_DQ_0<4>: length 54.2
  IN1 w0.079: v2(113.24,61.24) 111.57,59.57 111.57,57.84 109.87,56.13 109.04,56.13 104.4,51.49 104.4,47.5 100.05,43.15 100.05,42.11 93.99,36.05 93.99,22.13 94.61,21.52 v1(95.22,21.52)
  BOTTOM w0.079: v2(113.24,61.24) 113.57,61.57 113.57,62.56 114.08,63.07 114.08,64.11 114.49,64.52 U400.AL49
  BOTTOM w0.109: v1(95.22,21.52) JDIM2900.216
M_1_DQ_0<5>: length 53.8
  IN1 w0.079: v1(95.22,22.79) 94.56,22.79 94.29,23.06 94.29,35.95 100.21,41.87 100.33,41.99 100.33,43.03 104.69,47.39 104.69,51.43 109.14,55.88 110.02,55.88 111.87,57.72 111.87,58.74 v2(113.24,60.12)
  BOTTOM w0.079: 113.8,62.39 113.8,62.56 114.26,63.02 114.26,63.7 U400.AL50
  BOTTOM w0.109: v1(95.22,22.79) 94.22,21.79 JDIM2900.212 ; 113.8,62.39 113.8,60.68 v2(113.24,60.12)
M_1_DQ_0<6>: length 53.2
  IN1 w0.079: v2(113.24,59.56) 112.6,58.92 112.6,58.81 112.74,58.67 112.74,58.56 112.63,58.45 112.52,58.45 112.38,58.59 112.27,58.59 112.16,58.48 112.16,57.6 110.18,55.62 109.24,55.62 104.98,51.36 104.98,47.28 101.98,44.28 101.98,44.11 102.31,43.78 102.31,43.67 102.2,43.56 102.09,43.56 101.78,43.86 101.67,43.86 101.56,43.75 101.56,43.64 101.91,43.29 101.91,43.18 101.8,43.06 101.69,43.06 101.36,43.39 101.25,43.39 101.14,43.28 101.14,43.17 101.47,42.84 101.47,42.73 101.36,42.62 101.25,42.62 100.94,42.92 100.83,42.92 100.72,42.81 100.72,42.7 100.96,42.46 100.96,42.22 94.58,35.84 94.58,26.24 94.83,25.99 v1(94.97,25.85)
  BOTTOM w0.079: U400.AL52 114.49,63 114.08,62.59 114.08,62.26
  BOTTOM w0.109: v1(94.97,25.85) 94.83,25.99 93.97,26.85 JDIM2900.211 ; v2(113.24,59.56) 114.08,60.4 114.08,62.26
M_1_DQ_0<7>: length 52.7
  IN1 w0.079: v1(94.97,27.12) 94.97,35.83 102.74,43.6 102.74,43.81 102.38,44.17 102.38,44.28 102.49,44.39 102.61,44.39 103.01,43.99 103.12,43.99 103.23,44.1 103.23,44.21 102.83,44.61 102.83,44.73 102.94,44.84 103.04,44.84 103.46,44.43 103.57,44.43 103.68,44.54 103.68,44.65 103.27,45.07 103.27,45.17 103.38,45.28 103.5,45.28 103.9,44.88 104.01,44.88 104.13,44.99 104.13,45.1 103.74,45.49 103.74,45.6 103.85,45.71 103.96,45.71 104.35,45.32 104.46,45.32 104.57,45.43 104.57,45.54 104.18,45.93 104.18,46.04 104.3,46.15 104.41,46.15 104.79,45.77 104.9,45.77 105.03,45.89 105.03,45.99 104.65,46.38 104.65,46.55 104.85,46.75 104.96,46.75 105.07,46.64 105.18,46.64 105.29,46.75 105.29,46.86 105.18,46.97 105.18,47.08 105.27,47.18 105.27,51.27 109.37,55.37 110.34,55.37 112.46,57.49 112.46,58.08 112.55,58.16 112.96,58.16 v2(113.24,58.44)
  BOTTOM w0.109: v2(113.24,58.44) 113.71,58.91 113.71,59.71 114.36,60.36 114.36,62.5 U400.AL53 ; v1(94.97,27.12) JDIM2900.215
M_1_DQ_1<0>: length 57.3
  IN1 w0.079: v1(89.72,21.55) 90.46,21.55 90.57,21.66 90.57,22.25 90.39,22.43 90.39,24.04 90.57,24.23 90.57,37.66 100.18,47.27 100.18,48.47 101.5,49.8 101.5,51.24 105.59,55.32 v2(105.59,55.35)
  BOTTOM w0.079: U400.AH49 113.16,64.46 113.45,64.17 113.45,62.97 113.39,62.92 113.39,61.88 112.89,61.38 112.89,60.93
  BOTTOM w0.109: JDIM2900.194 v1(89.72,21.55) ; 112.89,60.93 112.89,58.51 110.61,56.23 108.05,56.23 107.17,55.35 v2(105.59,55.35)
M_1_DQ_1<1>: length 57
  IN1 w0.079: v1(89.72,22.82) 89.33,23.2 89.33,37.62 95.96,44.25 95.96,45.46 100.58,50.07 100.58,51.5 106.46,57.39 107.51,57.39 v2(107.56,57.44)
  BOTTOM w0.079: U400.AH50 113.16,63.69 112.91,63.45 112.91,63 112.78,62.86 112.78,62.4 112.86,62.32 112.86,62.02 112.16,61.32
  BOTTOM w0.109: JDIM2900.190 88.72,21.82 v1(89.72,22.82) ; 112.16,61.32 112.16,58.9 110.36,57.1 107.9,57.1 v2(107.56,57.44)
M_1_DQ_1<2>: length 55.9
  IN1 w0.079: v1(90.02,25.82) 89.62,26.21 89.62,37.52 96.63,44.52 96.63,44.84 96.31,45.17 96.31,45.28 96.42,45.39 96.53,45.39 96.96,44.96 97.07,44.96 97.18,45.07 97.18,45.18 96.77,45.59 96.77,45.72 96.86,45.81 97,45.81 97.4,45.41 97.51,45.41 97.62,45.52 97.62,45.63 97.23,46.02 97.23,46.32 100.89,49.99 100.89,51.49 105.98,56.57 v2(106.82,56.57)
  BOTTOM w0.079: U400.AH52 113.16,63.01 112.94,62.79 112.94,62.49 113.04,62.39 113.04,61.98 112.41,61.34 112.41,60.83
  BOTTOM w0.109: JDIM2900.191 88.97,26.82 89.97,25.82 v1(90.02,25.82) ; v2(106.82,56.57) 107.41,56.57 107.66,56.82 110.44,56.82 112.41,58.79 112.41,60.83
M_1_DQ_1<3>: length 55.2
  IN1 w0.079: v2(106.42,56.16) 105.87,56.16 101.21,51.5 101.21,49.91 99.44,48.13 99.44,47.95 99.89,47.5 99.89,47.39 99.78,47.27 99.67,47.27 99.18,47.76 99.07,47.76 98.96,47.65 98.96,47.54 99.45,47.05 99.45,46.94 99.34,46.83 99.23,46.83 98.76,47.29 98.65,47.29 98.54,47.18 98.54,47.07 99,46.61 99,46.5 98.89,46.38 98.78,46.38 98.34,46.82 98.23,46.82 98.12,46.71 98.12,46.6 98.56,46.16 98.56,46.05 98.45,45.94 98.33,45.94 97.87,46.4 97.76,46.4 97.65,46.29 97.65,46.18 98.07,45.76 98.07,45.56 89.92,37.41 89.92,27.19 v1(90.02,27.09)
  BOTTOM w0.079: 112.66,60.86 112.66,61.37 113.22,61.93 113.22,62.57 U400.AH53
  BOTTOM w0.109: v1(90.02,27.09) 89.97,27.14 JDIM2900.195 ; 112.66,60.86 112.66,58.63 110.56,56.54 107.85,56.54 107.47,56.16 v2(106.42,56.16)
M_1_DQ_1<4>: length 55.7
  IN1 w0.079: v2(110.86,62.03) 109.9,61.08 109.9,57.64 109.36,57.1 108.63,57.1 102.93,51.39 102.93,48.05 102.71,47.83 102.6,47.83 102.26,48.17 102.15,48.17 102.04,48.06 102.04,47.95 102.37,47.61 102.37,47.5 102.26,47.39 102.15,47.39 101.81,47.73 101.7,47.73 101.59,47.62 101.59,47.5 101.93,47.17 101.93,47.05 91.99,37.12 91.99,25.03 92.54,24.49 92.54,22.18 v1(93.22,21.5)
  BOTTOM w0.079: v2(110.86,62.03) 110.86,62.38 111.54,63.06 111.54,63.57 111.59,63.62 111.59,64.24 U400.AF49
  BOTTOM w0.109: v1(93.22,21.5) JDIM2900.208
M_1_DQ_1<5>: length 55.4
  IN1 w0.079: v1(93.22,22.77) 92.83,23.16 92.83,24.61 92.29,25.15 92.29,37.01 92.41,37.13 92.61,37.13 92.97,36.77 93.08,36.77 93.19,36.88 93.19,36.99 92.84,37.35 92.84,37.46 92.95,37.57 93.06,37.57 93.42,37.22 93.53,37.22 93.64,37.33 93.64,37.44 93.27,37.81 93.27,37.99 103.22,47.94 103.22,51.32 108.78,56.89 109.51,56.89 110.2,57.57 110.2,60.25 v2(110.86,60.91)
  BOTTOM w0.079: U400.AF50 111.94,63.75 111.69,63.5 111.69,63 111.21,62.51 111.21,61.27 v2(110.86,60.91)
  BOTTOM w0.109: v1(93.22,22.77) 92.22,21.77 JDIM2900.204
M_1_DQ_1<6>: length 54.5
  IN1 w0.079: v2(110.86,59.8) 110.46,59.4 110.46,57.48 109.62,56.63 108.86,56.63 103.51,51.29 103.51,47.84 95.5,39.82 95.5,39.66 95.88,39.28 95.88,39.17 95.77,39.06 95.66,39.06 95.25,39.46 95.14,39.46 95.03,39.35 95.03,39.24 95.43,38.83 95.43,38.72 95.32,38.61 95.21,38.61 94.81,39.01 94.69,39.01 94.59,38.91 94.59,38.79 94.99,38.39 94.99,38.28 94.88,38.16 94.76,38.16 94.36,38.57 94.24,38.57 94.13,38.46 94.13,38.35 94.54,37.94 94.54,37.83 94.43,37.72 94.32,37.72 93.91,38.12 93.8,38.12 93.69,38.01 93.69,37.91 94.08,37.51 94.08,37.37 92.58,35.87 92.58,26.26 92.97,25.87 v1(92.97,25.83)
  BOTTOM w0.079: U400.AF52 111.94,63.01 111.37,62.44 111.37,60.31 v2(110.86,59.8)
  BOTTOM w0.109: JDIM2900.203 91.97,26.83 v1(92.97,25.83)
M_1_DQ_1<7>: length 54
  IN1 w0.079: v2(110.86,58.68) 110.86,58.68 110.86,57.52 109.72,56.38 108.93,56.38 103.8,51.25 103.8,47.73 99.06,42.99 99.06,42.87 99.46,42.47 99.46,42.35 99.35,42.24 99.24,42.24 98.84,42.65 98.73,42.65 98.62,42.53 98.62,42.42 99.02,42.02 99.02,41.91 98.91,41.8 98.8,41.8 98.39,42.2 98.28,42.2 98.17,42.09 98.17,41.98 98.57,41.57 98.57,41.46 98.46,41.35 98.35,41.35 97.95,41.75 97.84,41.75 97.73,41.64 97.73,41.53 98.13,41.13 98.13,41.02 98.02,40.91 97.91,40.91 97.5,41.31 97.39,41.31 97.28,41.2 97.28,41.09 97.68,40.68 97.68,40.57 97.57,40.46 97.46,40.46 97.11,40.81 97,40.81 96.89,40.7 96.89,40.59 97.24,40.24 97.24,40.13 97.13,40.02 97.01,40.02 96.64,40.39 96.53,40.39 96.42,40.28 96.42,40.17 96.79,39.79 96.79,39.68 96.68,39.57 96.57,39.57 96.19,39.95 96.08,39.95 95.97,39.84 95.97,39.72 96.28,39.41 96.28,39.17 92.97,35.85 v1(92.97,27.1)
  BOTTOM w0.079: v2(110.86,58.68) 110.86,58.68 111.58,59.4 111.58,62.28 U400.AF53
  BOTTOM w0.109: v1(92.97,27.1) JDIM2900.207
M_1_DQ_2<0>: length 57.3
  IN3 w0.089: v2(116.78,65.37) 117.3,64.86 117.3,64.11 117.73,63.68 117.73,60.2 116.84,59.31 116.84,53.31 118.95,51.2 118.95,47.04 106.99,35.09 106.99,34.96 107.03,34.92 107.03,34.8 106.91,34.67 106.78,34.67 106.74,34.71 106.62,34.71 106.49,34.59 106.49,34.46 106.53,34.42 106.53,34.3 106.4,34.17 106.28,34.17 106.24,34.21 106.11,34.21 105.99,34.08 105.99,33.96 106.03,33.92 106.03,33.79 105.9,33.67 105.78,33.67 105.74,33.71 105.61,33.71 105.48,33.58 105.48,33.45 105.52,33.41 105.52,33.29 105.4,33.16 105.27,33.16 105.23,33.2 105.11,33.2 104.98,33.08 104.98,32.95 105.02,32.91 105.02,32.79 104.9,32.66 104.77,32.66 104.73,32.7 104.61,32.7 104.48,32.57 104.48,32.45 104.52,32.41 104.52,32.28 104.39,32.16 104.27,32.16 104.23,32.2 104.1,32.2 103.98,32.07 103.98,31.95 104.02,31.91 104.02,31.78 103.89,31.65 103.76,31.65 103.72,31.69 103.6,31.69 103.47,31.57 103.47,31.44 103.51,31.4 103.51,31.28 103.39,31.15 103.26,31.15 103.22,31.19 103.1,31.19 102.97,31.07 102.97,30.94 103.01,30.9 103.01,30.77 102.88,30.65 102.76,30.65 102.72,30.69 102.59,30.69 102.39,30.48 102.39,25.24 103.1,24.53 103.1,21.76 103.36,21.5 v1(103.72,21.5)
  BOTTOM w0.109: v2(116.78,65.37) 117.07,65.66 U400.AV47 ; v1(103.72,21.5) JDIM2900.250
M_1_DQ_2<1>: length 57.2
  IN3 w0.089: v1(100.47,27.12) 100.47,31.02 101.33,31.89 101.33,32.14 101.49,32.3 101.72,32.3 101.82,32.2 101.94,32.2 102.07,32.32 102.07,32.45 101.94,32.58 101.94,32.7 102.06,32.83 102.19,32.83 102.32,32.7 102.45,32.7 102.57,32.82 102.57,32.95 102.44,33.08 102.44,33.21 102.57,33.33 102.69,33.33 102.82,33.2 102.95,33.2 103.07,33.33 103.07,33.45 102.89,33.64 102.89,33.76 103.01,33.89 103.14,33.89 103.33,33.7 103.45,33.7 103.58,33.83 103.58,33.96 103.39,34.14 103.39,34.27 103.52,34.39 103.64,34.39 103.83,34.21 103.95,34.21 104.08,34.33 104.08,34.46 103.89,34.64 103.89,34.77 104.02,34.9 104.15,34.9 104.33,34.71 104.46,34.71 104.58,34.84 104.58,34.96 104.4,35.15 104.4,35.27 104.52,35.4 104.65,35.4 104.83,35.21 104.96,35.21 105.09,35.34 105.09,35.46 104.9,35.65 104.9,35.78 105.03,35.9 105.15,35.9 105.34,35.72 105.46,35.72 105.59,35.84 105.59,35.97 105.4,36.15 105.4,36.28 105.53,36.4 105.65,36.4 105.84,36.22 105.97,36.22 106.09,36.34 106.09,36.47 105.91,36.66 105.91,36.78 106.03,36.91 106.16,36.91 106.34,36.72 106.47,36.72 106.59,36.85 106.59,36.97 106.41,37.16 106.41,37.28 106.53,37.41 106.66,37.41 106.85,37.22 106.97,37.22 107.1,37.35 107.1,37.48 106.91,37.66 106.91,37.79 107.04,37.91 107.16,37.91 107.35,37.73 107.47,37.73 107.6,37.85 107.6,37.98 107.41,38.16 107.41,38.29 107.54,38.42 107.67,38.42 107.85,38.23 107.98,38.23 108.1,38.36 108.1,38.48 107.92,38.67 107.92,38.79 108.04,38.92 108.17,38.92 108.35,38.73 108.48,38.73 118.06,48.32 118.06,50.97 115.85,53.19 115.85,65.35 v2(115.87,65.37)
  BOTTOM w0.109: v2(115.87,65.37) 116.15,65.66 U400.AR47 ; v1(100.47,27.12) JDIM2900.237
M_1_DQ_2<2>: length 58.4
  IN3 w0.089: v2(116.78,66.02) 116.78,65.9 118.07,64.62 118.07,60.1 117.14,59.18 117.14,53.36 119.25,51.25 119.25,46.93 107.77,35.45 107.77,35.12 107.56,34.91 107.56,34.78 107.62,34.72 107.62,34.6 107.49,34.47 107.37,34.47 107.31,34.53 107.18,34.53 107.05,34.41 107.05,34.28 107.11,34.22 107.11,34.1 106.99,33.97 106.86,33.97 106.8,34.03 106.68,34.03 106.55,33.9 106.55,33.78 106.61,33.72 106.61,33.59 106.48,33.47 106.36,33.47 106.3,33.53 106.17,33.53 106.05,33.4 106.05,33.27 106.11,33.22 106.11,33.09 105.98,32.96 105.86,32.96 105.8,33.02 105.67,33.02 105.55,32.9 105.55,32.77 105.6,32.71 105.6,32.59 105.48,32.46 105.35,32.46 105.29,32.52 105.17,32.52 105.04,32.39 105.04,32.27 105.1,32.21 105.1,32.08 104.98,31.96 104.85,31.96 104.79,32.02 104.67,32.02 104.54,31.89 104.54,31.77 104.6,31.71 104.6,31.58 104.47,31.46 104.35,31.46 104.29,31.51 104.16,31.51 104.04,31.39 104.04,31.26 104.1,31.2 104.1,31.08 103.97,30.95 103.84,30.95 103.79,31.01 103.66,31.01 102.69,30.04 102.69,25.37 103.4,24.66 103.4,23.08 v1(103.72,22.77)
  BOTTOM w0.109: U400.AV45 117.07,66.31 v2(116.78,66.02) ; JDIM2900.246 102.72,21.77 v1(103.72,22.77)
M_1_DQ_2<3>: length 57.8
  IN3 w0.089: v1(100.47,25.85) 100.06,26.25 100.06,31.74 104.91,36.59 105.16,36.59 108.31,39.74 108.62,39.74 108.78,39.58 108.91,39.58 109.04,39.7 109.04,39.83 108.86,40 108.86,40.13 108.98,40.24 109.12,40.24 109.29,40.08 109.41,40.08 109.54,40.2 109.54,40.33 109.33,40.53 109.33,40.66 109.45,40.78 109.59,40.78 109.79,40.58 109.92,40.58 110.04,40.71 110.04,40.83 109.82,41.05 109.82,41.18 109.94,41.29 110.09,41.29 110.29,41.08 110.42,41.08 110.54,41.21 110.54,41.34 110.31,41.57 110.31,41.7 110.42,41.81 110.57,41.81 110.8,41.59 110.92,41.59 111.05,41.71 111.05,41.84 110.84,42.05 110.84,42.19 110.95,42.31 111.08,42.31 111.3,42.09 111.42,42.09 111.55,42.22 111.55,42.34 111.32,42.57 111.32,42.69 111.44,42.81 111.58,42.81 111.8,42.59 111.93,42.59 112.05,42.72 112.05,42.84 111.83,43.07 111.83,43.19 111.93,43.29 112.11,43.29 112.3,43.1 112.43,43.1 117.14,47.81 117.14,51.48 115.59,53.03 115.59,64.97 115.47,65.1 115.47,65.48 115.87,65.88 v2(115.87,66.02)
  BOTTOM w0.109: JDIM2900.233 99.47,26.85 v1(100.47,25.85) ; U400.AR45 116.15,66.31 v2(115.87,66.02)
M_1_DQ_2<4>: length 60.3
  IN3 w0.089: v1(103.47,27.12) 103.47,28.97 103.67,29.18 103.8,29.18 104.11,28.86 104.24,28.86 104.36,28.99 104.36,29.12 104.05,29.43 104.05,29.56 104.18,29.68 104.3,29.68 104.62,29.37 104.74,29.37 104.87,29.49 104.87,29.62 104.55,29.93 104.55,30.06 104.68,30.19 104.8,30.19 105.12,29.87 105.24,29.87 105.37,30 105.37,30.12 105.05,30.44 105.05,30.56 105.18,30.69 105.31,30.69 105.6,30.39 105.73,30.39 105.85,30.52 105.85,30.64 105.56,30.94 105.56,31.06 105.68,31.19 105.81,31.19 106.11,30.89 106.24,30.89 106.36,31.02 106.36,31.14 106.06,31.44 106.06,31.57 106.19,31.69 106.31,31.69 106.59,31.41 106.72,31.41 106.85,31.54 106.85,31.66 106.56,31.95 106.56,32.07 106.69,32.2 106.82,32.2 107.13,31.88 107.26,31.88 107.38,32.01 107.38,32.13 107.07,32.45 107.07,32.57 107.19,32.7 107.32,32.7 107.59,32.42 107.72,32.42 107.84,32.55 107.84,32.68 107.57,32.95 107.57,33.08 107.7,33.2 107.82,33.2 108.08,32.95 108.2,32.95 108.33,33.07 108.33,33.2 108.07,33.45 108.07,33.58 108.35,33.86 108.35,35.2 119.84,46.69 119.84,51.38 117.75,53.46 117.75,58.93 118.58,59.75 118.58,64.69 117.33,65.94 117.33,67.43 v2(116.78,67.97)
  BOTTOM w0.109: v1(103.47,27.12) JDIM2900.249 ; v2(116.78,67.97) 117.07,68.26 U400.AV41
M_1_DQ_2<5>: length 61.4
  IN3 w0.089: v2(115.87,67.32) 115.52,66.97 115.52,65.81 114.79,65.08 114.79,60.67 115.29,60.17 115.29,52.98 116.23,52.04 116.23,47.31 112.6,43.68 111.81,43.68 111.14,43.01 111.01,43.01 110.95,43.07 110.83,43.07 110.7,42.95 110.7,42.82 110.76,42.76 110.76,42.64 110.64,42.51 110.51,42.51 110.43,42.59 110.3,42.59 110.18,42.47 110.18,42.34 110.26,42.26 110.26,42.13 110.13,42.01 110.01,42.01 109.93,42.09 109.8,42.09 109.67,41.96 109.67,41.84 109.76,41.76 109.76,41.63 109.63,41.5 109.5,41.5 109.42,41.59 109.3,41.59 109.17,41.46 109.17,41.34 109.25,41.25 109.25,41.13 109.13,41 109,41 108.92,41.08 108.79,41.08 108.67,40.96 108.67,40.83 108.75,40.75 108.75,40.63 108.62,40.5 108.5,40.5 108.42,40.58 108.29,40.58 108.16,40.46 108.16,40.33 108.25,40.25 108.25,40.12 108.12,40 108,40 107.91,40.08 107.79,40.08 107.66,39.95 107.66,39.83 107.74,39.74 107.74,39.62 107.62,39.49 107.49,39.49 107.41,39.58 107.29,39.58 107.16,39.45 107.16,39.32 107.24,39.24 107.24,39.12 107.12,38.99 106.99,38.99 106.91,39.07 106.78,39.07 106.66,38.95 106.66,38.82 106.74,38.74 106.74,38.61 106.61,38.49 106.49,38.49 106.4,38.57 106.28,38.57 106.15,38.44 106.15,38.32 106.24,38.24 106.24,38.11 106.11,37.98 105.98,37.98 105.9,38.07 105.78,38.07 105.65,37.94 105.65,37.82 105.73,37.73 105.73,37.61 105.61,37.48 105.48,37.48 105.4,37.56 105.27,37.56 105.15,37.44 105.15,37.31 105.23,37.23 105.23,37.1 105.1,36.98 104.98,36.98 104.9,37.06 104.77,37.06 99.75,32.04 99.75,23.25 v1(100.22,22.78)
  BOTTOM w0.109: JDIM2900.232 99.22,21.78 v1(100.22,22.78) ; U400.AR42 116.15,67.61 v2(115.87,67.32)
M_1_DQ_2<6>: length 59.8
  IN3 w0.089: v2(116.78,67.32) 116.8,67.32 117.14,66.99 117.14,65.84 118.34,64.65 118.34,59.94 117.45,59.05 117.45,53.41 119.56,51.31 119.56,46.82 108.06,35.33 108.06,34.63 107.6,34.17 107.6,34.05 107.77,33.87 107.77,33.75 107.65,33.62 107.52,33.62 107.35,33.79 107.23,33.79 107.1,33.67 107.1,33.54 107.27,33.37 107.27,33.25 107.15,33.12 107.02,33.12 106.85,33.29 106.72,33.29 106.6,33.17 106.6,33.04 106.77,32.87 106.77,32.74 106.64,32.62 106.52,32.62 106.35,32.79 106.22,32.79 106.09,32.66 106.09,32.54 106.27,32.37 106.27,32.24 106.14,32.11 106.01,32.11 105.84,32.29 105.72,32.29 105.59,32.16 105.59,32.03 105.76,31.86 105.76,31.74 105.64,31.61 105.51,31.61 105.34,31.78 105.21,31.78 105.09,31.66 105.09,31.53 105.26,31.36 105.26,31.23 105.13,31.11 105.01,31.11 104.84,31.28 104.71,31.28 104.59,31.15 104.59,31.03 104.76,30.86 104.76,30.73 104.63,30.61 104.51,30.61 104.33,30.78 104.21,30.78 104.08,30.65 104.08,30.53 104.27,30.34 104.27,30.22 104.14,30.09 104.01,30.09 103.83,30.27 103.71,30.27 103.58,30.15 103.58,30.02 103.78,29.82 103.78,29.7 103.66,29.58 103.52,29.58 103.33,29.77 103.2,29.77 102.99,29.56 102.99,26.32 v1(103.47,25.85)
  BOTTOM w0.109: v2(116.78,67.32) 117.07,67.61 U400.AV42 ; v1(103.47,25.85) 102.47,26.85 JDIM2900.245
M_1_DQ_2<7>: length 58.8
  IN3 w0.089: v2(115.87,67.97) 115.33,67.43 115.33,65.91 114.51,65.09 114.51,60.54 115.05,60.01 115.05,52.84 115.92,51.97 115.92,47.42 112.6,44.1 111.14,44.1 99.08,32.04 99.08,30.41 98.99,30.33 98.8,30.33 98.72,30.24 98.72,30.06 98.81,29.97 98.99,29.97 99.08,29.88 99.08,29.7 98.99,29.61 98.82,29.61 98.73,29.53 98.73,29.35 98.82,29.26 98.99,29.26 99.08,29.17 99.08,22.65 v1(100.22,21.51)
  BOTTOM w0.109: v2(115.87,67.97) 116.15,68.26 U400.AR41 ; v1(100.22,21.51) JDIM2900.236
M_1_DQ_3<0>: length 62.8
  IN1 w0.079: v1(87.97,25.85) 87.58,26.24 87.58,39.04 87.73,39.19 87.87,39.19 88.31,38.74 88.43,38.74 88.54,38.85 88.54,38.97 88.05,39.46 88.05,39.57 88.16,39.68 88.27,39.68 88.76,39.19 88.87,39.19 88.98,39.3 88.98,39.41 88.49,39.9 88.49,40.01 88.6,40.12 88.72,40.12 89.2,39.63 89.32,39.63 89.43,39.75 89.43,39.86 88.94,40.35 88.94,40.46 89.05,40.57 89.16,40.57 89.65,40.08 89.76,40.08 89.87,40.19 89.87,40.3 89.46,40.72 89.46,40.98 99.1,50.62 99.1,51.45 104.95,57.3 104.95,59.23 105.53,59.81 105.53,61.16 107.06,62.69 108.12,62.69 108.7,63.27 111.76,63.27 111.96,63.47 112.39,63.47 114.04,65.12 v2(114.04,65.37)
  BOTTOM w0.109: U400.AL47 114.32,65.66 v2(114.04,65.37) ; JDIM2900.183 86.97,26.85 v1(87.97,25.85)
M_1_DQ_3<1>: length 63.4
  IN1 w0.079: v2(114.04,66.02) 114.04,65.9 114.45,65.49 114.45,65.22 114.2,64.97 114.2,64.15 113.14,63.09 112.04,63.09 111.94,62.99 108.84,62.99 106.32,60.47 106.32,59.05 105.58,58.31 105.58,57.51 99.39,51.33 99.39,50.52 92.61,43.73 92.61,43.54 93.06,43.09 93.06,42.98 92.95,42.87 92.84,42.87 92.38,43.32 92.27,43.32 92.16,43.21 92.16,43.1 92.61,42.64 92.61,42.53 92.5,42.42 92.39,42.42 91.93,42.88 91.82,42.88 91.71,42.76 91.71,42.65 92.17,42.2 92.17,42.09 92.06,41.97 91.94,41.97 91.49,42.43 91.38,42.43 91.27,42.32 91.27,42.21 91.72,41.75 91.72,41.64 91.61,41.53 91.5,41.53 91.02,42.01 90.91,42.01 90.79,41.9 90.79,41.79 91.28,41.31 91.28,41.2 91.16,41.08 91.05,41.08 90.57,41.57 90.46,41.57 90.35,41.45 90.35,41.34 90.83,40.86 90.83,40.75 90.72,40.64 90.61,40.64 90.13,41.12 90.02,41.12 89.9,41.01 89.9,40.9 90.32,40.48 90.32,40.24 87.97,37.88 v1(87.97,27.12)
  BOTTOM w0.109: v2(114.04,66.02) 114.32,66.31 U400.AL45 ; v1(87.97,27.12) JDIM2900.187
M_1_DQ_3<2>: length 62.4
  IN1 w0.079: v2(113.12,65.37) 112.44,65.37 111.72,64.66 110.61,64.66 110.27,64.32 108.32,64.32 107.85,63.85 106.92,63.85 104.9,61.82 104.9,60.3 104.11,59.51 104.11,57.73 97.69,51.31 86.08,39.7 86.08,29.05 86,28.96 85.57,28.96 85.49,28.89 85.49,28.73 85.57,28.65 86,28.65 86.08,28.57 86.08,28.41 86,28.33 85.57,28.33 85.49,28.26 85.49,28.1 85.57,28.02 86,28.02 86.08,27.94 86.08,27.78 86,27.7 85.57,27.7 85.45,27.58 85.45,23.02 85.16,22.73 85.16,21.95 v1(84.72,21.5)
  BOTTOM w0.109: v2(113.12,65.37) 113.41,65.66 U400.AJ47 ; v1(84.72,21.5) JDIM2900.174
M_1_DQ_3<3>: length 63.4
  IN1 w0.079: v2(113.12,66.02) 112.76,66.02 111.58,64.85 110.42,64.85 110.16,64.59 106.61,64.59 104.09,62.08 104.09,60.6 102.59,59.1 102.59,56.6 85.18,39.2 85.18,30.46 85.3,30.35 85.64,30.35 85.72,30.27 85.72,30.11 85.64,30.03 85.23,30.03 85.16,29.95 85.16,29.79 85.23,29.72 85.64,29.72 85.72,29.64 85.72,29.48 85.64,29.4 85.31,29.4 85.16,29.25 85.16,24.05 84.63,23.52 84.63,22.85 v1(84.72,22.77)
  BOTTOM w0.109: v1(84.72,22.77) 83.72,21.77 JDIM2900.170 ; U400.AJ45 113.41,66.31 v2(113.12,66.02)
M_1_DQ_3<4>: length 64.5
  IN1 w0.079: v1(87.72,22.76) 88.44,23.49 88.44,37.96 93.45,42.97 93.45,43.27 93.2,43.53 93.2,43.64 93.31,43.75 93.42,43.75 93.77,43.4 93.88,43.4 93.99,43.51 93.99,43.62 93.64,43.97 93.64,44.08 93.75,44.19 93.86,44.19 94.21,43.84 94.32,43.84 94.44,43.96 94.44,44.07 93.98,44.52 93.98,44.71 99.69,50.41 99.69,51.27 105.9,57.49 105.9,58.15 106.58,58.82 106.58,60.37 108.91,62.7 112.05,62.7 112.14,62.79 113.15,62.79 114.5,64.13 114.5,64.97 114.64,65.11 114.64,65.57 114.41,65.8 114.41,66.95 v2(114.04,67.32)
  BOTTOM w0.109: JDIM2900.182 86.72,21.76 v1(87.72,22.76) ; U400.AL42 114.32,67.61 v2(114.04,67.32)
M_1_DQ_3<5>: length 63.2
  IN1 w0.079: v1(87.72,21.49) 88.74,22.51 88.74,37.86 94.89,44.01 94.89,44.2 94.44,44.65 94.44,44.76 94.56,44.87 94.67,44.87 95.15,44.39 95.26,44.39 95.38,44.5 95.38,44.61 94.94,45.04 94.94,45.27 99.98,50.3 99.98,51.24 106.91,58.16 106.93,58.16 109.32,60.55 109.32,61.08 110.64,62.41 112.14,62.41 112.24,62.51 113.21,62.51 114.83,64.13 114.83,65.65 114.58,65.89 114.58,67.43 v2(114.04,67.97)
  BOTTOM w0.109: v1(87.72,21.49) JDIM2900.186 ; U400.AL41 114.32,68.26 v2(114.04,67.97)
M_1_DQ_3<6>: length 60.4
  IN1 w0.079: v2(113.12,67.32) 112.33,66.53 112.1,66.53 111.83,66.27 111.83,65.37 111.5,65.03 110.16,65.03 109.93,64.79 106.48,64.79 103.82,62.14 103.82,60.7 102.31,59.19 102.31,56.72 97.13,51.54 84.87,39.28 84.87,30.51 84.76,30.4 84.58,30.4 84.5,30.32 84.5,30.17 84.58,30.09 84.74,30.09 84.87,29.96 84.87,26.23 v1(84.47,25.83)
  BOTTOM w0.109: JDIM2900.169 83.47,26.83 v1(84.47,25.83) ; U400.AJ42 113.41,67.61 v2(113.12,67.32)
M_1_DQ_3<7>: length 62.3
  IN1 w0.079: v2(113.12,67.97) 112.65,67.5 112.65,67.12 112.25,66.72 112.02,66.72 111.65,66.36 111.03,66.36 109.68,65 106.38,65 103.58,62.2 103.58,60.77 102.03,59.22 102.03,56.84 84.47,39.28 84.47,30.92 83.69,30.15 83.69,29.79 83.77,29.71 84.39,29.71 84.47,29.63 84.47,29.47 84.39,29.39 83.74,29.39 83.67,29.32 83.67,29.16 83.74,29.08 84.39,29.08 84.47,29 84.47,28.84 84.39,28.76 83.74,28.76 83.67,28.69 83.67,28.53 83.74,28.45 84.39,28.45 84.47,28.37 84.47,28.21 84.39,28.13 83.74,28.13 83.67,28.06 83.67,27.9 83.74,27.82 84.39,27.82 84.47,27.74 v1(84.47,27.1)
  BOTTOM w0.109: v1(84.47,27.1) JDIM2900.173 ; U400.AJ41 113.41,68.26 v2(113.12,67.97)
M_1_DQ_4<0>: length 79.2
  IN1 w0.079: v1(54.97,27.12) 54.97,27.23 59.47,31.74 69.05,31.74 80.31,43 80.6,43 81.1,42.5 81.21,42.5 81.32,42.61 81.32,42.72 80.78,43.26 80.78,43.37 80.9,43.48 81.01,43.48 81.52,42.97 81.63,42.97 81.74,43.08 81.74,43.19 81.23,43.71 81.23,43.82 81.34,43.93 81.45,43.93 82.02,43.37 82.13,43.37 82.24,43.48 82.24,43.59 81.7,44.13 81.7,44.24 81.81,44.35 81.92,44.35 82.46,43.81 82.57,43.81 82.68,43.92 82.68,44.03 82.1,44.62 82.1,44.73 82.21,44.85 82.32,44.85 82.91,44.26 83.02,44.26 83.13,44.37 83.13,44.48 82.57,45.04 82.57,45.15 82.68,45.27 82.79,45.27 83.35,44.7 83.46,44.7 83.57,44.81 83.57,44.93 83.44,45.06 82.96,45.54 82.96,45.65 83.07,45.76 83.18,45.76 83.76,45.18 83.95,45.18 97.84,59.08 97.84,64.11 98.38,64.64 99.27,64.64 99.65,64.25 v2(99.68,64.25)
  BOTTOM w0.079: U400.E47 102.47,65.71 102.18,65.42 101.2,65.42 101.03,65.24 101.03,64.87 100.91,64.75 100.15,64.75 99.68,64.28 v2(99.68,64.25)
  BOTTOM w0.109: v1(54.97,27.12) JDIM2900.63
M_1_DQ_4<1>: length 78.8
  IN1 w0.079: v1(54.97,25.85) 55.42,26.3 55.42,27.26 59.62,31.46 69.17,31.46 78.04,40.33 78.28,40.33 78.74,39.87 78.86,39.87 78.97,39.98 78.97,40.09 78.49,40.57 78.49,40.68 78.6,40.79 78.71,40.79 79.27,40.24 79.38,40.24 79.49,40.35 79.49,40.46 78.91,41.04 78.91,41.15 79.02,41.26 79.13,41.26 79.71,40.68 79.82,40.68 79.93,40.79 79.93,40.9 79.33,41.51 79.33,41.62 79.44,41.73 79.55,41.73 80.16,41.13 80.29,41.13 80.4,41.24 80.4,41.35 79.84,41.91 79.84,42.02 79.95,42.13 80.07,42.13 80.63,41.57 80.74,41.57 80.85,41.68 80.85,41.8 80.24,42.41 80.24,42.52 80.35,42.63 80.46,42.63 81,42.09 81.25,42.09 98.14,58.97 98.14,63.27 v2(99.12,64.25)
  BOTTOM w0.079: U400.D46 102.02,65.89 101.7,65.57 101.13,65.57 100.92,65.36 100.65,65.36 100.23,64.94 99.8,64.94 v2(99.12,64.25)
  BOTTOM w0.109: JDIM2900.59 53.97,26.85 v1(54.97,25.85)
M_1_DQ_4<2>: length 78.2
  IN1 w0.079: v1(54.72,21.52) 54.02,22.22 54.02,27.12 59.21,32.3 68.79,32.3 84.08,47.6 84.3,47.6 84.87,47.03 84.98,47.03 85.09,47.14 85.09,47.26 84.47,47.88 84.47,47.99 84.58,48.1 84.69,48.1 85.31,47.48 85.43,47.48 85.54,47.59 85.54,47.7 85.27,47.97 85.27,48.08 85.38,48.19 85.49,48.19 85.76,47.92 85.89,47.92 97.25,59.29 97.25,65.79 v2(97.31,65.84)
  BOTTOM w0.079: 100.15,65.16 100.24,65.16 100.61,65.54 100.87,65.54 101.16,65.82 U400.B46
  BOTTOM w0.109: v1(54.72,21.52) JDIM2900.62 ; 100.15,65.16 97.99,65.16 v2(97.31,65.84)
M_1_DQ_4<3>: length 77.9
  IN1 w0.079: v2(97.86,65.84) 97.55,65.53 97.55,59.19 84.95,46.58 84.72,46.58 84.21,47.09 84.1,47.09 83.99,46.98 83.99,46.87 84.55,46.31 84.55,46.2 84.44,46.08 84.33,46.08 83.77,46.64 83.66,46.64 83.55,46.53 83.55,46.42 84.1,45.86 84.1,45.75 83.99,45.64 83.88,45.64 83.35,46.17 83.09,46.17 68.93,32.02 59.32,32.02 54.31,27.01 54.31,23.2 v1(54.72,22.79)
  BOTTOM w0.079: 100.07,65.36 100.21,65.36 100.65,65.8 U400.A46
  BOTTOM w0.109: 100.07,65.36 98.26,65.36 97.86,65.76 v2(97.86,65.84) ; v1(54.72,22.79) 53.72,21.79 JDIM2900.58
M_1_DQ_4<4>: length 80.2
  IN1 w0.079: v2(98.59,67.11) 98.21,67.49 96.24,67.49 92.99,64.23 92.29,64.23 89,60.95 89,54.89 88.8,54.69 88.8,54.58 89.05,54.33 89.05,54.22 88.93,54.11 88.82,54.11 88.58,54.35 88.47,54.35 88.36,54.24 88.36,54.13 88.93,53.56 88.93,53.45 88.82,53.34 88.71,53.34 88.13,53.91 88.02,53.91 87.91,53.8 87.91,53.69 88.15,53.44 88.15,53.33 88.04,53.22 87.93,53.22 87.69,53.46 87.58,53.46 68.09,33.98 57.78,33.98 51.03,27.23 51.03,26.27 v1(51.46,25.84)
  BOTTOM w0.079: U400.E44 102.44,67.07 102.26,66.89 101.24,66.89 101.14,66.8 100.63,66.8 100.57,66.73 98.96,66.73 v2(98.59,67.11)
  BOTTOM w0.109: v1(51.46,25.84) 50.46,26.84 JDIM2900.45
M_1_DQ_4<5>: length 79.9
  IN1 w0.079: v1(51.46,27.11) 58.05,33.7 68.21,33.7 86.05,51.53 86.28,51.53 86.84,50.98 86.95,50.98 87.06,51.09 87.06,51.2 86.49,51.77 86.49,51.88 86.61,51.99 86.72,51.99 87.28,51.43 87.39,51.43 87.5,51.54 87.5,51.65 86.89,52.26 86.89,52.38 87.01,52.5 87.1,52.5 87.73,51.87 87.84,51.87 87.95,51.98 87.95,52.09 87.33,52.71 87.33,52.82 87.45,52.93 87.56,52.93 88.17,52.32 88.29,52.32 88.41,52.44 88.41,52.56 88.15,52.81 88.15,52.92 88.27,53.04 88.38,53.04 88.61,52.8 88.77,52.8 89.34,53.38 89.34,60.89 92.4,63.94 93.11,63.94 96.25,67.08 v2(97.46,67.08)
  BOTTOM w0.079: v2(97.46,67.08) 97.92,67.55 100.94,67.55 101.1,67.38 101.53,67.38 101.57,67.34 101.69,67.34 101.81,67.22 U400.D43
  BOTTOM w0.109: v1(51.46,27.11) JDIM2900.49

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EN_5V: length 2.1
  BOTTOM w0.109: R3305.2 167.08,9.4 v1(167.41,9.07) 167.79,9.45 PR8619.1
EN_5V_3V: length 252.3
  TOP w0.109: v1(119.07,13) 118.64,13.43 118.64,13.94 118.92,14.22 119.17,14.22 121.75,16.8 122.4,16.8 122.7,17.11 122.7,17.7 122.47,17.93 v1(121.31,17.93) ; R7506.1 22.55,45.17 22.38,45.34 R3301.2 22.07,45.67 v1(21.89,45.85) ; v2(165.99,10.16) 165.5,10.64 165.5,11 165.16,11.34 163.84,11.34 163.33,11.85 162.39,11.85 162.17,12.07 162.17,12.5 162.23,12.66 163.7,14.12 v2(163.7,14.78)
  IN1 w0.079: v1(21.89,45.85) 23.49,47.46 25.77,47.46 26.19,47.04 26.19,46.55 26.95,45.79 27.81,45.79 29.33,47.31 31,47.31 31.41,47.72 v1(35.5,47.72) ; v2(163.7,14.78) 162.7,13.78 157.47,13.78 157.26,13.57 157.26,13.06 156.82,12.62 153.28,12.62 152.65,13.26 145.98,13.26 145.26,13.98 144.36,13.98 143.48,13.1 139.75,13.1 139.52,13.33 139.44,13.33 v1(139.17,13.6)
  IN2 w0.089: v1(121.31,17.93) 120.86,17.93 117.93,15.01 115.67,15.01 114.63,16.05 114.63,16.28 114.02,16.89 111.66,16.89 111.05,17.5 104.43,17.5 103.99,17.06 102.43,17.06 101.97,17.53 101.97,18.6 100.99,19.57 94.23,19.57 92.94,18.29 92.94,17.19 92.08,16.32 89.81,16.32 88.18,17.96 83.82,17.96 83.33,17.47 72.38,17.47 69.9,14.98 65.08,14.98 63.45,13.36 60.89,13.36 58.89,15.36 48.71,15.36 45.94,18.13 37.31,18.13 35.63,19.81 33.86,19.81 32.18,21.49 32.18,28.83 34.26,30.91 36.49,30.91 37.24,31.66 37.24,35.2 v1(36.29,36.15)
  IN3 w0.089: v1(119.07,13) 119.94,13 120.11,12.83 126.38,12.83 126.65,13.1 127.73,13.1 128.15,12.69 132.2,12.69 132.83,13.31 133.61,13.31 134.24,13.94 135.76,13.94 135.97,13.74 138.05,13.74 138.19,13.6 v1(139.17,13.6) ; v1(36.29,36.15) 36.46,36.32 36.46,46.75 v1(35.5,47.72) 35.5,48.71 33.24,50.96 30.74,50.96 29.39,52.32 29.39,56.51 28.8,57.1 28.8,58.06 29.26,58.52 29.26,58.82 28.34,59.74 28.34,67.2 28.95,67.82 28.95,68.63 28.4,69.19 28.4,70.56 v1(27.68,71.27)
  BOTTOM w0.109: R5406.2 31.01,74.78 29.46,74.78 28.77,74.08 U5401.3 28.77,72.35 v1(27.68,71.27) ; R3308.1 119.78,12.68 119.63,12.82 119.25,12.82 v1(119.07,13) ; v2(165.99,10.16) R3305.1 ; R3306.1 139.44,13.33 v1(139.17,13.6)
EN_VRPVDDQ: length 161.3
  TOP w0.109: D3300.2 19.3,45.19 18.77,45.71 R3304.1 18.29,45.71 v1(17.6,46.4)
  IN3 w0.089: v1(109.65,6.83) 109.37,6.55 104.22,6.55 102.02,7.46 101.44,8.04 98.9,8.04 97.97,8.97 75.36,8.97 75.03,8.63 73.81,8.63 73.18,8 66.55,8 65.91,7.36 65.91,5.15 65.02,4.26 63.45,4.26 62.91,3.73 60.36,3.73 59.67,4.42 58.92,4.42 58.82,4.32 56.32,4.32 54.43,6.21 52.4,6.21 51.79,6.83 51.2,7.08 50.76,7.08 50.21,6.53 48.34,6.53 46.8,4.98 42.56,4.98 41.94,5.6 35.73,5.6 35.1,4.97 31.81,4.97 31.68,4.84 25.32,4.84 23.93,6.23 23.93,6.7 23.51,7.12 22.52,7.12 22.27,6.86 16.83,6.86 16.41,7.29 10.37,7.29 8.16,9.49 8.16,18.65 10.05,20.54 10.05,34.61 11.11,35.67 11.11,39.24 10.57,39.78 10.57,40.98 11.51,41.92 13.93,41.92 14.21,42.2 14.21,43.78 16.84,46.4 v1(17.6,46.4)
  BOTTOM w0.109: PR8701.1 107.77,9.98 109.6,8.15 109.6,6.88 v1(109.65,6.83)
EN_VRPVTT: length 1.6
  TOP w0.109: R3307.2 108.51,10.92 v1(108.48,10.89) 108.21,10.89 PR8703.1
EQ: length 3
  TOP w0.109: R3507.1 R3508.1 199.92,52 200.01,52.08 200.01,52.7 200.01,52.7 200.01,53.21 199.66,53.56 U3501.13
ESPI_0: length 107.7
  TOP w0.076: 196.78,14.13 196.78,14.36 U4700.H1
  TOP w0.109: v2(207.06,15.42) 207.21,15.27 208.37,15.27 208.48,15.16 208.48,13.11 207.03,11.66 207.03,11.32 206.05,10.33 203.42,10.33 203.11,10.64 202.03,10.64 201.48,10.08 200.38,10.08 199.21,11.25 199.21,11.38 198.87,11.72 198.87,12.02 198.63,12.27 196.97,12.27 196.75,12.49 196.75,12.87 196.78,12.93 196.78,14.13
  IN3 w0.089: v1(159.9,55.57) 160.51,55.57 161.06,55.01 162.36,55.01 163.35,54.02 163.62,54.02 165.76,51.88 168.78,51.88 170.75,49.91 171.25,49.91 172.42,48.73 173.1,48.73 173.56,48.27 173.92,48.27 176.22,45.98 176.47,45.98 176.83,45.98 178.94,43.87 179.8,43.87 181.14,42.53 181.14,39.61 185.19,35.56 185.19,35.34 187.42,33.11 187.42,31.22 189.91,28.73 190.14,28.73 191.01,27.86 191.01,27.48 192.21,26.28 195.84,26.28 196.03,26.08 196.39,26.08 196.96,25.51 198.24,25.51 200.06,23.7 201.22,23.7 204.98,19.94 204.98,19.45 205.01,19.42 205.01,17.9 206.88,16.03 206.88,15.6 v2(207.06,15.42)
  BOTTOM w0.109: R1112.2 148.12,61.78 148.19,61.78 148.35,61.62 148.35,61.36 148.68,61.04 148.68,60.73 149.03,60.38 149.03,59.74 149.4,59.37 149.4,56.51 150.33,55.58 154.26,55.58 154.58,55.26 156.69,55.26 157.28,54.67 158.38,54.67 159.28,55.57 v1(159.9,55.57) ; v2(207.06,15.42) 207.45,15.42 207.69,15.67 R7716.2
ESPI_0_R: length 6.9
  BOTTOM w0.109: U400.DP52 142.58,63.1 142.91,62.77 142.91,62.51 143.68,61.74 146.18,61.74 146.97,60.95 147.53,60.95 148,61.41 R1112.1
ESPI_1: length 105.7
  TOP w0.076: 197.21,14.13 197.21,14.42 197.06,14.56 U4700.J1
  TOP w0.109: v2(206.35,13.99) 206.8,13.99 207.29,13.5 207.29,12.58 206.62,11.9 206.62,11.31 205.93,10.62 203.55,10.62 203.22,10.95 201.93,10.95 201.36,10.37 200.49,10.37 199.46,11.4 199.46,11.54 199.08,11.92 199.08,12.11 198.7,12.49 197.97,12.49 197.81,12.66 v1(197.81,12.68) 197.21,13.28 197.21,14.13
  IN3 w0.089: v2(206.35,13.99) 206.64,14.29 206.64,15.93 204.77,17.8 204.77,19.3 204.72,19.35 204.72,19.85 201.12,23.45 199.96,23.45 198.14,25.27 195.27,25.27 194.71,25.84 192.29,25.84 190.73,27.4 190.73,27.78 190.03,28.49 189.8,28.49 187.18,31.11 187.18,33.01 184.95,35.24 184.95,35.46 180.9,39.51 180.9,42.34 179.61,43.63 178.65,43.63 177.53,44.74 177.44,44.83 176.74,44.83 176.14,45.43 176.14,45.72 173.82,48.03 173.46,48.03 173,48.49 172.37,48.49 171.97,48.09 171.77,48.09 170.64,49.22 170.43,49.22 168.88,50.77 165.91,50.77 163.33,53.34 163.07,53.34 162.08,54.33 158.93,54.33 158.4,54.86 157,54.86 156.68,55.18 149.55,55.18 148.26,56.47 v1(148.26,57.81)
  BOTTOM w0.109: v2(206.35,13.99) 206.68,14.32 207.79,14.32 R7715.2 ; R1111.2 148.39,60.61 148.74,60.27 148.74,59.62 149.11,59.25 149.11,58.66 v1(148.26,57.81)
ESPI_1_R: length 8.4
  BOTTOM w0.109: U400.DP50 142.54,63.75 142.28,63.48 142.28,63.15 142.33,63.09 142.33,62.82 142.28,62.77 142.28,62.06 142.71,61.62 143.49,61.62 143.57,61.55 145.93,61.55 146.79,60.69 147.83,60.69 R1111.1
ESPI_2: length 106.2
  TOP w0.076: 198.23,14.13 198.21,14.13 197.71,14.63 U4700.K1
  TOP w0.109: v2(206.07,13.2) 206.07,13.33 206.31,13.57 206.81,13.57 207,13.38 207,12.84 206.31,12.14 206.31,11.4 205.81,10.91 203.67,10.91 203.35,11.22 201.9,11.22 201.47,10.79 v1(200.94,10.79) 200.38,10.79 199.7,11.47 199.7,11.61 199.38,11.93 199.38,13.11 198.98,13.51 198.85,13.51 198.23,14.13
  IN3 w0.089: v2(206.07,13.2) 206.07,13.31 205.74,13.64 205.33,13.64 205.26,13.57 204.73,13.57 204.05,14.25 204.05,18.76 203.93,18.87 203.93,19.61 202.24,21.3 201.46,21.3 200.69,22.07 199.65,22.07 197.95,23.77 197.72,23.77 197.08,24.41 192.7,24.41 189.86,27.24 189.44,27.24 188.64,28.04 188.64,28.49 186.45,30.68 186.45,32.71 184.22,34.94 184.22,35.16 180.13,39.25 180.13,41.12 177.23,44.02 177.14,44.11 176.44,44.11 175.18,45.37 174.09,45.37 173.71,45.75 173.71,46.62 173.09,47.24 171.6,47.24 170.34,48.5 170.13,48.5 168.58,50.04 165.59,50.04 163.31,52.32 162.64,52.32 161.92,53.05 158.84,53.05 157.97,53.92 157.76,54.13 156.67,54.13 156.18,53.64 149.7,53.64 147.85,55.5 147.85,55.86 146.68,57.02 146.68,58.22 v1(145.21,59.69)
  BOTTOM w0.109: v1(145.21,59.69) 145.29,59.61 R1110.2 ; R7714.2 208,14.03 207.05,14.03 206.59,13.57 206.41,13.57 206.07,13.23 v2(206.07,13.2)
ESPI_2_R: length 9.4
  BOTTOM w0.109: R1110.1 145.74,59.87 145.53,60.08 144.87,60.08 144.47,60.48 141.27,60.48 140.63,61.12 140.63,62.81 140.45,63 140.45,63.58 140.14,63.89 U400.DH50
ESPI_3: length 101.5
  TOP w0.076: U4700.L1 198.95,14.13
  TOP w0.109: 198.95,14.13 199.06,14.02 199.72,14.02 200,13.74 200,13.59 200.45,13.13 200.45,12.55 v1(200.94,12.06) 201.25,11.75 202.86,11.75 203.4,12.29 203.4,12.66 203.61,12.86 205.42,12.86 205.49,12.84 205.65,12.68 206.25,12.68 206.6,13.03 206.6,13.19 v2(206.61,13.2)
  IN3 w0.089: v1(144.58,59.69) 144.96,60.07 146.7,60.07 147.82,58.96 147.82,56.57 149.45,54.94 156.58,54.94 156.9,54.61 157.96,54.61 159.04,53.53 162.12,53.53 162.84,52.8 163.51,52.8 165.79,50.52 168.78,50.52 170.33,48.98 170.54,48.98 171.67,47.85 172.07,47.85 172.47,48.25 172.79,48.25 173.28,47.76 173.75,47.76 175.9,45.62 175.9,45.33 176.64,44.59 177.34,44.59 177.43,44.5 180.64,41.29 180.64,39.42 184.71,35.36 184.71,35.14 186.93,32.91 186.93,30.99 189.68,28.24 189.93,28.24 190.49,27.68 190.49,27.3 192.76,25.03 198.04,25.03 199.93,23.14 201.09,23.14 204.44,19.79 204.44,19.17 204.53,19.09 204.53,17.7 206.4,15.83 206.4,14.6 205.94,14.15 205.94,13.87 v2(206.61,13.2)
  BOTTOM w0.109: R1109.2 144.75,59.52 v1(144.58,59.69) ; R7713.2 206.89,13.2 v2(206.61,13.2)
ESPI_3_R: length 6.5
  BOTTOM w0.109: R1109.1 144.05,59.36 144.05,59.58 143.39,60.25 141.18,60.25 140.36,61.06 140.36,62.5 U400.DJ53
ESPI_ALERT#: length 4.2
  TOP w0.076: 199.57,15.24 199.14,15.67 198.81,15.67 198.46,16.02 U4700.L3
  TOP w0.109: 199.57,15.24 199.8,15.01 200.71,15.01 201.29,14.42 TP4700.1
ESPI_CLK: length 97.3
  TOP w0.076: U4700.M1 199.18,14.55 199.57,14.55
  TOP w0.109: 199.57,14.55 200,14.55 200.47,14.08 200.47,13.73 200.77,13.42 201.94,13.42 R4747.1 202.23,13.71 202.23,13.79 202.93,14.5 v2(203.15,14.5)
  IN3 w0.089: v2(206.02,15.67) 206.02,15.87 205.64,16.25 205.44,16.25 205.24,16.05 205.11,16.05 204.99,16.18 204.99,16.23 205.26,16.5 205.26,16.63 205.14,16.75 205.01,16.75 204.73,16.48 204.61,16.48 204.48,16.6 204.48,16.73 204.76,17.01 204.76,17.13 204.29,17.6 204.29,18.97 204.19,19.07 204.19,19.7 200.99,22.9 199.83,22.9 198.71,24.02 197.81,24.02 197.18,24.65 192.8,24.65 189.96,27.48 189.54,27.48 188.91,28.11 188.91,28.56 186.69,30.78 186.69,32.81 184.46,35.04 184.46,35.26 180.39,39.34 180.39,41.21 177.33,44.26 177.24,44.35 176.54,44.35 175.28,45.61 174.19,45.61 173.95,45.85 173.95,46.72 173.19,47.48 171.7,47.48 170.44,48.74 170.23,48.74 168.68,50.28 165.69,50.28 163.41,52.56 162.74,52.56 162.02,53.29 158.94,53.29 157.86,54.37 156.8,54.37 156.48,54.69 148.99,54.69 148.09,55.6 148.09,55.96 147.31,56.74 v1(147.31,57.86)
  BOTTOM w0.109: R7717.2 207.19,16.63 206.83,16.28 206.63,16.28 v2(206.02,15.67) 206.02,15.39 205.59,14.96 v1(203.88,14.96) 203.6,14.96 v2(203.15,14.5) ; v1(147.31,57.86) 147.6,57.86 148.56,58.83 148.56,59.18 148.31,59.43 C1101.2 148.39,59.64 R1108.2
ESPI_CLK_R: length 7.7
  BOTTOM w0.109: U400.DN53 142.06,62.9 142.06,61.94 142.64,61.36 145.72,61.36 146.99,60.09 R1108.1
ESPI_CS#: length 102.9
  TOP w0.076: 199.57,14.32 199.19,14.32 199.08,14.43 198.87,14.43 198.69,14.61 198.69,14.84 198.36,15.16 U4700.L2
  TOP w0.109: 199.57,14.32 199.9,14.32 200.23,13.99 200.23,13.66 200.71,13.18 200.71,12.62 200.84,12.49 201.09,12.49 201.62,11.96 202.77,11.96 203.19,12.38 203.19,12.83 203.52,13.16 205.45,13.16 v2(205.52,13.23)
  IN3 w0.089: v1(145.08,58.48) 145.84,58.48 146.44,57.87 146.44,56.92 147.61,55.76 147.61,55.4 149.6,53.4 156.28,53.4 156.77,53.89 157.66,53.89 158.74,52.81 161.82,52.81 162.64,51.99 163.25,51.99 164.81,50.43 165.44,49.8 168.48,49.8 170.03,48.26 170.24,48.26 171.5,46.99 172.99,46.99 173.16,46.83 173.16,45.96 174.05,45.07 175.14,45.07 176.34,43.87 177.04,43.87 177.13,43.78 179.88,41.03 179.88,39.16 183.98,35.06 183.98,34.84 186.21,32.61 186.21,30.58 188.36,28.43 188.36,27.97 189.34,27 189.76,27 192.6,24.17 196.97,24.17 197.6,23.53 197.85,23.53 199.56,21.82 200.6,21.82 201.36,21.06 201.61,21.06 202.2,20.47 202.2,19.78 202.76,19.23 202.76,19 203.15,18.62 203.63,18.62 203.81,18.44 203.81,14.15 204.72,13.23 v2(205.52,13.23)
  BOTTOM w0.109: v1(145.08,58.48) 145.32,58.24 v1(145.67,58.24) 146.1,58.24 R1122.1 146.33,58.47 R1115.2 ; R7712.2 208,12.85 207.35,12.2 206.33,12.2 205.52,13.01 v2(205.52,13.23)
ESPI_CS#_L_R: length 2
  BOTTOM w0.109: R7712.1 209.34,13.03 209.93,13.03 210.24,12.72 CON7702.6
ESPI_CS#_R: length 9.1
  BOTTOM w0.109: U400.DK52 140.84,63.09 140.84,61.26 141.4,60.69 142.12,60.69 142.4,60.97 145.34,60.97 146.78,59.53 R1115.1
ESPI_EC_IO0_R_R: length 2.7
  BOTTOM w0.109: R7716.1 209.03,15.38 209.79,15.38 210.21,14.97 210.21,14.86 210.34,14.72 CON7702.10
ESPI_EC_IO1_R_R: length 2.2
  BOTTOM w0.109: CON7702.9 210.33,14.22 210.02,14.54 209.11,14.54 R7715.1
ESPI_EC_IO2_R_R: length 2.4
  BOTTOM w0.109: CON7702.8 210.38,13.72 210.18,13.92 210.18,13.97 209.93,14.22 209.4,14.22 209.07,13.9 R7714.1
ESPI_EC_IO3_R_R: length 4.8
  BOTTOM w0.109: CON7702.7 210.15,13.22 210.05,13.32 207.79,13.32 R7713.1 207.09,12.62 v1(206.5,12.62)
ESPI_RESET#: length 102.6
  TOP w0.076: 199.57,14.94 199.44,15.07 198.82,15.07 198.72,15.17 198.72,15.55 198.59,15.68 198.06,15.68 U4700.K3
  TOP w0.109: 199.57,14.94 199.73,14.78 200.35,14.78 v1(200.58,14.55) 200.69,14.45 200.69,13.82 200.87,13.64 201.32,13.64 201.67,13.99 202.12,13.99 203.17,15.05 v2(203.17,15.9) ; v1(140.74,58.17) 140.42,58.17 140.16,58.44 R1117.2 R1123.2
  IN3 w0.089: v2(203.17,15.9) 203.27,15.9 203.35,15.97 203.35,16.76 202.88,17.23 202.88,18.25 201.83,19.3 201.83,19.84 201.46,20.2 201.31,20.2 201.11,20.4 201.04,20.57 201.04,21 200.49,21.55 199.45,21.55 197.81,23.19 197.56,23.19 196.86,23.9 192.49,23.9 189.65,26.73 189.23,26.73 188.08,27.88 188.08,28.33 185.94,30.47 185.94,32.5 183.71,34.73 183.71,34.95 179.6,39.06 179.6,40.93 176.93,43.6 176.03,43.6 174.86,44.77 173.6,44.77 172.43,45.95 172.17,45.95 170.13,47.99 169.89,47.99 168.35,49.53 165.33,49.53 163.14,51.72 162.53,51.72 161.71,52.54 158.63,52.54 157.55,53.62 156.88,53.62 156.39,53.13 148.17,53.13 147.11,54.2 147.11,55.88 146.17,56.81 146.17,57.55 145.77,57.96 144.93,57.96 144.62,58.27 144.62,58.84 143.87,59.59 142.61,59.59 141.58,58.56 141.13,58.56 v1(140.74,58.17)
  BOTTOM w0.109: v2(203.17,15.9) 203.48,15.59 204.34,15.59 204.67,15.26 205.46,15.26 205.65,15.45 205.65,16.09 R7718.2
ESPI_RESET#_R: length 5.4
  TOP w0.109: R1117.1 v1(140.16,59.84) 140.16,60.9 v2(141.24,61.99)
  BOTTOM w0.109: v2(141.24,61.99) 141.11,62.12 141.11,63.58 141.42,63.89 U400.DL50
EXT_SMI#: length 133.6
  TOP w0.109: v1(146.09,88.94) 145.8,88.94 141.17,84.3 140.79,83.92 140.79,82.98 140.66,82.85 139.79,82.85 v2(139.36,82.42)
  TOP w0.14: U4700.J4 v2(197.39,16.34)
  IN1 w0.079: v2(197.39,16.34) 197.39,16.49 199.03,18.13 199.03,18.9 199.97,19.84 199.97,20.55 197.37,23.15 195.89,23.15 192.59,26.45 191.57,26.45 190.61,27.4 190.61,28.45 190.15,28.92 189.01,28.92 186.68,31.25 186.68,33.07 184.65,35.1 184.65,37.3 182.66,39.29 182.66,42.11 181.86,42.91 181.16,42.91 176.86,47.21 176.54,47.21 175.58,48.17 174.8,48.17 174.37,47.74 174,47.74 173.49,47.23 171.38,47.23 170.55,46.39 169.96,46.39 167.87,44.3 164.64,44.3 164.46,44.12 163.89,44.12 v1(162.99,45.02)
  IN2 w0.089: v2(139.36,82.42) 140.46,82.42 140.8,82.76 142.28,82.76 142.6,82.45 143.13,82.45 143.47,82.78 148.72,82.78 150.24,81.27 152.25,81.27 152.58,80.94 154.96,80.94 156.67,79.24 156.67,78.31 157.02,77.96 157.02,75.89 157.1,75.81 157.1,74.77 157.96,73.91 157.96,73.03 157.26,72.34 157.26,71.71 155.4,69.85 155.4,69.32 154.13,68.06 154.13,67.08 156.45,64.77 156.45,64.35 157.17,63.62 157.17,63.04 156.97,62.84 156.97,62.48 157.45,62 157.45,60.85 158.22,60.08 158.22,59.57 157.39,58.75 157.39,57.7 157.81,57.28 157.81,55.08 157.9,54.99 157.9,54.06 159.35,52.62 159.66,52.62 159.97,52.3 159.97,51.98 159.69,51.7 159.69,49.17 159.77,49.09 159.77,48.69 160.73,47.73 160.88,47.73 162.16,46.46 162.16,45.55 162.7,45.02 v1(162.99,45.02)
  BOTTOM w0.109: v1(146.09,88.94) 146.09,89.16 146.57,89.65 R628.1 ; U400.DF8 v2(139.36,82.42)
FAN1_PWM: length 203.8
  TOP w0.076: U4700.G8 195.55,19.27 195.23,18.94 v2(194.79,18.94)
  IN1 w0.079: v1(156.7,45.95) 156.84,45.8 158.97,45.8 160.4,47.23 160.4,47.34 162.4,49.33 164.02,49.33 165.04,50.35 165.87,50.35 166.3,50.79 168.06,50.79 168.4,51.13 168.99,51.13 170.04,52.19 171.96,52.19 172.21,51.93 v1(172.67,51.93)
  IN2 w0.089: v1(172.67,51.93) 173.24,51.36 173.58,51.36 175.69,49.25 175.69,48.6 177.3,46.98 177.3,42.66 177.32,42.64 177.32,42.59 180,39.91 180,38.06 180.81,37.26 180.81,36.48 182.5,34.8 182.5,33.8 185.09,31.21 185.09,29.81 185.61,28.55 186.72,27.44 186.72,26.41 186.96,26.17 187.44,26.17 187.72,25.89 187.72,25.76 188.07,25.41 188.39,25.28 189.22,24.45 189.22,24.02 190.75,22.5 190.75,21.67 190.88,21.54 191.87,21.54 192.12,21.79 193.27,21.79 193.42,21.64 193.96,21.64 194.66,20.93 194.66,19.07 v2(194.79,18.94)
  BOTTOM w0.109: Q5401.5 36.45,57.45 37.01,56.89 37.01,56.49 38.02,55.47 v1(38.99,55.47) 39.32,55.8 43.99,55.8 48.23,51.57 48.23,40.85 51.47,37.61 99.83,37.61 102.86,40.64 117.27,40.64 118.24,41.6 151.31,41.6 155.81,46.1 156.18,46.1 156.34,45.95 v1(156.7,45.95)
FAN1_PWM_Y: length 16.3
  BOTTOM w0.109: CON5400.4 24.51,66.34 24.23,66.06 24.23,62.66 28.66,58.22 C5402.1 30.45,58.22 30.68,57.99 32.67,57.99 R5402.2
FB_CAL_PD_VDDQ: length 12
  TOP w0.109: R6705.2 55.58,91.81 v1(55.62,91.77) 56.51,90.88 57.53,90.88 59.13,89.28 60.32,89.28 60.65,88.95 60.65,88.01 61.49,87.17 61.49,86.51 61.21,86.23 61.21,85.57 v2(60.84,85.2)
  BOTTOM w0.14: v2(60.84,85.2) U6600.D22
FB_CAL_PU_GND: length 5.9
  BOTTOM w0.079: 59.23,88.47 59.23,88.46 59.23,86.71 U6600.C24
  BOTTOM w0.109: R6706.2 59.12,89.58 59.12,88.58 59.23,88.47
FB_CAL_TERM_GND: length 5.7
  BOTTOM w0.079: 58.83,88.56 59.07,88.32 59.07,87.53 U6600.B25
  BOTTOM w0.109: 58.83,88.56 58.83,89.5 58.19,90.14 57.67,90.14 56.46,91.35 R6707.2
FBA_CMD0: length 33.3
  BOTTOM w0.14: VRAM7000.G12 37.12,89.72 38.48,89.72 38.7,89.93 38.7,95.79 41.32,98.42 v4(45.26,98.42) 46.37,98.42 56.25,88.55 56.25,87.57 56.73,87.09 56.73,87.05 57.14,86.64 U6600.C27
FBA_CMD1: length 32.3
  BOTTOM w0.14: VRAM7000.H10 38.68,89.3 39.22,89.84 39.22,95.56 41.55,97.89 v4(43.79,97.89) 46.15,97.89 55.7,88.34 55.7,87.09 56.79,86 57.54,86 U6600.C26
FBA_CMD2: length 37
  TOP w0.14: v2(37.94,88.98) 37.94,89.24 38.38,89.68 38.38,93.95 41.92,97.49 v4(45.13,97.49) 47.08,97.49 50.59,93.98 50.59,92.6 53.74,89.46 57.18,89.46 59.56,87.08 59.56,84.73 v2(59.96,84.33)
  BOTTOM w0.14: VRAM7000.H11 37.62,89.3 v2(37.94,88.98) ; v2(59.96,84.33) U6600.E24
FBA_CMD3: length 38.1
  TOP w0.14: v2(37.98,87.31) 38.16,87.49 38.75,87.49 39.6,88.34 39.6,89.55 39.03,90.12 39.03,93.84 42.14,96.95 v4(42.92,96.95) 46.85,96.95 50.05,93.75 50.05,92.38 53.52,88.92 56.96,88.92 59.03,86.86 59.03,86.46 58.73,86.16 58.73,84.81 59.13,84.41 59.14,84.41 v2(59.14,84.41)
  BOTTOM w0.14: v2(37.98,87.31) 37.59,87.7 VRAM7000.K11 ; U6600.F24 59.14,84.3 v2(59.14,84.41)
FBA_CMD4: length 34.7
  BOTTOM w0.14: VRAM7000.K10 38.58,87.94 38.83,87.94 39.05,87.72 39.05,87 39.23,86.82 39.63,86.82 39.75,86.94 39.75,95.34 41.77,97.36 v4(42.39,97.36) 45.93,97.36 55.05,88.23 55.05,86.99 56.44,85.6 U6600.D27
FBA_CMD5: length 37.1
  TOP w0.14: v2(58.32,85.13) 58.32,85.35 57.43,86.24 57.43,86.42 55.46,88.39 53.29,88.39 49.52,92.16 49.52,93.53 46.63,96.42 v4(46.07,96.42) 42.36,96.42 39.64,93.7 39.64,90.36 40.19,89.81 40.19,88.04 39.05,86.9 VRAM7000.L12 v2(36.34,86.5)
  BOTTOM w0.14: v2(58.32,85.13) 58.32,85.22 U6600.D26 ; v2(36.34,86.5) 36.74,86.9 VRAM7000.L12
FBA_CMD6: length 36.2
  BOTTOM w0.14: U6600.F25 58.29,84.35 57.64,84.35 57.03,84.96 56.32,84.96 54.52,86.76 54.52,88.01 v4(49.27,93.26) 45.71,96.82 41.99,96.82 40.28,95.12 40.28,87.66 40.96,86.97 41.55,86.97 41.87,87.3 42.74,87.3 VRAM7000.K4
FBA_CMD7: length 31.9
  BOTTOM w0.14: U6600.F26 57.67,83.9 57.14,84.43 56.1,84.43 53.99,86.54 53.99,87.79 v4(47.19,94.59) 45.49,96.29 42.23,96.29 40.83,94.89 40.83,88.31 41.26,87.88 42.15,87.88 VRAM7000.K5
FBA_CMD8: length 36.4
  TOP w0.102: v2(60.76,83.48) 60.3,83.94 59.81,83.94 59.72,84.03 58.72,84.03 58.6,84.15
  TOP w0.14: 58.6,84.15 57.9,84.84 57.9,85.25 56.73,86.42 56.67,86.42 55.24,87.86 53.07,87.86 48.99,91.94 48.99,93.31 46.41,95.89 v4(43.84,95.89) 42.58,95.89 40.17,93.47 40.17,90.68 40.79,90.05 40.79,88.34 41.08,88.05 v2(42.73,88.05)
  BOTTOM w0.14: v2(42.73,88.05) 43.14,88.46 VRAM7000.J4 ; v2(60.76,83.48) U6600.F23
FBA_CMD9: length 30.9
  TOP w0.102: v2(60.79,82.66) 60.39,83.07 58.19,83.07
  TOP w0.14: v2(41.83,88.5) 41.87,88.46 43.77,88.46 43.92,88.6 45,88.6 45.63,87.97 46.2,87.97 46.41,88.19 46.72,88.19 46.93,87.97 47.45,87.97 v4(47.92,88.45) 48.32,88.85 48.51,88.85 48.74,88.61 48.74,88.42 48.01,87.69 48.01,87.49 48.18,87.32 48.38,87.32 49.11,88.05 49.31,88.05 49.48,87.88 49.48,87.68 48.75,86.95 48.75,86.75 48.92,86.58 49.12,86.58 49.85,87.31 50.04,87.31 50.21,87.14 50.21,86.94 49.49,86.21 49.49,86.02 49.66,85.85 49.86,85.85 50.58,86.57 50.78,86.57 51.15,86.2 51.42,86.2 51.64,85.98 51.94,85.98 52.16,86.2 52.46,86.2 52.68,85.98 52.98,85.98 53.2,86.2 53.5,86.2 53.72,85.98 54.02,85.98 54.25,86.2 54.6,86.2 57.73,83.07 58.19,83.07
  BOTTOM w0.14: U6600.G22 60.79,82.71 v2(60.79,82.66) ; v2(41.83,88.5) VRAM7000.J5
FBA_CMD10: length 32.6
  TOP w0.102: v2(59.96,83.48) 59.72,83.48 59.37,83.83 58.17,83.83 58.12,83.88
  TOP w0.14: v2(42.74,88.9) 42.61,89.03 41.6,89.03 41.33,89.3 41.33,90.36 40.7,90.99 40.7,93.25 42.38,94.93 43.97,94.93 43.97,94.93 v4(46,94.93) 46.61,94.93 46.81,94.73 46.81,94.73 48.45,93.09 48.45,91.72 52.85,87.32 55.02,87.32 57.04,85.3 57.04,84.96 58.12,83.88
  BOTTOM w0.14: v2(42.74,88.9) VRAM7000.H4 ; v2(59.96,83.48) U6600.G23
FBA_CMD11: length 29.2
  TOP w0.14: v2(59.14,83.45) 58.11,83.45 54.82,86.74 52.5,86.74 52.22,87.01 52.02,87.01 51.75,86.74 51.53,86.74 51.36,86.91 51.36,87.09 51.65,87.38 51.65,87.58 51.48,87.75 51.29,87.75 50.92,87.38 50.72,87.38 50.55,87.55 50.55,87.75 50.92,88.12 50.92,88.31 50.7,88.53 50.5,88.53 50.4,88.43 50.2,88.43 50.03,88.6 50.03,88.8 50.13,88.9 50.13,89.1 49.88,89.35 49.69,89.35 49.32,88.98 49.12,88.98 48.95,89.15 48.95,89.34 49.32,89.71 49.32,89.91 48.56,90.68 48.33,90.68 48.2,90.54 v4(48.2,90.07) 48.2,89.48 47.45,88.73 45.63,88.73 45.06,89.31 44.29,89.31 44.17,89.43 44.17,89.81 44.05,89.93 43.63,89.93 43.49,89.79 43.49,89.32 43.35,89.18 43.11,89.18 42.97,89.32 42.97,89.79 42.83,89.93 42.2,89.93 v2(41.75,89.48)
  BOTTOM w0.14: v2(59.14,83.45) 59.19,83.45 U6600.G24 ; VRAM7000.H5 41.92,89.3 v2(41.75,89.48)
FBA_CMD12: length 29.3
  BOTTOM w0.14: U6600.F27 55.86,83.9 53.44,86.32 53.44,87.58 v4(49.62,91.4) 45.16,95.86 42.62,95.86 41.41,94.65 41.41,90.15 41.63,89.93 41.93,89.93 42.18,89.69 43.37,89.69 43.79,90.1 VRAM7000.G3
FBA_CMD13: length 27
  BOTTOM w0.14: U6600.G25 58.32,82.68 54.93,82.68 54.61,83 54.15,83 R6703.2 53.89,83.52 53.72,83.69 52.05,83.69 51.9,83.84 51.9,84.17 51.75,84.33 51.45,84.33 51.29,84.17 51.29,83.84 51.14,83.69 50.85,83.69 50.71,83.83 50.71,84.69 50.57,84.83 50.33,84.83 50.19,84.69 50.19,83.83 50.05,83.69 49.81,83.69 49.65,83.85 49.65,85.14 49.51,85.28 48.83,85.28 48.69,85.42 48.69,85.66 48.83,85.8 49.51,85.8 49.65,85.94 49.65,86.24 49.51,86.38 v4(48.92,86.38) 47.71,86.38 47.57,86.52 47.57,86.76 47.71,86.9 49.51,86.9 49.65,87.04 49.65,87.31 49.52,87.43 46.63,87.43 45.96,88.1 45.14,88.1 VRAM7000.J2
FBA_CMD14: length 25.6
  BOTTOM w0.14: VRAM7000.J3 44.33,88.89 45.97,88.89 46.62,89.55 46.62,89.82 46.76,89.96 47,89.96 47.14,89.82 47.14,89.55 47.28,89.41 47.52,89.41 47.66,89.55 47.66,89.82 47.8,89.96 48.05,89.96 48.19,89.82 48.19,89.55 48.33,89.41 48.57,89.41 48.71,89.55 48.71,89.82 48.85,89.96 49.09,89.96 49.23,89.82 49.23,89.55 49.37,89.41 49.54,89.41 50.82,88.13 50.82,87.44 50.96,87.29 50.96,87.1 50.18,86.31 50.18,86.12 50.35,85.94 50.54,85.94 v4(50.95,86.35) 51.33,86.73 51.53,86.73 51.7,86.56 51.7,86.36 50.91,85.58 50.91,85.38 51.08,85.21 51.28,85.21 52.06,85.99 52.26,85.99 52.49,85.77 52.49,85.57 51.98,85.07 51.98,84.87 52.15,84.7 52.35,84.7 52.86,85.2 53.05,85.2 53.89,84.36 R6701.2 54.17,83.87 54.35,83.87 55.12,83.1 U6600.G27
FBA_CMD15: length 26
  BOTTOM w0.14: U6600.G26 57.55,83.49 55.51,83.49 52.91,86.1 52.91,86.18 52.91,86.45 52.73,86.64 52.6,86.64 52.37,86.64 52.15,86.86 52.15,87.05 52.59,87.49 52.59,87.69 52.42,87.86 52.22,87.86 51.78,87.42 51.59,87.42 51.35,87.66 51.35,87.75 51.84,88.24 51.84,88.44 51.54,88.74 51.34,88.74 51.25,88.65 51.05,88.65 50.88,88.82 50.88,89.02 50.97,89.11 50.97,89.31 50.8,89.48 50.6,89.48 50.51,89.38 50.31,89.38 50.14,89.56 50.14,89.75 50.24,89.85 50.24,90.04 49.78,90.5 49.31,90.5 49.17,90.64 49.17,90.92 49.03,91.06 48.79,91.06 48.65,90.92 48.65,90.64 48.51,90.5 v4(47.34,90.5) 44.6,90.5 44.33,90.23 44.33,89.95 44.1,89.73 43.84,89.73 43.51,89.39 43.51,88.34 43.74,88.12 44.17,88.12 44.35,87.94 44.35,87.31 VRAM7000.L3
FBA_CMD16: length 44.2
  TOP w0.14: v2(36.34,71.7) 36.72,71.32 37.29,71.32 37.56,71.05 37.56,64.67 41.36,60.87 45.2,60.87 46.47,62.14 48,63.68 48.79,65.58 49.88,66.67 49.88,67.53 52.31,69.95 52.31,72.2 52.61,72.5 v4(52.61,73.63) 52.61,75.36 53.5,76.25 55.11,76.25 55.14,76.28 57.02,76.28 58.16,77.42 58.82,77.42 v2(59.94,78.54)
  BOTTOM w0.14: v2(36.34,71.7) 36.74,72.1 VRAM7001.G12 ; U6600.M24 v2(59.94,78.54)
FBA_CMD17: length 43.6
  TOP w0.14: v2(37.95,71.65) 38.4,71.2 38.4,69.72 38.24,69.56 38.24,68.84 38.66,68.42 38.66,64.33 41.58,61.41 44.98,61.41 47.55,63.98 48.27,65.72 48.27,67.05 51.77,70.55 v4(51.77,71.96) 51.77,72.58 52.08,72.89 52.08,75.58 53.28,76.78 54.68,76.78 56.15,78.25 58.79,78.25 59.51,78.97 60.36,78.97 v2(60.75,78.57)
  BOTTOM w0.14: v2(60.75,78.57) 60.71,78.57 U6600.M23 ; v2(37.95,71.65) 38.3,71.3 VRAM7001.H10
FBA_CMD18: length 41.4
  TOP w0.14: v2(37.14,71.74) 37.47,72.08 38.1,72.08 40.55,69.63 40.55,64.91 41.47,63.99 45.29,63.99 45.85,64.54 46.32,65.25 46.51,65.87 46.51,67.7 47.24,68.44 47.24,70.39 50.48,73.63 50.48,76.25 v4(51.82,77.59) 53.87,79.63 58,79.63 59.02,80.65 59.49,80.65 v2(59.94,80.2)
  BOTTOM w0.14: v2(59.94,80.2) 59.94,80.22 U6600.K24 ; VRAM7001.H11 37.54,71.34 v2(37.14,71.74)
FBA_CMD19: length 41.7
  TOP w0.14: v2(60.76,80.2) 60.35,79.79 58.95,79.79 58.18,79.03 54.02,79.03 v4(51.37,76.38) 51.01,76.03 51.01,73.33 50.62,72.93 50.62,71.06 47.1,67.54 47.1,65.72 46.78,64.94 46.32,64.26 45.12,63.06 41.53,63.06 39.81,64.77 39.81,69.54 38.81,70.55 v2(38.81,70.73)
  BOTTOM w0.14: VRAM7001.K11 37.54,69.75 37.86,70.08 38.49,70.08 38.81,70.4 v2(38.81,70.73) ; v2(60.76,80.2) U6600.K23
FBA_CMD20: length 35.3
  TOP w0.14: v2(38.73,69.23) 39.27,68.68 39.27,64.49 41.26,62.5 45.32,62.5 46.78,63.96 46.98,64.21 47.21,64.59 47.7,65.78 47.7,67.31 51.15,70.76 51.15,72.71 51.55,73.11 v4(51.55,74.6) 51.55,75.8 54.14,78.39 v1(54.14,78.52)
  BOTTOM w0.14: U6600.M27 56.94,79.14 55.26,79.14 54.64,78.52 v1(54.14,78.52) ; VRAM7001.K10 38.34,69.62 v2(38.73,69.23)
FBA_CMD21: length 54.3
  TOP w0.14: v2(36.34,68.5) 36.75,68.09 36.75,64.73 41.13,60.34 v4(44.02,60.34) 46.99,60.34 49.69,57.64 53.88,57.64 54.33,58.09 54.74,58.09 57.06,60.41 57.06,64.76 53.64,68.18 53.64,72.35 54.34,73.05 54.34,75.61 v1(54.17,75.78)
  BOTTOM w0.14: v1(54.17,75.78) 54.08,75.78 53.26,76.61 53.26,78.26 54.43,79.42 57.32,79.42 57.8,78.94 U6600.M26 ; VRAM7001.L12 v2(36.34,68.5)
FBA_CMD22: length 34.4
  BOTTOM w0.14: VRAM7001.K4 43.19,69.7 43.59,70.1 46.19,70.1 46.68,69.61 49.62,69.61 51.05,71.04 51.05,73.14 50.9,73.3 49.34,73.3 49.19,73.45 49.19,73.75 49.34,73.91 52.34,73.91 52.51,74.07 52.51,74.36 52.35,74.52 49.34,74.52 49.19,74.67 49.19,74.97 49.34,75.13 v4(51.26,75.13) 52.37,75.13 52.59,75.35 52.59,78.41 53.91,79.72 57.46,79.72 57.86,79.32 58.36,79.32 U6600.M25
FBA_CMD23: length 34.1
  TOP w0.14: v1(45.65,78.86) 45.65,78.46 44.97,77.79 44.97,74.69 44.62,74.34 43.66,74.34 43.13,73.81 43.13,72.89 43.16,72.87 43.16,72.14 43.13,72.12 v4(43.13,70.23) 43.13,69.71 v2(42.73,69.31)
  BOTTOM w0.14: U6600.K26 57.43,80.11 55.41,80.11 55.16,80.35 53.35,80.35 52.06,79.07 52.06,76.19 51.9,76.03 50.54,76.03 50.39,76.17 50.39,77.54 50.22,77.71 49.94,77.71 49.78,77.56 49.78,76.22 49.63,76.07 49.34,76.07 49.17,76.23 49.17,77.54 49,77.71 48.72,77.71 48.57,77.56 48.57,76.88 48.4,76.71 48.13,76.71 45.98,78.86 v1(45.65,78.86) ; v2(42.73,69.31) VRAM7001.K5
FBA_CMD24: length 37.5
  TOP w0.102: v2(60.76,81.02) 60.32,81.46 60.32,82.1 60.16,82.27 58.98,82.27 58.76,82.49
  TOP w0.14: 58.76,82.49 58.65,82.61 57.38,82.61 54.55,85.44 v4(50.92,85.44) 50.3,85.44 45.92,81.06 44.75,81.06 40.47,76.78 40.47,73.29 40.85,72.91 41.35,72.91 41.5,72.75 41.5,72.45 41.35,72.3 40.85,72.3 40.43,71.87 40.43,70.52 40.99,69.96 v2(41.54,69.96)
  BOTTOM w0.14: v2(60.76,81.02) 60.78,81.02 U6600.K22 ; v2(41.54,69.96) 41.68,70.1 42.64,70.1 43.04,70.5 VRAM7001.J4
FBA_CMD25: length 35.3
  TOP w0.14: v2(59.94,81.02) 58.2,81.02 57.73,81.49 56.93,81.49 54.85,83.57 52.61,83.57 52.07,84.11 v4(51.46,84.11) 51.01,84.11 50.61,83.71 50.61,82.97 50.31,82.67 50.31,82.46 50.63,82.13 50.63,81.91 50.42,81.69 50.21,81.69 49.87,82.03 49.66,82.03 49.44,81.81 49.44,81.59 49.72,81.32 49.72,81.07 49.5,80.86 49.32,80.86 49.01,81.16 48.8,81.16 48.39,80.75 48.17,80.75 47.88,81.05 47.66,81.05 47.45,80.83 47.45,80.62 47.74,80.32 47.74,80.11 47.43,79.79 45.47,79.79 45.08,79.4 45.08,78.65 44.48,78.05 43.49,78.05 43.49,78.04 43.26,77.81 43.26,76.06 43.1,75.91 42.55,75.91 42.11,75.48 42.11,71.93 42.5,71.55 42.5,70.72 42.34,70.57 v2(41.52,70.57)
  BOTTOM w0.14: VRAM7001.J5 41.59,70.5 v2(41.52,70.57) ; v2(59.94,81.02) U6600.J23
FBA_CMD26: length 33.9
  BOTTOM w0.102: 56.39,82.38 57.3,82.38 57.78,81.9 57.99,81.9 58.47,81.42 U6600.J25
  BOTTOM w0.14: 56.39,82.38 54.64,82.38 54.53,82.49 52.11,82.49 51.78,82.15 51.78,80.68 51.61,80.51 51.3,80.51 51.15,80.66 51.15,82.97 50.97,83.16 50.7,83.16 50.56,83.02 50.56,80.54 50.2,80.18 v4(49.53,80.18) 46.01,80.18 45.13,79.31 45.13,78.41 44.8,78.08 42.99,78.08 41.05,76.14 41.05,72.32 41.98,71.4 41.98,71.16 42.2,70.94 42.78,70.94 VRAM7001.H4
FBA_CMD27: length 33.6
  TOP w0.14: v1(41.48,73.59) 41.11,73.96 41.11,76.43 45.04,80.35 45.97,80.35 47.83,82.22 48.04,82.22 48.49,81.78 48.73,81.78 48.94,81.99 48.94,82.18 48.48,82.65 48.48,82.86 48.69,83.08 48.91,83.08 49.37,82.61 49.58,82.61 49.8,82.83 49.8,83.05 49.34,83.51 49.34,83.73 v4(49.83,84.22) 50.52,84.91 52.07,84.91 52.87,84.1 55.07,84.1 57.01,82.17 58.46,82.17 58.61,82.01 58.61,81.52 58.77,81.37 59.47,81.37 v2(59.94,81.84)
  BOTTOM w0.14: U6600.J24 59.94,81.82 v2(59.94,81.84) ; v1(41.48,73.59) 41.48,72.45 42.34,71.6 VRAM7001.H5
FBA_CMD28: length 32.9
  TOP w0.14: v2(44.38,71.71) 44.38,71.09 44.24,70.96 44.24,70.53 44.4,70.37 45.72,70.37 47.8,72.45 47.8,73.76 48.52,74.49 48.52,74.82 48.37,74.97 48.23,74.97 48.08,75.12 48.08,75.43 48.23,75.58 48.37,75.58 48.52,75.73 48.52,76.04 48.37,76.19 48.23,76.19 48.08,76.34 48.08,76.65 48.23,76.8 48.37,76.8 48.52,76.95 48.52,77.24 48.81,77.53 48.81,77.74 48.08,78.47 48.08,78.69 48.29,78.91 48.52,78.91 v4(49.08,78.35) 49.59,77.84 49.83,77.84 50.05,78.06 50.05,78.24 48.93,79.36 48.93,79.58 49.15,79.79 49.36,79.79 49.66,79.49 50.04,79.49 50.35,79.17 50.35,78.8 50.74,78.41 51.14,78.41 51.52,78.79 51.52,79 51.14,79.38 51.14,79.6 51.36,79.81 51.57,79.81 51.95,79.44 52.16,79.44 52.38,79.65 52.38,79.87 51.67,80.57 51.67,80.8 51.88,81.01 52.1,81.01 52.81,80.3 53.02,80.3 53.43,80.7 53.91,80.7 54.26,81.05 54.57,81.05 54.92,80.7 55.67,80.7 v1(55.78,80.59)
  BOTTOM w0.14: v2(44.38,71.71) 43.98,72.1 VRAM7001.G3 ; U6600.K27 55.81,80.62 v1(55.78,80.59)
FBA_CMD29: length 34.4
  TOP w0.14: v1(55.27,81.83) 55.18,81.92 54.68,81.92 54.53,82.07 54.53,82.86 54.35,83.04 54.05,83.04 53.92,82.91 53.92,81.81 53.77,81.66 53.47,81.66 53.31,81.82 53.31,82.33 53.16,82.48 52.85,82.48 52.7,82.33 52.7,81.79 52.57,81.66 52.22,81.66 51.95,81.93 51.95,83.08 51.8,83.23 51.38,83.23 51.16,83.02 v4(51.16,82.14) R6704.1 50.79,80.9 50.22,80.32 48.93,80.32 47.54,78.94 47.54,78.19 47.91,77.82 47.91,77.24 47.54,76.87 47.54,75.15 47.29,74.9 46.36,74.9 46.17,74.71 46.17,74.16 46.41,73.92 47.05,73.92 47.27,73.71 47.27,72.77 47.16,72.66 46.78,72.66 46.31,73.13 45.78,73.13 45.63,72.98 45.63,72.3 45.79,72.14 46.24,72.14 46.35,72.03 46.35,71.76 45.47,70.88 v2(45.14,70.88)
  BOTTOM w0.102: U6600.K25 58.35,81.01 57.68,81.01 57.51,81.19 57.51,81.58 57.28,81.81 56.96,81.81 56.49,81.34
  BOTTOM w0.14: v1(55.27,81.83) 55.76,81.34 56.49,81.34 ; VRAM7001.J2 44.76,70.5 v2(45.14,70.88)
FBA_CMD30: length 32.4
  TOP w0.14: v1(46.84,78.92) 46.84,77.2 46.32,76.68 45.78,76.68 45.57,76.46 45.57,74.06 45.35,73.84 45.09,73.84 44.75,73.5 44.75,72.71 44.75,72.71 44.75,72.37 44.51,72.13 44.2,72.13 43.95,71.88 43.95,71.26 v2(43.56,70.88)
  BOTTOM w0.14: v1(46.84,78.92) 47.17,79.25 47.38,79.25 47.54,79.1 47.54,78.13 47.67,78 47.98,78 48.13,78.15 48.13,79.45 48.31,79.63 48.6,79.63 48.76,79.48 48.76,78.4 48.91,78.25 49.21,78.25 49.36,78.4 49.36,79.47 49.53,79.63 49.82,79.63 49.97,79.48 49.97,78.42 50.13,78.27 50.74,78.27 50.94,78.07 50.94,77.44 51.12,77.27 51.38,77.27 51.51,77.4 v4(51.51,78.51) 51.51,79.5 52.37,80.36 52.37,81.48 52.73,81.84 53.58,81.84 53.89,81.53 R6702.1 54.08,81.04 56.76,81.04 U6600.J27 ; v2(43.56,70.88) VRAM7001.J3
FBA_CMD31: length 32.9
  TOP w0.14: v1(55.97,81.82) 55.77,81.63 55.77,81.35 56.44,80.69 57.91,80.69 58.09,80.51 58.09,80.19 57.95,80.04 55.53,80.04 55.41,80.17 53.65,80.17 v4(52.55,79.07) 50.8,77.32 49.95,77.32 49.8,77.17 49.21,77.17 49.06,77.02 49.06,76.71 49.21,76.56 49.8,76.56 49.95,76.41 49.95,76.1 49.8,75.95 49.21,75.95 49.06,75.8 49.06,75.49 49.21,75.34 49.8,75.34 49.95,75.19 49.95,74.89 49.8,74.73 49.21,74.73 49.06,74.58 49.06,74.28 49.21,74.12 49.8,74.12 49.95,73.97 49.95,73.85 49.31,73.21 49.1,73.21 48.75,73.55 48.55,73.55 48.33,73.34 48.33,73.11 48.63,72.81 48.63,72.53 46.7,70.6 46.7,70.15 46.59,70.04 46.14,70.04 45.94,69.84 44.57,69.84 44.36,69.63 v2(44.36,69.33)
  BOTTOM w0.102: v1(55.97,81.82) 56.21,82.07 57.31,82.07 57.94,81.44 U6600.J26
  BOTTOM w0.14: VRAM7001.L3 43.94,69.13 44.14,69.33 v2(44.36,69.33)
FBA_DBI0: length 24.5
  IN1 w0.102: v2(62.08,89.08) 61.09,89.08 60.44,89.73 50.15,89.73 46.67,93.21 45.8,93.21 45.53,92.94 v2(45.13,92.94)
  BOTTOM w0.079: U6600.D19 63.39,85.93 63.39,88.91 62.86,89.43 62.43,89.43 v2(62.08,89.08)
  BOTTOM w0.14: VRAM7000.D2 45.13,92.89 v2(45.13,92.94)
FBA_DBI1: length 51.2
  IN1 w0.102: v2(68.26,85.2) 68.26,85.75 70.12,87.61 70.12,89.62 69.26,90.47 69.26,93.47 67.66,95.08 66.07,95.08 65,95.52 53.9,95.52 50.31,99.1 42.59,99.1 41.28,97.8 37.41,97.8 35.09,95.48 35.09,94.8 35.1,94.79 35.1,93.3 v2(35.51,92.88)
  BOTTOM w0.14: VRAM7000.D13 35.56,92.88 v2(35.51,92.88) ; U6600.D14 68.24,85.2 v2(68.26,85.2)
FBA_DBI2: length 45.7
  IN3 w0.114: v2(36.39,84.11) 35.99,84.51 35.42,84.51 35.1,84.84 35.1,85.77 35.43,86.1 35.71,86.1 35.96,86.36 35.96,87.48 36.19,87.7 37.31,87.7 37.56,87.96 37.56,88.29 37.82,88.54 38.25,88.54 38.48,88.77 38.48,88.97 41.35,91.85 41.35,92.23 41.58,92.46 42.13,92.46 42.27,92.32 42.27,91.82 42.48,91.6 43.12,91.6 44.03,92.51 45.52,92.51 45.58,92.45 46.73,92.45 48.12,93.84 63.31,93.84 64.97,92.17 64.97,89.82 v2(65.94,88.86)
  BOTTOM w0.079: 65.84,88.47 65.7,88.33 65.7,87.35 65.71,87.34 65.71,86.75 U6600.C17
  BOTTOM w0.102: 65.84,88.47 65.94,88.56 v2(65.94,88.86)
  BOTTOM w0.14: VRAM7000.P13 36.33,84.11 v2(36.39,84.11)
FBA_DBI3: length 22.8
  IN3 w0.114: v2(45.14,84.03) 45.46,83.71 49.82,83.71 55.48,89.36 60.39,89.36 61.09,88.66 61.09,87.59 61.64,87.04 v2(61.64,86)
  BOTTOM w0.14: v2(45.14,84.03) 45.14,84.1 VRAM7000.P2 ; v2(61.64,86) U6600.C22
FBA_DBI4: length 23.1
  IN1 w0.102: v2(47.03,75.85) 46.91,75.85 46.76,76 46.76,77.09 51.33,81.66 53.74,81.66 54.36,81.05 54.81,81.05 55.18,81.43 56.43,81.43 59.95,77.91 v2(59.95,76.87)
  BOTTOM w0.14: v2(47.03,75.85) 47.03,75.73 46.8,75.5 46.8,75.25 46.42,74.88 45.12,74.88 VRAM7001.D2 ; v2(59.95,76.87) 59.95,76.89 U6600.P24
FBA_DBI5: length 54.1
  IN1 w0.102: v2(36.34,74.9) 36.34,74.91 35.96,75.29 34.62,75.29 34.4,75.07 33.97,74.02 33.97,64.9 34.62,63.31 36.24,61.7 37.28,61.26 40.2,58.34 42.22,58.34 43.57,57.79 54.51,57.79 57.71,60.98 57.71,64.08 58.89,66.93 58.89,68.81 58.73,68.97 58.73,72.16 59.14,72.58 v2(59.14,72.78)
  BOTTOM w0.14: VRAM7001.D13 35.94,74.5 v2(36.34,74.9) ; v2(59.14,72.78) U6600.W24
FBA_DBI6: length 31.7
  IN1 w0.102: v2(36.34,66.1) 36.34,65.85 36.51,65.69 37.41,65.69 37.59,65.5 37.59,65.01 37.86,64.75 37.86,64.6 41.68,60.78 46.02,60.78 51.23,65.99 52.8,65.99 54.88,68.06 54.88,70.16 v2(54.8,70.24)
  BOTTOM w0.14: U6600.AA25 58.33,71.09 55.27,71.09 54.8,70.62 v2(54.8,70.24) ; VRAM7001.P13 v2(36.34,66.1)
FBA_DBI7: length 20
  IN1 w0.102: v2(59.14,75.17) 58.77,74.8 56.72,74.8 56.67,74.85 56.19,74.85 55.71,75.32 55.4,75.32 55.06,74.99 53.38,74.99 51.05,72.66 51.05,71.85 46.99,67.78 46.99,67.38 46.27,66.65 45.69,66.65 v2(45.14,66.1)
  BOTTOM w0.14: VRAM7001.P2 v2(45.14,66.1) ; v2(59.14,75.17) 59.09,75.17 U6600.U25
FBA_EDC0: length 24.6
  IN1 w0.102: v2(63.3,85.2) 63.13,85.37 63.13,86.43 60.24,89.32 49.53,89.32 v2(47.93,90.93)
  BOTTOM w0.14: VRAM7000.C2 45.18,93.74 46.53,93.74 v4(47.59,92.68) 48.27,92 48.27,91.28 v2(47.93,90.93) ; v2(63.3,85.2) 63.32,85.2 U6600.E19
FBA_EDC1: length 47.4
  IN1 w0.102: v2(67.42,86) 69.42,88 69.42,89.24 68.45,90.2 68.45,92.96 67.54,93.88 66.25,93.88 65.83,94.3 64.84,94.71 53.55,94.71 51.61,96.65 49.97,98.29 43.14,98.29 41.84,96.99 37.78,96.99 37.15,96.35 37.15,95.55 36.73,95.13 36.73,93.27 v2(36.35,92.89)
  BOTTOM w0.14: VRAM7000.C13 v2(36.35,92.89) ; U6600.C15 67.4,86 v2(67.42,86)
FBA_EDC2: length 47.8
  IN3 w0.114: v2(35.54,83.3) 35.22,83.3 34.69,83.82 33.94,84.95 33.9,85.06 33.9,86.22 34.27,87.12 34.44,87.37 35.3,88.24 35.41,88.24 37.06,89.89 38.02,89.89 40.09,91.96 40.09,92.24 41.44,93.58 41.44,93.76 41.75,94.07 45.47,94.07 45.77,93.77 46.31,93.77 47.21,94.68 63.65,94.68 64.49,93.85 65.16,93.85 66.18,92.83 66.18,91.79 66.33,91.64 66.33,90.05 v2(66.09,89.81)
  BOTTOM w0.079: 66.07,88.38 65.87,88.17 65.87,87.78 U6600.B16
  BOTTOM w0.102: 66.07,88.38 66.37,88.67
  BOTTOM w0.14: 66.37,88.67 66.37,89.53 v2(66.09,89.81) ; VRAM7000.R13 v2(35.54,83.3)
FBA_EDC3: length 20.7
  IN3 w0.114: v2(45.13,83.31) 45.54,82.9 49.61,82.9 55.65,88.94 58.55,88.94 59.09,88.4 59.88,88.4 v2(60.26,88.77)
  BOTTOM w0.14: U6600.B22 60.78,87.66 60.78,88.25 v2(60.26,88.77) ; VRAM7000.R2 v2(45.13,83.31)
FBA_EDC4: length 21.1
  IN1 w0.102: v2(59.17,76.89) 59.17,78.11 56.26,81.02 55.42,81.02 54.93,80.52 53.9,80.52 53.79,80.63 53.79,80.92 53.69,81.02 53.24,81.02 53.07,80.84 52.1,80.84 51.76,80.5 51.76,80.36 51.92,80.2 51.92,80.05 51.77,79.91 51.63,79.91 51.47,80.07 51.33,80.07 50.8,79.55 50.02,79.55 47.3,76.83 47.3,76.78 v2(47.12,76.61)
  BOTTOM w0.14: VRAM7001.C2 45.16,75.72 46.2,75.72 46.83,76.35 46.87,76.35 v2(47.12,76.61) ; v2(59.17,76.89) U6600.R25
FBA_EDC5: length 55.1
  IN1 w0.102: v2(35.54,75.7) 34.46,75.7 34.03,75.28 33.55,74.12 33.55,64.8 34.31,62.97 35.91,61.37 36.96,60.93 40.01,57.88 42.22,57.88 43.44,57.38 54.68,57.38 58.11,60.81 58.11,63.99 59.29,66.84 59.29,69.06 59.54,69.64 59.54,71.98 59.85,72.74 v2(59.94,72.78)
  BOTTOM w0.14: VRAM7001.C13 35.94,75.3 v2(35.54,75.7) ; v2(59.94,72.78) U6600.W23
FBA_EDC6: length 29.7
  IN1 w0.102: v2(36.34,65.3) 36.34,65.09 36.42,65.02 36.91,64.52 37.36,64.52 41.51,60.38 46.19,60.38 51.22,65.4 52.79,65.4 55.43,68.04 55.43,69.1 55.8,69.47 55.8,69.91 v2(56.42,70.52)
  BOTTOM w0.14: v2(56.42,70.52) 56.66,70.28 57.27,70.28 57.7,70.7 U6600.AB26 ; VRAM7001.R13 v2(36.34,65.3)
FBA_EDC7: length 19.1
  IN1 w0.102: v2(44.37,66.1) 44.86,66.59 44.86,66.62 45.34,67.1 46.12,67.1 46.5,67.48 46.5,67.87 50.65,72.02 50.65,72.82 53.23,75.4 54.88,75.4 55.25,75.77 v2(56.6,75.77)
  BOTTOM w0.102: U6600.T26 57.4,75.37 57.24,75.32 57.05,75.32 56.94,75.36 56.82,75.49 v2(56.6,75.77)
  BOTTOM w0.14: v2(44.37,66.1) 44.37,66.07 VRAM7001.R2
FBVDD_EN: length 73.6
  IN3 w0.089: v1(85.77,97.75) 84.5,97.75 84.1,98.14 84.1,98.7 81.79,101.01 80.31,101.01 79.7,101.62 57.58,101.62 56.41,102.79 49.01,102.79 46.46,100.25 41.98,100.25 41.19,101.04 33.5,101.04 32.05,102.49 30.15,102.49 28.85,101.19 28.85,101.12 v1(28.57,100.83)
  BOTTOM w0.109: U6701.4 86.37,98.09 R6712.2 86.1,98.79 86.1,98.02 85.82,97.75 v1(85.77,97.75) ; v1(28.57,100.83) 28.36,100.63 28.36,97.53 27.74,96.9 27.74,95.76 27.46,95.47 v1(27.46,94.28) 27.46,93.96 PR10208.2
FBVDD_PWROK: length 198.3
  IN2 w0.079: 141.69,83.61 v2(141.96,83.35) 142.34,83.73 142.86,83.73 142.92,83.79
  IN2 w0.089: v2(150.77,82.18) 150.62,82.32 150.62,82.55 149.39,83.79 147.55,83.79 147.46,83.87 144.69,83.87 144.53,84.03 143.16,84.03 142.92,83.79 ; v1(80.54,101.6) 80.54,102.18 81.04,102.68 81.04,106.69 82.05,107.7 83.4,107.7 83.54,107.57 85.3,107.57 86.7,108.97 89.63,108.97 89.78,108.82 92.7,108.82 92.88,109.01 104.71,109.01 105,108.73 108.59,108.73 109.45,109.58 111.03,109.58 112.55,108.07 119.86,108.07 121.85,106.08 123.81,106.08 125.63,104.26 128.65,104.26 128.85,104.47 129.33,104.47 129.5,104.29 132.32,104.29 132.63,103.99 132.63,102.22 132.81,102.03 133.03,102.03 133.54,101.52 133.84,101.52 134.05,101.31 134.05,100.97 133.86,100.78 133.86,99.82 134.43,99.25 135.61,99.25 136.22,98.63 136.22,96.74 137.19,95.77 137.19,93.32 137.88,92.63 138.45,92.63 138.79,92.3 141.85,92.3 142.52,91.63 142.52,90.69 142.83,90.38 144.98,90.38 145.21,90.14 145.21,88.09 141.49,84.37 141.49,83.81 141.69,83.61
  IN3 w0.089: v1(28.42,101.44) 28.85,101.44 30.07,102.66 32.14,102.66 33.59,101.22 40.87,101.22 41.4,101.75 41.73,101.75 42.28,101.21 46.92,101.21 48.88,103.17 56.56,103.17 57.76,101.98 80.16,101.98 v1(80.54,101.6)
  BOTTOM w0.079: v2(141.96,83.35) 141.54,83.77 U400.DM6
  BOTTOM w0.109: PR10204.2 27.02,95.37 27.51,95.85 27.51,97 28.13,97.62 28.13,101.16 v1(28.42,101.44) ; v2(150.77,82.18) 150.77,81.86 150.95,81.68 R1145.2 ; v1(80.54,101.6) 80.72,101.42 U6901.1 80.72,99.69 79.64,98.61 79.64,98.36 77.29,96.01 76.22,96.01 75.98,95.77 75.98,95.67 R6810.2 ; R6810.2 75.71,95.48 75.42,95.78 73.46,95.78 72.85,96.38 71.16,96.38 71.1,96.33 67.86,96.33 67.77,96.42 67.77,96.68 67.51,96.94 66.47,96.94 65.96,96.43 65.96,96.31 65.38,95.73 63.73,95.73 62.5,94.5 61.53,94.5 60.93,93.91 60.01,93.91 Q6801.3 ; R6810.2 75.71,95.29 75.26,94.84 R6807.1
FBVDDQ_GPU: length 8.6
  TOP w0.254: R6708.1 61.92,84.1 v2(62.46,83.56)
  BOTTOM w0.203: v2(59.14,81.84) 58.54,81.84 58.12,82.26 U6600.H26 ; v2(59.16,80.21) 59.14,80.2 58.36,80.2 U6600.L26
  BOTTOM w0.254: v1(52.91,81.23) R6702.2 ; v1(53.05,84.55) 53.44,84.16 R6701.1
  BOTTOM w0.305: U6600.H24 59.54,82.24 v2(59.14,81.84) ; U6600.L24 59.54,79.83 v2(59.16,80.21) ; U6600.E26 57.83,84.75 v2(57.45,85.12) ; U6600.C25 58.74,86.43 v2(58.34,86.83) 57.97,87.2 U6600.B26 ; U6600.E23 60.39,84.8 v2(59.99,85.2)
  vias: v1(60.27,65.12) v1(60.27,64.49) v1(60.27,63.85) v1(60.3,65.76) v1(65,85.14) v2(61.58,81.02) v2(61.57,80.16) v2(61.59,72.76) v2(61.62,82.73) v2(61.92,74.85) v2(62.1,79.83) v2(62.89,82.55) v2(63.31,83.55) v2(64.13,83.55) v2(64.16,82.75) v2(65,82.84) v2(65.66,82.84) v2(65.78,83.55) v2(68.26,83.5) v2(68.19,82.72) v3(32.71,80.21) v3(32.71,79.45) v3(33.22,62.81) v3(33.48,81.35) v3(33.48,80.59) v3(33.48,79.83) v3(33.86,62.05) v3(34.24,80.59) v3(34.49,61.54) v3(35.13,60.91)
FBVDDQ_MEM: length 65.3
  TOP w0.381: C7025.1 36.41,76.43 v2(36.34,76.5) ; C7014.2 34.16,64.8 v2(34.72,65.36) ; v2(37.94,74.1) 38,74.16 C7046.1 ; v2(38.76,75.66) 38.89,75.79 C7027.1
  IN1 w0.381: v2(37.94,93.7) v2(37.14,93.7)
  BOTTOM w0.203: VRAM7000.B3 44.35,93.69 44.35,92.91 VRAM7000.D3
  BOTTOM w0.254: v2(34.72,65.36) 35.14,64.94 VRAM7001.T14 ; VRAM7000.G1 v2(45.16,89.72) 44.79,90.1 VRAM7000.G2 44.74,89.9 44.2,89.36 44,89.36 VRAM7000.H3 ; VRAM7001.M1 v2(45.94,68.5) VRAM7001.L1 ; R7009.1 49.45,71.75 v1(49.68,71.98) ; VRAM7000.H12 36.37,89.67 v2(36.31,89.67) ; VRAM7001.B14 v2(34.71,76.53) ; v2(44.31,74.9) 43.94,74.53 VRAM7001.D3 ; v2(43.55,66.04) 43.94,66.43 VRAM7001.P3 ; v2(36.34,94.5) VRAM7000.B12 v2(37.14,93.7) ; v2(46.04,66.21) 45.75,66.5 VRAM7001.P1 ; VRAM7001.M3 v2(44.36,68.52) VRAM7001.L2 ; VRAM7000.C5 42.32,93.3 v2(41.88,92.87) ; VRAM7001.B12 v2(36.34,76.5) ; VRAM7000.F3 43.94,90.84 v2(43.57,90.47) 43.2,90.1 VRAM7000.G4 ; VRAM7001.K3 43.94,69.68 43.92,69.68 v2(43.54,69.3) ; VRAM7001.P14 v2(34.74,66.1) ; VRAM7001.T3 v2(43.54,65.3) ; VRAM7001.G13 v2(36.34,72.5) 36.74,72.9 VRAM7001.F12 ; VRAM7000.F1 45.64,91 v2(46.19,91) ; VRAM7001.T1 v2(45.12,65.32) ; VRAM7000.M3 43.94,86.1 v2(44.34,86.5) 44.74,86.9 VRAM7000.L2 ; v2(41.87,92.08) 41.96,92.08 VRAM7000.E5 ; VRAM7000.C10 v2(37.94,93.7)
  BOTTOM w0.305: v2(35.54,90.5) VRAM7000.G13 ; VRAM7001.G2 44.74,72.15 v2(44.35,72.54) 43.99,72.9 VRAM7001.F3 ; VRAM7000.E10 VRAM7000.D11 v2(37.14,92.9) VRAM7000.D12 ; v2(35.56,84.1) 35.54,84.1 VRAM7000.P14 ; VRAM7001.E5 v2(42.71,73.33) ; v2(46.05,94.22) 45.93,94.1 VRAM7000.B1 ; VRAM7000.M1 45.61,86.1 v2(46,86.49) 45.6,86.9 VRAM7000.L1 ; VRAM7001.D1 46.58,74.5 v2(46.66,74.42) ; VRAM7000.P1 v2(45.94,84.1) ; v2(35.54,74.9) 35.54,74.9 VRAM7001.D14 ; v2(41.56,75.67) 41.93,75.3 VRAM7001.C5 ; v2(34.77,92.87) VRAM7000.D14 v2(34.72,92.08) ; v2(37.14,84.14) 37.18,84.14 VRAM7000.P11 ; v2(35.57,86.5) 35.94,86.87 VRAM7000.L13 v2(36.34,87.3) 36.74,87.7 VRAM7000.K12 ; v2(35.57,86.5) 35.17,86.9 VRAM7000.L14 ; v2(35.57,86.5) 35.17,86.1 VRAM7000.M14 35.53,85.71 v2(35.59,85.71) ; v2(35.54,72.5) 35.14,72.1 VRAM7001.G14 ; VRAM7001.B1 45.67,76.23 v2(46.08,76.23) ; VRAM7001.L11 37.14,68.5 v2(37.14,68.45) 37.08,68.45 36.74,68.1 VRAM7001.M12 ; VRAM7001.M14 35.14,68.13 v2(35.51,68.5) 35.91,68.9 VRAM7001.L13 ; v2(45.93,92.83) 45.6,92.5 VRAM7000.D1 ; v2(37.94,84.09) 37.95,84.09 VRAM7000.R10 ; v2(36.35,69.37) 36.41,69.37 VRAM7001.K12 ; VRAM7001.G1 45.58,72.1 v2(46.05,72.57) 45.71,72.9 VRAM7001.F1 ; v2(43.52,92.89) 43.91,92.5 VRAM7000.D3 ; VRAM7001.R5 41.93,66.11 v2(41.46,66.11) ; VRAM7001.C10 38.39,75.3 v2(38.76,75.66) ; VRAM7000.T1 45.94,82.5 v2(45.94,82.5) ; v2(41.97,83.33) VRAM7000.R5 ; VRAM7000.G14 35.14,90.1 v2(34.75,90.5) ; v2(41.2,84.71) 41.75,84.71 VRAM7000.N5 ; v2(43.54,86.5) VRAM7000.L4 v2(43.54,87.3) 43.94,87.7 VRAM7000.K3 ; VRAM7001.F14 35.08,72.9 v2(34.73,73.25) ; v2(44.34,75.7) 43.94,76.1 VRAM7001.B3 ; VRAM7000.M12 36.81,86.1 37.14,86.43 v2(37.14,86.47) 37.18,86.47 37.54,86.83 VRAM7000.L11 ; v2(43.54,83.3) 43.94,82.9 VRAM7000.T3 ; v2(34.7,94.54) VRAM7000.B14 ; VRAM7001.G4 v2(43.54,71.7) 43.94,71.3 VRAM7001.H3 ; v2(38.73,84.94) 38.7,84.94 VRAM7000.N10 ; v2(41.46,66.85) 41.89,66.85 VRAM7001.N5 ; VRAM7001.E10 38.34,73.7 v2(37.94,74.1) ; VRAM7000.G11 v2(37.13,90.51) ; VRAM7000.F14 35.07,90.9 v2(34.66,91.31) ; VRAM7001.L14 35.03,68.9 v2(34.66,68.53) ; VRAM7000.P12 v2(37.14,84.9) ; VRAM7001.D11 37.54,74.5 v2(37.14,74.9) 36.74,74.5 VRAM7001.D12 ; v2(44.37,84.07) VRAM7000.P3 ; v2(36.35,90.51) VRAM7000.F12 ; VRAM7001.T12 v2(36.34,64.5)
  vias: v1(31.85,67.31) v1(31.85,66.67) v1(31.85,66.04) v1(31.85,65.4) v1(31.85,64.77) v1(31.85,64.13) v1(31.85,63.5) v1(32.48,67.31) v1(32.48,66.67) v1(32.48,66.04) v1(32.48,65.4) v1(32.48,64.77) v1(32.48,64.13) v1(32.48,63.5) v1(32.51,95.15) v1(32.61,96.09) v1(33.07,96.54) v1(32.99,95.58) v1(33.45,96.04) v1(33.45,94.66) v1(33.55,97.03) v1(33.96,96.54) v1(39.59,79.85) v1(41.25,80.01) v1(41.36,78.43) v1(49.27,96.54) v1(49.91,96.52) v2(34.25,81.77) v2(34.63,86.97) v2(36.39,82.53) v2(37.15,72.51) v2(37.15,66.1) v2(43.52,68.47)
FCCM: length 20
  TOP w0.203: PU8800.13 87.91,107.13 v1(87.98,107.2)
  IN3 w0.203: v1(103.71,109.55) 103.71,109.24 103.51,109.04 102.52,109.04 102.03,109.53 97.46,109.53 96.89,108.96 92.29,108.96 v1(91.85,109.4) 91.45,109 90.59,109 89.58,108 89.05,108 88.25,107.2 v1(87.98,107.2)
  BOTTOM w0.203: PR8910.1 104,109.25 v1(103.71,109.55) ; v1(91.85,109.4) 91.85,109.62 92.1,109.88 PR8903.1
FCCM_PH1: length 1.6
  BOTTOM w0.203: PU8900.1 93.26,108.72 92.55,109.43 PR8903.2
FCCM_PH2: length 1.3
  BOTTOM w0.203: PR8910.2 104.78,109.13 105.33,109.13 105.54,108.92 PU8901.1
FN_KEY_LED#: length 79.1
  TOP w0.076: v2(189.25,21.57) 189.39,21.43 190.13,21.43 190.73,20.83 191.54,20.83 191.8,20.57 U4700.A10
  TOP w0.109: v2(189.25,21.57) 189.25,21.67 188.92,22 R4807.1 ; v2(126.9,12.32) 126.72,12.14 126.72,10.4 C5034.2 126.81,9.85 126.94,9.85 R5004.1
  IN3 w0.089: v2(189.25,21.57) 188.78,22.04 187.47,22.04 187.17,22.1 187.03,22.16 185.96,23.23 184.69,23.23 184.61,23.14 184.45,23.14 183.2,21.88 183.2,21.27 181.6,19.67 180.7,19.67 179.81,18.78 179.81,17.9 178.15,16.25 173.76,16.25 172.5,17.51 168.16,17.51 167.98,17.33 165.89,17.33 165.26,16.7 164.82,16.7 164.29,16.18 163.93,16.18 162.87,15.12 160.89,15.12 160.58,14.81 160.58,14.37 160.2,13.99 157.33,13.99 156.87,13.54 156.87,13.32 156.59,13.04 153.55,13.04 153.1,13.49 148.25,13.49 147.92,13.82 144.84,13.82 144.16,13.15 143.01,13.15 142.89,13.27 140.9,13.27 140.66,13.03 138.23,13.03 137.98,12.78 136.41,12.78 135.61,13.59 134.4,13.59 133.65,12.84 133.65,12.79 133.19,12.33 129.38,12.33 129.14,12.09 127.12,12.09 v2(126.9,12.32)
FP_FUSE_SRC: length 18.5
  TOP w0.305: v2(74.04,70.24) 74.57,69.71 C6684.2 75.4,68.93 76.4,68.93 79.96,65.38 79.96,63.7 80.34,63.32 80.87,63.32 82.14,64.59 v1(82.14,64.69) 82.24,64.79 82.24,65.22 82.87,65.86 U7601.6 82.57,66.42 82.24,66.75 82.24,68.27 82.74,68.77 R6619.2
  BOTTOM w0.305: U6600.AB6 74.44,70.64 v2(74.04,70.24)
FPR_LOCK#: length 137.3
  IN2 w0.089: v2(157.09,9.01) 157.45,8.65 157.98,8.65 158.38,9.05 160.62,9.05 160.78,9.21 162.13,9.21 162.67,8.67 164.75,8.67 164.99,8.43 169.94,8.43 172.36,6.01 174.56,6.01 174.86,6.31 176.72,6.31 176.94,6.53 176.94,7.24 177.39,7.69 177.39,7.92 181.21,11.74 184.61,11.74 185.15,12.28 187.92,12.28 188.75,13.11 188.75,16.25 187.71,17.29 186.08,17.29 185.29,18.09 185.29,18.58 183.6,20.26 183.6,22.03 181.22,24.41 181.22,27.72 179.08,29.86 179.08,31.34 176.47,33.95 176.47,34.46 173.96,36.98 173.96,37.9 173.58,38.28 173.58,40 172.56,41.01 169.97,41.01 167.99,42.99 163.97,42.99 163.24,42.26 162.23,42.26 161.56,42.93 160.86,42.93 159.09,44.71 159.09,45.77 158.37,46.49 158.37,47.08 156.79,48.65 156.79,48.98 156.53,49.24 156.26,49.24 153.37,52.13 153.37,53.47 151.65,55.19 150.66,55.19 148.93,56.92 148.35,56.92 147.69,57.57 147.69,58.1 147.91,58.31 147.91,59.72 145.95,61.67 145.95,62.75 146.54,63.33 147.6,63.33 148.08,63.81 148.08,64.95 147.87,65.46 147.87,65.46 147.87,66.22 147.52,66.57 147.33,66.57 147.04,66.86 147.04,67.26 146.62,67.68 146.62,70.48 148.84,72.7 148.84,74.02 148.56,74.3 148.56,75.18 147.92,75.82 147.92,76.13 147.62,76.44 146.73,76.44 146.45,76.16 146.11,76.16 145.74,76.52 145.73,76.52 v2(145.73,76.52)
  BOTTOM w0.109: C5202.1 157.09,9.54 v2(157.09,9.01) ; C5202.1 157.5,9.95 157.5,10.77 157.55,10.82 R5202.2 ; C5202.1 157.46,9.41 157.46,8.82 157.29,8.65 CON5200.6 ; U400.DW21 145.14,77.09 145.17,77.09 v2(145.73,76.52)
FPR_OFF#: length 142
  IN2 w0.089: v2(142.89,75.11) 142.91,75.11 144.63,73.39 v2(147.03,73.39) 147.04,73.37 147.04,72.8 146.6,72.36 144.83,72.36 144.24,71.76 144.24,66.22 144.68,65.77 144.68,63.66 143.78,62.76 143.78,58.3 144.1,57.97 144.1,57.17 143.63,56.7 143.63,54.16 144.69,53.11 145.09,53.11 146.06,52.14 146.63,52.14 146.91,51.86 146.91,51.29 148.07,50.13 149.02,50.13 149.53,49.62 150.58,49.62 152.26,47.94 153.62,47.94 153.89,47.67 156.05,47.67 156.2,47.52 156.2,47.26 156,47.06 156,46.56 156.24,46.32 156.58,46.32 156.72,46.38 156.97,46.38 157.97,45.37 157.97,44.32 159.08,43.21 159.08,42.2 160.07,41.2 161.3,41.2 162,41.91 163.45,41.91 164.18,42.64 167.84,42.64 169.82,40.65 171.24,40.65 173.22,38.67 173.22,38.13 173.6,37.75 173.6,36.83 176.12,34.32 176.12,33.75 178.73,31.14 178.73,29.71 180.86,27.57 180.86,24.26 183.24,21.88 183.24,20.12 184.93,18.43 184.93,17.94 185.94,16.93 186.93,16.93 187.47,16.39 187.82,16.39 188.57,15.64 188.57,13.18 187.84,12.45 185.07,12.45 184.54,11.92 181.13,11.92 177.19,7.97 177.19,7.74 176.58,7.14 175.44,7.14 174.49,6.19 172.43,6.19 170.01,8.61 165.07,8.61 164.83,8.85 162.75,8.85 162.21,9.39 160.67,9.39 160.51,9.23 158.12,9.23 157.96,9.4 156.94,9.4 156.56,9.01 v2(156.36,9.01)
  BOTTOM w0.109: v2(156.36,9.01) 156.36,9.48 156.54,9.66 C5202.2 156.76,9.34 156.73,9.31 156.73,8.72 156.79,8.66 CON5200.7 ; U400.DR27 142.89,74.77 v2(142.89,75.11) ; v2(147.03,73.39) 147.03,73.47 147.6,74.04 148.94,74.04 R807.1

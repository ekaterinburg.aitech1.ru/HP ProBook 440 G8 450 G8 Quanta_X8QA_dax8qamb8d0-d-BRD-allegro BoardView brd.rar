# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FT_DIGITAL_CLK: length 186.8
  TOP w0.109: L3401.1 28.73,30.8 R1545.2 29.14,30.9 29.42,30.62 v1(29.42,30.12)
  IN1 w0.079: v1(156.37,48.85) 156.37,49.43 155.26,50.55 154.4,50.55 153.86,51.09 153.86,52.99 153.37,53.48 147.92,53.48 147.42,53.98 147.42,55.65 146.22,56.85 146.22,57.34 145.94,57.62 145.55,57.62 145.2,57.27 144.12,57.27 141.42,59.96 v2(141.42,61.39) ; v1(49.71,43.79) 49.71,43.86 49.48,44.09 47.42,44.09 46.43,43.1 45.02,43.1 44.88,42.97 38.62,42.97 37.92,42.27 35.44,42.27 34.83,42.88 30.89,42.88 30.7,42.69 30.14,42.69 29.77,43.06 29.42,43.06 29.02,42.66 29.02,42.43 27.58,40.99 26.4,40.99 25.97,41.42 25.49,41.42 24.87,40.8 v1(24.87,39.5)
  IN3 w0.089: v1(29.42,30.12) 26.24,30.12 25.52,30.84 25.52,36 24.87,36.65 v1(24.87,39.5)
  BOTTOM w0.109: v2(141.42,61.39) 141.63,61.59 141.63,62.44 U400.DL53 ; v1(49.71,43.79) 49.78,43.79 52.12,41.45 76.37,41.45 82.73,47.81 100.22,47.81 107.03,41 117.12,41 118.08,41.97 151.16,41.97 154.91,45.72 154.91,47.39 v1(156.37,48.85)
FT_DIGITAL_CLK_L: length 3.4
  TOP w0.109: v1(29.55,28.85) 29.33,28.85 28.89,28.4 C3410.1 28.7,28.81 28.73,28.83 L3401.2
  BOTTOM w0.109: v1(29.55,28.85) 29.35,28.85 28.95,29.25 CON3400.8
FT_DIGITAL_D1: length 186.9
  TOP w0.109: Q3406.3 27.93,24.33 28.67,25.07 28.67,25.42 28.55,25.55 R3435.2 28.55,25.97 v1(29.48,26.91)
  IN1 w0.079: v1(144.48,56.75) 145.39,55.84 145.39,55.29 145.59,55.09 146.5,55.09 147.01,54.57 147.01,53.92 147.79,53.14 153.19,53.14 153.53,52.8 153.53,50.95 154.27,50.21 154.84,50.21 155.06,49.99 155.06,49.3 v1(155.2,49.17) ; v1(25.55,40.38) 25.84,40.66 27.72,40.66 27.9,40.84 29.89,40.84 31.6,42.55 34.7,42.55 35.3,41.94 38.17,41.94 38.85,42.62 46.42,42.62 47.05,43.25 49.7,43.25 50.59,44.14 v1(51.1,44.14)
  IN2 w0.089: v1(25.55,40.38) 27,38.94 27.29,38.94 28.44,37.79 28.44,27.95 v1(29.48,26.91)
  BOTTOM w0.109: v1(51.1,44.14) 51.79,44.83 60.35,44.83 61.52,43.66 77.41,43.66 82.39,48.64 100.56,48.64 107.62,41.58 116.53,41.58 117.74,42.8 150.1,42.8 154.09,46.78 154.09,47.76 155.2,48.88 v1(155.2,49.17) ; U400.DG51 139.29,63.4 139.29,62.58 139.09,62.37 139.09,61.56 139.63,61.02 139.63,60.72 141.88,58.47 141.88,57.4 142.38,56.9 144.33,56.9 v1(144.48,56.75)
FT_DIGITAL_D1_L: length 4.8
  TOP w0.109: L3402.2 30.22,26.19 30.33,26.3 C3416.1 v1(29.52,27.53)
  BOTTOM w0.109: CON3400.7 28.98,28.75 29.16,28.57 29.16,27.89 v1(29.52,27.53)
GC6_FB_EN: length 59.6
  TOP w0.109: v1(85.94,97.08) 85.78,97.08 85.18,97.68 84.26,97.68 83.35,98.59 80.73,98.59 80.35,98.97 R6962.1 79.9,98.32 78.98,97.39 v1(78.98,96.75) 78.98,96.28 78.69,95.98 78.69,95.35 78.33,94.99 78.33,93.88 77.95,93.5 77.95,93.11 78.34,92.72 78.34,90.55 78.73,90.17 78.73,88.66 v1(79.12,88.26)
  IN2 w0.089: v1(85.94,97.08) 87.05,95.97 87.05,92.46 87.53,91.98 87.53,84.94 v1(86.28,83.69) 86.28,82.93 85.9,82.55 85.9,80.02 84.62,78.74 84.62,74.88 79.96,70.22 v1(79.96,69.73)
  BOTTOM w0.109: U6701.1 85.26,96.39 v1(85.94,97.08) ; Q6903.2 87.58,83.46 87.35,83.69 v1(86.28,83.69) ; v1(79.96,69.73) 81.29,71.07 83.28,71.07 83.5,71.28 Q6901.2
  BOTTOM w0.127: v1(79.12,88.26) 78.7,87.85 78.21,87.85 77.74,87.38 U6600.B2
GC6_FB_EN_Q: length 67.6
  TOP w0.109: v2(98.61,71.57) 98.61,70.34 98.04,69.77 v1(92.17,69.77) 91.8,69.77 91.08,70.48 91.08,71.55 90.34,72.29 v1(90.34,72.74) ; R1413.1 139.56,74.64 v2(139.94,75.02)
  IN1 w0.079: v1(134.08,73.69) 134.4,73.37 139.31,73.37 139.94,74 v2(139.94,75.02)
  IN3 w0.089: v1(134.08,73.69) 133.62,73.22 132.15,73.22 128.99,76.37 115.36,76.37 114.46,75.47 107.31,75.47 106.84,75 102.77,75 101.87,74.1 101.87,72.89 100.56,71.57 v2(98.61,71.57)
  BOTTOM w0.109: U400.DJ25 139.94,75.27 v2(139.94,75.02) ; Q6901.3 85.43,71.8 85.54,71.69 R6943.1 87.27,71.69 87.54,71.42 88.03,71.42 88.28,71.17 88.8,71.17 90.34,72.71 v1(90.34,72.74)
GPD7: length 11.7
  TOP w0.109: v2(142.65,67.77) 142.91,67.77 145.89,64.79 146.63,64.79 147.11,65.26 149.51,65.26 149.91,64.87 v2(150.66,64.87)
  BOTTOM w0.109: v2(150.66,64.87) 151.07,65.29 R1214.2 R1219.1 ; v2(142.65,67.77) 142.62,67.74 142.53,67.74 U400.DN43
GPIO10_VREF: length 109.6
  TOP w0.109: v1(78.66,100.84) 78.66,100.38 78.97,100.07 R6964.2 79.27,98.53 v1(79.12,98.37) 78.92,98.17 78.92,97.86 78.46,97.41 78.46,95.45 78.1,95.1 78.1,93.98 77.72,93.6 77.72,93.02 78.12,92.62 78.12,90.62 v1(77.4,89.91) ; v1(28.81,100.24) 29.72,99.34 29.72,98.85 30.16,98.41 Q7000.2
  IN3 w0.089: v1(29.06,69.9) 29.06,71.04 27.24,72.86 27.24,75.11 27.03,75.31 27.03,75.88 23.75,79.16 23.75,85.21 24.05,85.52 24.05,86.69 25.27,87.91 25.27,89 26.39,90.12 26.39,91.09 26.76,91.46 26.76,92.93 27.02,93.19 27.02,95.37 28.12,96.47 28.12,99.51 28.32,99.72 28.32,99.75 v1(28.81,100.24) 29.03,100.46 29.03,101.09 30.25,102.31 31.97,102.31 33.42,100.86 41.12,100.86 41.91,100.07 46.53,100.07 49.08,102.61 56.11,102.61 57.27,101.45 78.05,101.45 v1(78.66,100.84)
  BOTTOM w0.109: v1(29.06,69.9) 29.5,69.46 Q7001.2 ; v1(77.4,89.91) 77.2,89.91 75.5,88.21 75.5,87.51 75.72,87.3 75.72,86.92 75.29,86.49 U6600.C5
GPIO18_FP_FUSE: length 26.3
  TOP w0.109: U7601.4 85.47,67.96 84.53,68.91 R6618.2 84.53,69.29 v1(83.72,70.1) 83.51,70.3 82.75,70.3 80.85,72.21 v1(80.72,72.21)
  BOTTOM w0.109: U6600.C2 77.56,86.4 77.16,86 76.81,86 76.55,85.75 76.55,85.37 76.32,85.14 75.92,85.14 75.69,84.91 75.69,84.58 75.92,84.35 77.19,84.35 77.37,84.17 77.37,83.74 77.59,83.51 78.66,83.51 78.99,83.18 78.99,82.9 79.63,82.27 79.63,77.39 81.05,75.97 81.05,73.43 80.72,73.1 v1(80.72,72.21)
GPIO40: length 2.9
  TOP w0.076: v2(194.79,16.99) U4700.E5
  BOTTOM w0.076: v2(194.79,16.99) 195.07,16.71 195.07,16.18 195.25,16 196.01,16 TP4800.1
GPP_B18: length 9.7
  TOP w0.109: v2(137.11,65.22) 137.34,65.45 138.34,65.45 138.49,65.3 138.49,64.72 138.87,64.34 138.87,63.62 138.24,62.99 138.24,59.73 R1220.2
  BOTTOM w0.079: v2(137.11,65.22) 136.61,64.72 136.61,63.89 U400.DA51
GPP_B23: length 7.6
  BOTTOM w0.079: 137.13,59.83 137.13,59.99 136.96,60.16 136.96,61.97 136.58,62.36 136.58,62.8 136.41,62.96 136.17,62.96 136.09,63.04 136.09,63.72 U400.CY50
  BOTTOM w0.109: 137.13,59.83 R1228.1 137.29,59.71 137.51,59.48 137.51,59.05 137.34,58.87 R1223.2 137.3,58.7 136.9,58.35 v1(136.9,57.58)
GPP_RCOMP: length 7
  TOP w0.109: R800.1 145.08,57.83 144.65,58.27 144.65,58.81 143.96,59.5 143.96,62.49 143.25,63.21 v2(143.03,63.21)
  BOTTOM w0.109: U400.DR51 143.13,63.34 143.03,63.24 v2(143.03,63.21)
GPPC_E6: length 14.6
  TOP w0.109: v2(146.28,83.34) 146.28,83.46 147.17,84.36 147.17,85.14 147.38,85.34 147.75,85.34 147.93,85.16 147.93,83.95 148.52,83.36 150.28,83.36 150.59,83.05 152.53,83.05 152.93,82.65 R1230.1 R1231.1 R1233.1
  BOTTOM w0.109: U400.DT8 143.47,83.09 143.68,82.88 145.46,82.88 145.92,83.34 v2(146.28,83.34)
GPS_XMIT_OFF#: length 152.7
  TOP w0.109: v2(137.77,67.95) 138.25,67.47 138.25,66.8 138.3,66.67 138.3,65.86 138.73,65.43 138.73,64.8 139.1,64.43 139.1,63.53 138.49,62.92 138.49,60.41 v1(138.66,60.25) 138.49,60.08 138.49,58.69 R627.1
  IN1 w0.079: v1(198.12,2.94) 198.55,2.51 205.58,2.51 206.2,3.12 206.2,3.53 207.02,4.35 207.02,4.89 209.01,6.88 209.01,9.5 208.52,9.99 208.52,21.87 207.1,23.28 206.08,23.28 205.43,23.92 205.43,24.1 203.83,25.7 203.7,25.7 202.69,26.71 202.11,26.71 201.69,26.89 201.4,27.18 201.02,27.18 199.53,28.68 197.89,28.68 197,29.05 196.26,29.05 196.18,29.13 193.7,29.13 192.92,29.91 192.51,29.91 190.38,32.04 190.38,34.17 189.31,35.24 189.31,37.68 188.55,38.44 188.55,40.88 189.61,41.93 189.61,44.55 188.98,45.18 187.62,45.18 186.66,46.14 185.95,46.14 185.23,46.86 185.23,47.45 184.67,48 183.93,48 183.54,48.39 183.54,48.88 183.41,49.01 183.12,49.01 183.09,49.04 179.86,49.04 178.76,50.14 177.59,50.14 176.75,50.98 176.14,50.98 175.5,51.62 174.48,51.62 174.23,51.38 172.6,51.38 171.7,50.48 168.93,50.48 168.32,49.88 166.39,49.88 166.22,49.7 165.31,49.7 164.28,48.67 163.88,48.67 163.34,48.14 162.94,48.14 161.17,46.36 161.17,46.02 160.83,45.68 159.6,45.68 159.15,45.24 157.01,45.24 156.7,44.92 154.75,44.92 153.56,46.11 152.98,46.11 151.49,47.59 150.56,47.59 149.64,48.52 149.64,49 149.09,49.55 147.97,49.55 147.23,50.29 146.87,50.29 142.4,54.76 142.4,55.87 141.4,56.87 140.88,56.87 140.38,57.37 140.38,57.99 140.21,58.16 140.21,63.01 139.22,64 139.22,64.49 138.23,65.48 137.93,65.48 137.42,65.99 137.42,66.86 137.3,66.98 137.3,67.48 v2(137.77,67.95)
  BOTTOM w0.109: CON4202.26 196.16,2.11 196.28,2.28 196.59,2.54 196.66,2.57 197.04,2.94 v1(198.12,2.94) ; U400.DB42 137.43,67.61 v2(137.77,67.95)
GPU_BST1:
  vias: v1(78.05,106.2)
GPU_CS1: length 58.4
  TOP w0.178: PU9800.16 37.09,102.7 v1(37.46,102.33)
  TOP w0.203: PR9822.2 37.16,102.16 37.34,102.33 v1(37.46,102.33)
  IN3 w0.254: v1(79.86,109.85) 79.86,107.69 79.58,107.41 79.58,104.01 77.82,102.26 57.94,102.26 55.83,104.37 55.83,105.03 54.48,106.37 54.02,106.37 53.76,106.11 53.76,105.52 53.54,105.31 50.16,105.31 46.67,101.81 42.88,101.81 42.3,102.39 41.15,102.39 40.61,101.85 37.95,101.85 v1(37.46,102.33)
  BOTTOM w0.203: v1(79.86,109.85) 79.86,109.32 79.27,108.74 78.84,108.74 78.76,108.66 PU9900.18
GPU_CS2: length 25.5
  TOP w0.178: PU9800.15 36.09,102.05 36.19,102.16 v1(36.4,102.16)
  TOP w0.203: PR9823.2 36.75,100.81 v1(36.5,101.06) 36.5,102.06 v1(36.4,102.16)
  IN3 w0.254: v1(36.4,102.16) 37.06,101.5 40.76,101.5 41.3,102.03 41.93,102.03 42.5,101.47 46.81,101.47 50.14,104.8 53.74,104.8 54.23,105.28 v1(54.23,105.89)
  BOTTOM w0.203: v1(54.23,105.89) 54.23,105.86 54.15,105.79 54.15,104.42 54.3,104.26 PU9901.18
GPU_EVENT#: length 104.7
  TOP w0.109: R1119.2 151.51,81.68 150.61,81.68 150.36,81.93 150.36,82.2 149.93,82.62 147.07,82.62 146.81,82.88 144.09,82.88 143.84,82.62 142.41,82.62 142.23,82.81 141.92,82.81 141.42,83.31 v2(141.41,83.31)
  IN1 w0.079: v1(133.66,101.13) 133.5,100.97 131.76,100.97 127.38,96.59 121.06,96.59 119.84,95.37 119.84,94.57 118.46,93.19 118.46,92.33 117.42,91.28 115.55,91.28 114.88,91.95 114.3,91.95 113.57,91.22 112.94,91.22 111.99,92.17 106.86,92.17 106.53,91.84 106.53,91.26 106.25,90.98 103.97,90.98 103.71,91.24 103.26,91.24 102.7,90.68 96.81,90.68 95.7,91.78 91.4,91.78 90.05,93.14 90.05,95.82 88.99,96.89 87.97,96.89 87.15,97.71 87.03,97.71 85.61,99.13 84.55,99.13 v1(83.06,97.64)
  IN2 w0.089: v1(133.66,101.13) 133.68,101.11 133.68,99.74 134.35,99.07 135.54,99.07 136.05,98.56 136.05,96.66 137.01,95.7 137.01,93.24 137.8,92.45 138.38,92.45 138.77,92.07 141.71,92.07 142.34,91.43 142.34,90.61 142.76,90.2 144.9,90.2 145.01,90.09 145.01,88.14 141.31,84.44 141.31,83.44 141.42,83.34 141.42,83.32 v2(141.41,83.31)
  BOTTOM w0.109: U400.DK6 141.31,83.33 141.4,83.33 141.41,83.32 v2(141.41,83.31) ; v1(83.06,97.64) D6900.1
GPU_EVENT#_GPU: length 27.4
  TOP w0.109: v1(83.7,86.89) 80.33,86.89 79.65,87.56 76.66,87.56 75.09,85.99 v2(74.83,85.99)
  IN3 w0.089: v1(83.7,86.89) 83.89,87.09 83.89,88.61 85.72,90.44 86.22,91.64 86.22,93.58 83.56,96.24 82.42,96.24 v1(81.29,97.37)
  BOTTOM w0.109: v1(81.29,97.37) 81.29,96.81 D6900.2 ; U6600.D6 v2(74.83,85.99) ; R6956.1 84.84,87.32 84.45,86.93 84.02,86.93 83.98,86.89 v1(83.7,86.89)
GPU_PWM1: length 47.4
  TOP w0.203: PR9814.1 v1(39.04,105.15)
  IN1 w0.254: v1(78.36,110.39) 78.2,110.54 78.2,111.45 77.8,111.86 74.65,111.86 71.68,108.89 68.3,108.89 64.79,105.38 54.86,105.38 54.51,105.03 49.93,105.03 47.09,102.18 42.91,102.18 41.16,103.94 38.83,103.94 38.56,104.21 38.56,104.67 v1(39.04,105.15)
GPU_PWM2: length 15.9
  TOP w0.203: PR9816.1 v1(39.04,104.42)
  IN1 w0.254: v1(52.02,105.89) 51.74,105.61 49.78,105.61 46.76,102.59 43.03,102.59 40.84,104.77 39.39,104.77 v1(39.04,104.42)
GPU_SYNC: length 52.5
  TOP w0.254: v1(43.71,100.63) 43.76,100.58 47.17,100.58 49.65,103.07 49.65,103.76 49.86,103.96 49.86,104.7 50.52,105.36 52.19,105.36 52.65,105.81 v1(52.65,105.89)
  IN1 w0.203: v1(79.22,109.85) 79.22,110.44 79.32,110.54 79.32,111.22 78.23,112.32 74.39,112.32 71.5,109.42 68.04,109.42 64.49,105.86 55.14,105.86 54.53,106.47 52.91,106.47 52.65,106.22 v1(52.65,105.89)
  BOTTOM w0.203: v1(79.22,109.85) 79.04,109.85 78.66,109.47 78.63,109.46 PU9900.16 ; PR9832.2 39.83,99.97 39.99,99.8 41,99.8 41.32,100.12 PR9831.2 41.42,100.31 PR9830.1 v1(43,100.31) 43.38,100.31 v1(43.71,100.63) ; PU9901.16 53.5,104.89 52.65,105.74 v1(52.65,105.89)
GPU_TEMP: length 65.5
  TOP w0.203: v1(30.4,104.16) 30.5,104.06 31.09,104.06 31.29,103.86 PR9820.1
  IN3 w0.254: 53.29,105.92 52.71,106.5 50.54,106.5 46.43,102.39 43.3,102.39 42.77,102.92 40.94,102.92 40.28,102.26 38.4,102.26 37.69,102.97 36.37,102.97 35.72,102.32 33.51,102.32 31.67,104.16 v1(30.4,104.16) ; 53.29,105.92 53.29,106.35 53.82,106.88 54.68,106.88 56.34,105.23 56.34,104.57 58.21,102.69 77.49,102.69 78.53,103.73 78.53,108.68 v1(79.07,109.21) ; 53.29,105.92 v1(53.29,105.89)
  BOTTOM w0.203: v1(53.29,105.89) 53.82,105.36 53.82,104.29 53.9,104.21 PU9901.17 ; PU9900.17 78.91,109.06 v1(79.07,109.21)
GPU_VCC_SENSE: length 79.4
  TOP w0.203: PR9815.1 31.04,100.91 v1(31.07,100.95) 31.23,100.95 31.47,100.71 v1(31.79,100.71) 31.79,100.92 31.52,101.19 PR9813.2
  IN1 w0.203: v1(80.88,99.11) 81.89,98.1 81.89,96.75 82.78,95.86 84.49,95.86 86.34,94.02 86.34,90.78 84.33,88.77 82.89,88.77 79.86,85.74 79.86,84.2 v1(79.45,83.79)
  IN3 w0.203: v1(80.88,99.11) 79.94,99.11 78.88,98.05 60.64,98.05 60.58,98.12 57.22,98.12 56.26,97.16 54.37,97.16 53.97,97.57 50.75,97.57 50.32,98 39.86,98 39.01,98.85 32.18,98.85 31.07,99.96 v1(31.07,100.95)
  BOTTOM w0.203: U6600.F2 77.96,83.9 78.36,84.3 78.76,84.3 79.27,83.79 v1(79.45,83.79)
GPU_VID: length 77.9
  TOP w0.109: v1(78.03,100.84) 78.03,100.53 78.97,99.59 78.97,98.91 78.7,98.64 78.7,98.11 78.2,97.61 78.2,95.53 77.17,94.49 77.17,93.88 77.49,93.56 77.49,92.93 77.88,92.54 77.88,91.03 76.96,90.11 76.96,89.74 77.21,89.48 77.83,89.48 v1(78.27,89.92) ; v1(30.25,101.72) 29.56,102.41 v1(29.56,103.27) 29.56,104.82 30.53,105.79 31.14,105.79 PR9804.1
  IN3 w0.089: v1(30.25,101.72) 30.66,102.13 31.9,102.13 33.35,100.68 41.04,100.68 41.84,99.89 46.63,99.89 49.1,102.36 51.64,102.36 52.22,101.78 56.54,101.78 57.05,101.27 77.59,101.27 v1(78.03,100.84)
  BOTTOM w0.109: v1(78.27,89.92) 77.86,90.34 77.17,90.34 74.83,87.99 74.83,87.75 74.69,87.61 74.28,87.61 74.04,87.38 74.04,86.8 U6600.C6
GPU_VSS_SENSE: length 80.6
  TOP w0.203: PR9811.2 31.5,102.16 31.07,101.72 v1(31.04,101.72) 30.58,101.27 30.58,101.22 v1(30.45,101.09) 30.45,100.66 30.33,100.53 PR9809.1
  IN1 w0.203: v1(81.59,99.17) 82.35,98.42 82.35,96.94 82.97,96.32 84.68,96.32 86.8,94.2 86.8,90.59 84.52,88.31 83.08,88.31 80.31,85.55 80.31,83.97 79.45,83.11 v1(79.42,83.11)
  IN3 w0.203: v1(81.59,99.17) 81.11,99.65 79.66,99.65 78.59,98.58 56.94,98.58 55.98,97.61 54.56,97.61 54.15,98.02 50.94,98.02 50.51,98.46 40.22,98.46 39.37,99.31 32.38,99.31 31.62,100.07 31.62,101.14 v1(31.04,101.72)
  BOTTOM w0.203: v1(79.42,83.11) 79.42,83.16 78.68,83.9 U6600.F1
GPUT_CLK_L: length 13.6
  TOP w0.109: v2(72.36,86) 72.36,87.22 76.48,91.34 76.48,91.76 v1(76.93,92.22)
  BOTTOM w0.109: Q6900.4 78.47,95.19 79.07,94.59 v1(79.07,94.54) 79.07,93.11 78.51,92.56 R6927.2 77.28,92.56 v1(76.93,92.22) ; v2(72.36,86) U6600.D9
GPUT_DATA_L: length 10.3
  TOP w0.109: v1(76.96,91.59) 76.96,91.29 73.2,87.53 v2(73.2,86.03)
  BOTTOM w0.109: U6600.D8 72.8,85.63 v2(73.2,86.03) ; v1(76.96,91.59) 76.48,92.07 76.48,92.43 76.6,92.55 R6923.2 76.6,93.75 Q6900.1
H_CATERR#: length 3.8
  TOP w0.109: R600.1 106.5,80.94 106.5,82.83 106.33,83 106.33,83.62 v2(106.03,83.92)
  BOTTOM w0.109: U400.M7 105.81,83.69 v2(106.03,83.92)
H_VCCST_PWRGD: length 2.6
  TOP w0.109: R1566.2 123.94,81.94 123.94,82.95 v2(124.33,83.34)
  BOTTOM w0.109: v2(124.33,83.34) 124.63,83.04 U400.BP8
H_VCCST_PWRGD_R: length 43.1
  TOP w0.109: R1566.1 124.36,81.17 124.57,81.39 124.86,81.39 125.08,81.17 R1561.2 125.43,81.17 125.85,81.59 126.46,81.59 C1503.2 126.53,81.3 v2(126.95,80.88)
  IN3 w0.089: v2(155.94,73.43) 155.58,73.79 154.65,73.79 153.85,72.99 151.95,72.99 151.79,73.15 150.8,73.15 149.63,74.32 147.06,74.32 146.96,74.42 146.1,74.42 146,74.32 145.19,74.32 145.11,74.4 143.29,74.4 142.7,73.81 141.45,73.81 141.4,73.76 139.09,73.76 138.81,74.04 138.22,74.04 137.84,74.42 136.47,74.42 136.22,74.17 135.08,74.17 134.34,74.9 132.52,74.9 129.77,77.66 129.77,78.57 129.09,79.25 127.15,79.25 126.95,79.45 v2(126.95,80.88)
  BOTTOM w0.109: D1500.2 156.16,76.2 156.56,75.79 v1(156.56,74.98) 156.56,74.37 155.94,73.75 v2(155.94,73.43)
HD_SDIN0: length 2.4
  TOP w0.109: U3600.7 192.02,37.32 191.99,37.36 191.6,37.36 191.36,37.26 190.87,36.77 R3614.2
HDMI_HPD: length 22.3
  TOP w0.109: v1(203.93,44.96) 203.84,44.86 VC3500.1 203.49,44.32 C3504.1 204.39,44.32 204.82,44.75 205.03,44.75 206.02,45.74 v1(206.02,46.12) 206.74,46.85 206.74,47.04 CON3501.19 ; v1(202.34,58.17) U3501.25
  BOTTOM w0.109: v1(202.34,58.17) 202.34,55.94 203.25,55.03 203.25,52.37 204.04,51.58 204.04,48.33 203.93,48.23 v1(203.93,44.96)
HDMI_HPD_CON: length 89.6
  TOP w0.109: v1(197.79,58.17) U3501.3 ; v2(139.63,66.93) 139.95,66.62 139.95,64.14 141.96,62.12 141.96,62.04 142.67,61.33 142.67,60.86 142.09,60.28 142.09,59.29 141.76,58.96 141.76,58.13 141.98,57.9 141.98,57.43 142.89,56.53 143.15,56.53 143.43,56.24 R404.1 142.93,55.93 v1(142.85,55.85)
  IN1 w0.079: v1(155.59,46.54) 155.59,46.58 156.28,47.27 157.25,47.27 157.67,47.68 158.88,47.68 159.71,48.51 159.71,49.26 160.21,49.76 160.83,49.76 162.24,51.16 162.24,52.01 164.46,54.23 171.9,54.23 172.22,54.56 174,54.56 174.29,54.85 175.91,54.85 176.92,55.87 178.76,55.87 178.88,55.98 179.94,55.98 180.05,55.87 183.03,55.87 183.35,56.19 183.35,56.9 182.62,57.64 182.09,57.64 181.57,58.17 181.57,59.07 181.77,59.27 182.64,59.27 185.54,62.18 189.76,62.18 192.68,59.26 196.71,59.26 v1(197.79,58.17)
  IN3 w0.089: v1(142.85,55.85) 142.47,55.48 142.47,53.84 148.12,48.19 152.99,48.19 154.63,46.54 v1(155.59,46.54)
  BOTTOM w0.109: v2(139.63,66.93) 139.63,66.97 139.57,67.03 U400.DG43
HDMI_UP_CLK: length 22.5
  TOP w0.109: U3501.28 200.86,60.34 200.96,60.44 201.11,60.44 v1(201.44,60.12) ; v1(204.39,47.75) 204.3,47.75 203.54,48.52 C3527.1 203.88,48.59 204.11,48.36 R3509.2
  BOTTOM w0.109: v1(201.44,60.12) 201.82,60.12 202.49,59.45 202.49,58.85 202.97,58.37 202.97,56.19 204,55.16 v1(204,53.67) 204,52.51 204.67,51.84 204.67,48.03 v1(204.39,47.75) 204.82,47.32 206.3,47.32 206.65,47.67 206.65,48.95 CON3501.15
HDMI_UP_DATA: length 16.8
  TOP w0.109: U3501.29 200.46,60.3 201.04,60.88 v1(201.45,60.88) ; CON3501.16 205.35,49.9 R3514.2 204.35,49.97 C3526.1 205.03,50.66 v1(205.19,50.82)
  BOTTOM w0.109: v1(205.19,50.82) 205.19,52.04 204.49,52.73 204.49,55.8 203.54,56.76 v1(203.54,56.79) 203.54,58.5 202.98,59.05 202.98,59.66 201.99,60.65 201.67,60.65 v1(201.45,60.88)
HOLD#_7: length 4.7
  TOP w0.109: U6801.7 65.48,96.47 TP6809.1 65.83,97.13 R6841.2
HOOK2: length 19.4
  TOP w0.109: CON7703.45 48.53,50.48 49.58,51.53 50.96,51.53 v1(51.57,50.92) ; v1(54.81,49.43) 54.81,44.57 v1(54.28,44.04) 52.19,41.96 51.6,41.96 R7710.2 R7703.1
  BOTTOM w0.109: v1(54.81,49.43) 54.47,49.43 54.02,49.88 53.46,49.88 52.83,50.52 51.97,50.52 v1(51.57,50.92)
HOOK3: length 163.6
  TOP w0.109: CON7703.47 48.54,50.98 48.92,51.36 v1(48.92,51.51) ; v1(163.02,75.15) 163.03,75.15 163.03,75.14 163.19,74.98 C5606.2 163.69,75.57 163.37,75.89 R5636.2 163.32,76.27 162.92,75.87 R5635.2
  IN2 w0.089: v1(163.02,75.15) 163.03,75.15 163.03,75.14 162.85,74.97 162.85,73.9 162.25,73.3 162.25,70.9 163.18,69.98 163.18,68.17 162.95,67.94 162.95,65.14 163.52,64.56 164.21,64.56 164.59,64.18 164.59,61.79 164.23,61.43 164.23,58.94 164.82,58.34 164.82,56.97 164.65,56.79 164.65,55.9 v1(164.69,55.85)
  BOTTOM w0.109: v1(48.92,51.51) 48.59,51.19 48.59,45.48 49.53,44.55 50.04,44.55 51.26,43.33 51.56,43.33 52.58,44.35 60.37,44.35 61.52,43.2 77.6,43.2 82.58,48.18 100.37,48.18 107.19,41.37 116.96,41.37 117.93,42.34 150.29,42.34 154.54,46.59 154.54,47.62 156.19,49.27 157.2,49.27 157.52,49.59 158.97,49.59 159.93,50.55 161.07,50.55 161.61,51.09 161.61,52.61 164.69,55.69 v1(164.69,55.85)
HPOUT_JD: length 18.2
  TOP w0.254: R3609.2 194.7,33.15 195.08,32.77 v1(195.21,32.77) ; v1(201.17,32.43) 201.39,32.21 D3701.1 202.05,32.47 v1(202.61,32.47) 202.61,31.34 204.53,29.42 207.94,29.42 CON3700.6
  IN3 w0.254: v1(195.21,32.77) 195.29,32.77 196.17,33.65 198.78,33.65 199.67,32.76 200.84,32.76 v1(201.17,32.43)
HPOUT_L: length 1
  TOP w0.305: R3701.2 200.51,36.79 R3602.1
HPOUT_L_C: length 14.1
  TOP w0.254: v1(201.85,35.25) 201.85,35.23 202,35.08 C3702.2 202.46,35.41 201.86,36.01 R3701.1 ; v1(203.95,41.19) 204.06,41.31 204.06,41.93 D3700.2 204.72,42.13 v1(204.72,41.37) 204.72,41 205.62,40.11 CON3700.1
  IN1 w0.254: v1(201.85,35.25) 201.85,35.26 201.85,37.77 202.11,38.04 202.11,38.04 203.13,39.06 203.13,40.38 v1(203.95,41.19)
HPOUT_L_L: length 2.5
  TOP w0.203: U3600.25 198.45,37.72 198.5,37.67 199.28,37.67 199.61,37.34 R3602.2
HPOUT_R: length 1
  TOP w0.254: R3601.1 R3702.2
HPOUT_R_C: length 21.7
  TOP w0.254: R3702.1 202.52,37.37 C3700.2 203.21,36.97 v1(203.21,37.62)
  IN1 w0.254: v1(203.21,37.62) 203.41,37.43 203.41,32.9 202.77,32.26 202.77,31.1 204.72,29.16 211.14,29.16 v1(211.6,28.7)
  BOTTOM w0.254: v1(211.6,28.7) D3702.1 212.24,28.87 212.24,30.24 CON3700.2
HPOUT_R_R: length 2.3
  TOP w0.178: 198.48,38.12 U3600.26
  TOP w0.203: 198.48,38.12 198.5,38.1 199.73,38.1 R3601.2
I2C_CLICK_SCL: length 9.8
  TOP w0.109: R5208.1 40.79,6.04 40.77,6.02 C5206.1 40.77,5.42 40.46,5.11 v1(40.46,4.85)
  BOTTOM w0.109: CON5202.7 36.69,5.93 36.37,5.61 35.81,5.61 35.41,5.21 35.41,4.64 35.88,4.16 39.77,4.16 v1(40.46,4.85)
I2C_CLICK_SDA: length 9
  TOP w0.109: v1(39.76,4.86) 39.83,4.93 C5208.1 39.05,6.29 R5211.1
  BOTTOM w0.109: CON5202.6 37.19,5.95 36.92,5.67 36.76,5.67 36.42,5.33 35.89,5.33 35.66,5.1 35.66,4.72 35.99,4.39 39.29,4.39 v1(39.76,4.86)
I2C_INT_M2: length 12.7
  IN1 w0.079: v1(199.24,5.69) 199.24,7.16 v1(199.41,7.34)
  BOTTOM w0.109: v1(199.41,7.34) 199.41,7.52 198.27,8.66 198.27,9.17 198.42,9.32 198.42,9.57 198.96,10.11 198.96,10.5 198.56,10.89 R4233.2 ; CON4202.28 195.67,2.35 195.78,2.46 196.57,2.79 197.62,3.83 198.52,3.83 199.08,4.39 199.08,5.1 199.24,5.26 v1(199.24,5.69)
I2C_SCL_M2: length 28.6
  IN1 w0.079: v2(203.34,18.21) 203.55,18.21 203.73,18.03 203.73,17.44 203.52,17.23 203.52,15.75 203.23,15.47 202.99,15.47 202.36,14.84 202.36,13.59 202.64,13.31 202.64,10.8 203.37,10.07 203.37,6.33 v1(204.04,5.66)
  BOTTOM w0.109: v1(204.04,5.66) 203.86,5.48 201.17,5.48 198.78,3.1 198.78,2.64 198.42,2.28 197.84,2.28 197.67,2.11 CON4202.20 ; v2(203.34,18.21) 203.12,18.21 202.11,19.23 201.75,19.23 201.44,19.1 200.28,19.1 200.05,18.87 199.51,18.87 v1(199.2,18.56) 198.96,18.31 R4231.2
I2C_SDA_M2: length 31.6
  IN1 w0.079: v2(203.34,19.07) 203.73,19.07 203.91,18.9 203.91,17.37 203.68,17.14 203.68,15.69 203.3,15.31 203.05,15.31 202.52,14.77 202.52,13.65 202.79,13.38 202.79,10.87 203.53,10.13 203.53,6.55 204,6.08 204.25,6.08 v1(204.67,5.66)
  BOTTOM w0.109: CON4202.24 196.67,2.2 196.99,2.53 198.36,2.53 198.55,2.72 198.55,3.25 201,5.7 203.47,5.7 203.84,6.08 204.25,6.08 v1(204.67,5.66) ; v2(203.34,19.07) 203.09,19.07 202.71,19.45 v1(202.64,19.45) 201.76,19.45 201.45,19.33 200.18,19.33 199.95,19.1 198.8,19.1 198.73,19.02 R4232.2
I2C_TS_SCL: length 195.5
  IN2 w0.089: v2(140.58,76.04) 140.18,75.64 139.15,75.64 138.83,75.32 138.83,73.21 138.28,72.65 138.28,71.12 138.05,70.89 137.74,70.89 137.34,70.48 137.34,65.53 137.54,65.33 137.54,64.54 138.9,63.17 138.9,55.53 146.07,48.36 146.71,48.36 149.72,45.36 152.13,45.36 156.71,40.77 159.34,40.77 160.23,39.88 v1(160.63,39.88)
  BOTTOM w0.109: U400.DJ23 140.22,76.4 v2(140.58,76.04) ; CON3400.21 29.37,35.75 29.94,36.31 29.94,37.29 30.16,37.51 30.92,37.51 31.67,38.26 R3403.2 32.8,38.26 33.64,37.42 33.64,35.59 34.89,34.34 35.64,34.34 38.08,31.9 102.75,31.9 103.65,31 119.51,31 124.35,35.83 159.26,35.83 160.93,37.5 160.93,39.58 v1(160.63,39.88)
I2C_TS_SDA: length 200.1
  IN2 w0.089: v1(162.25,43.48) 162.04,43.48 161.45,44.07 161.45,45.32 160.13,46.64 159.43,46.64 159.08,46.99 159.08,47.38 158.02,48.43 158.02,50.79 155.9,52.92 155.43,52.92 152.09,56.26 151.1,56.26 149.4,57.96 149.4,58.23 148.99,58.65 148.99,61.92 151.21,64.15 151.21,65.32 151.19,65.35 151.19,67.53 150.67,68.05 150.67,70.37 151.51,71.21 152.08,71.21 152.57,71.7 152.57,72.27 152.75,72.46 152.75,74.22 148.47,78.5 148.23,78.5 147.53,79.2 146.63,79.2 146.41,78.98 146.41,78.73 146.18,78.5 145.8,78.5 v2(145.44,78.86)
  BOTTOM w0.109: U400.DT18 143.66,78.58 143.98,78.9 145.41,78.9 v2(145.44,78.86) ; v1(162.25,43.48) 162.48,43.25 162.48,41.93 160.86,40.31 160.45,40.31 160.2,40.05 160.2,39.57 160.7,39.07 160.7,37.59 159.4,36.29 124.48,36.29 119.41,31.22 103.74,31.22 102.83,32.13 38.17,32.13 35.71,34.59 34.97,34.59 33.87,35.69 33.87,37.52 32.58,38.8 R3401.2 31.7,38.8 31.41,38.51 31.41,38.32 30.83,37.74 30.07,37.74 29.71,37.38 29.71,36.48 29.48,36.25 CON3400.22
I2CA_SCL: length 9.3
  BOTTOM w0.109: R6800.1 79.51,92.74 79.07,92.3 v1(79.07,92.2) 79.07,91.51 78.56,91 76.92,91 74.03,88.11 74.03,87.82 73.64,87.43 U6600.B7
I_ADP_ADC0: length 156.1
  TOP w0.109: v1(175.15,18.23) 175.58,18.66 176.36,18.66 177.42,17.6 178.66,17.6 179.35,16.91 180.22,16.91 180.64,16.49 180.64,16.31 181.65,15.3 182.21,15.3 183.01,14.5 183.92,14.5 186.62,11.8 188.17,11.8 188.92,11.05 190.68,11.05 190.86,10.86 190.96,10.63 190.96,10.35 190.56,9.95 190.56,9.38 191.24,8.71 193.3,8.71 R4710.2 ; v1(54.63,13.38) 54.63,13.18 PR8233.1
  IN2 w0.089: v1(175.15,18.23) 174.16,19.23 171.5,19.23 171.19,18.91 165.35,18.91 165.27,18.84 123.72,18.84 123.11,18.23 123.11,16.76 122.4,16.05 119.52,16.05 118.12,14.65 116.03,14.65 115.52,14.15 111.33,14.15 110.92,14.55 110.92,16.66 110.44,17.14 104.58,17.14 104.14,16.7 97.49,16.7 97.1,16.31 94.51,16.31 94.09,16.74 93.06,16.74 92.04,15.71 88.81,15.71 88.38,15.28 80.36,15.28 78.61,13.53 75.83,13.53 74.61,14.76 70.93,14.76 68.17,12 58.2,12 57.88,12.32 55.98,12.32 55.44,12.86 55.16,12.86 v1(54.63,13.38)
I_ADP_ADC0_R: length 8.2
  TOP w0.076: U4700.F2 195.11,15.22 194.78,14.89 194.78,14.49 194.78,14.49 194.78,14.13
  TOP w0.109: 194.78,14.13 194.78,13.9 195.09,13.59 195.14,13.47 195.14,13.07 194.94,12.88 194.94,9.9 194.69,9.65 C4708.2 194.59,9.45 v1(195.04,8.99) 195.02,8.96 R4710.1
I_DCHG_ADC1: length 161.2
  TOP w0.109: v1(54.2,12.88) 54.2,12.59 PR8234.1 ; v1(87.12,14.73) 86.64,14.25 86.64,11.25 87.39,10.5 88.05,10.5 v1(89.1,9.45)
  IN1 w0.079: v2(194.3,13.62) 194.3,13.27 194.16,13.13 194.16,9.62 193.36,8.83 185.81,8.83 185.63,8.65 183.18,8.65 181.79,7.26 179.78,7.26 179.13,6.61 178.68,6.61 177.67,5.6 172.09,5.6 168.74,8.95 162.64,8.95 161.96,8.27 161.51,8.27 161.15,7.91 158.58,7.91 158.45,7.78 151.24,7.78 150.92,8.09 148.25,8.09 148.03,7.87 148.03,7.59 147.79,7.35 146.96,7.35 146.71,7.6 146.71,7.98 146.42,8.27 145.77,8.27 145.75,8.25 143.56,8.25 143.2,7.9 141.09,7.9 140.79,8.2 135.92,8.2 135.62,8.5 134.73,8.5 134.53,8.7 126.34,8.7 126.18,8.53 115.26,8.53 114.55,7.82 114.2,7.82 113.87,7.49 113.87,6.86 113.15,6.14 104.9,6.14 103.92,7.12 102.54,7.12 102.11,7.55 99.73,7.55 98.65,8.62 96.75,8.62 96.23,9.14 89.41,9.14 v1(89.1,9.45)
  IN2 w0.089: v1(87.12,14.73) 80.1,14.73 78.72,13.35 75.76,13.35 74.53,14.58 71.04,14.58 68.28,11.82 58.13,11.82 57.83,12.11 55.45,12.11 54.7,12.86 54.22,12.86 v1(54.2,12.88)
  BOTTOM w0.109: v2(194.3,13.62) 194.43,13.76 R4712.2
I_DCHG_ADC1_R: length 2.1
  TOP w0.076: U4700.E3 v2(194.14,15.69)
  BOTTOM w0.076: v2(194.14,15.69) 194.43,15.4 R4712.1 C4709.2
I_SET: length 209.3
  TOP w0.109: v1(59.26,8.43) 60.07,8.43 60.46,8.82 PR8209.2 ; v2(176.17,8.1) 178.45,8.1 179.23,7.31 181.18,7.31 182.62,5.87 184.81,5.87 185.28,6.34 187.45,6.34 187.94,6.84 189.19,6.84 190.12,7.76 193.17,7.76 v1(193.34,7.59)
  IN1 w0.079: v2(205.9,11.52) 208.19,13.81 208.19,21.76 206.97,22.97 205.33,22.97 203.42,24.88 203.42,25.54 202.57,26.39 202.04,26.39 201.54,26.6 201.27,26.87 200.89,26.87 199.79,27.97 195.92,27.97 195.08,28.82 193.57,28.82 192.78,29.6 192.38,29.6 190.07,31.91 190.07,34.01 189,35.08 189,37.55 188.24,38.31 188.24,41.22 188.34,41.32 188.34,44.24 188.29,44.3 v1(188.29,44.65)
  IN2 w0.089: v1(59.26,8.43) 60.12,8.43 61.29,9.6 66.2,9.6 66.58,9.21 73.83,9.21 75.8,11.18 79.77,11.18 80.95,12.36 85.32,12.36 86.36,11.33 92.05,11.33 92.28,11.1 98.91,11.1 100.25,9.75 102.61,9.75 102.99,9.37 104.46,9.37 105.22,8.61 106.8,8.61 107.1,8.31 110.62,8.31 111.18,8.87 120.06,8.87 120.41,8.51 130.46,8.51 130.64,8.34 132.72,8.34 133.56,7.49 136.09,7.49 136.56,7.96 138.03,7.96 138.28,8.21 142.75,8.21 142.81,8.27 144.7,8.27 145.09,8.65 152.3,8.65 152.38,8.57 154.75,8.57 155.57,9.4 156.67,9.4 156.84,9.57 158.04,9.57 158.2,9.41 160.44,9.41 160.59,9.57 162.29,9.57 162.83,9.03 164.9,9.03 165.14,8.79 170.08,8.79 171.45,7.42 174.48,7.42 175.15,8.1 v2(176.17,8.1) ; v1(193.34,7.59) 193.34,7.59 193.73,7.98 194.51,7.98 194.8,8.28 196.42,8.28 196.52,8.19 198.92,8.19 199.18,7.92 202.52,7.92 205.9,11.31 v2(205.9,11.52)
  BOTTOM w0.109: PQ8401.3 190.16,46.34 189.69,45.87 189.69,45.69 188.64,44.65 v1(188.29,44.65)
ILIM_H: length 1.3
  TOP w0.109: U6203.16 194.86,82.92 R6200.1
ILIM_LO: length 2.3
  TOP w0.109: v1(194.59,84.4) 194.65,84.34 R6201.1 195.07,83.59 195.24,83.42 U6203.15
ILIM_SEL: length 97.1
  TOP w0.076: U4700.A12 191.43,21.44 191.01,21.44 190.57,21.87 190.57,22.12
  TOP w0.109: v2(187.25,23.89) 187.63,24.28 188.37,24.28 188.39,24.25 188.93,24.25 189.15,24.03 R4822.2 189.33,23.82 189.84,23.31 v1(189.84,23.26) 189.84,22.98 190.57,22.25 190.57,22.12 ; U6203.4 198.39,81.8 199.44,80.75 R6202.2 200,80.35 200.49,79.86 200.49,79.1 v1(199.71,78.31)
  IN1 w0.079: v1(202.36,54.43) 202.72,54.79 202.72,59.51 202,60.22 202,63.17 201.16,64.02 201.16,68.67 200.77,69.06 200.77,70.85 201.14,71.22 201.14,71.7 198.98,73.86 198.98,77.59 v1(199.71,78.31)
  IN3 w0.089: v2(187.25,23.89) 187.13,23.77 186.66,23.77 184.55,25.88 184.07,27.04 182.59,29.26 182.59,31.03 181.47,32.14 180.23,32.14 178.85,33.52 178.85,35.81 178.66,36 177.67,36 177.06,36.6 v1(176.93,36.6)
  BOTTOM w0.109: v1(202.36,54.43) 202.69,54.1 202.69,52.02 203.27,51.43 203.27,50.57 203.02,50.32 200.85,50.32 200.27,50.89 196.6,50.89 195.73,51.76 193.14,51.76 192.58,51.2 192.58,49.79 191.69,48.91 191.69,47.7 191.51,47.52 189.53,47.52 185.69,43.68 183.38,43.68 182.85,43.15 182.85,42.43 182.14,41.72 181.45,41.72 180.82,41.09 180.82,40.11 180.01,39.3 180.01,38.78 178.5,37.28 178.28,37.28 177.61,36.6 v1(176.93,36.6)
IM_5S_CLK: length 175.8
  TOP w0.109: R5203.1 36.68,6.76 36.68,9.12 v1(36.88,9.32) ; v2(184.96,14.93) 184.88,14.86 184.88,14.15 v1(185.2,13.83) 186.86,12.17 188.26,12.17 189.15,11.28 190.97,11.28 R4719.2 191.78,11.53 192.12,11.87 192.12,12.99 192.47,13.33 192.47,13.9 193.16,14.6 U4700.C1
  IN1 w0.079: v2(184.96,14.93) 184.02,14.93 182.08,13 180.1,13 179.86,12.75 177.49,12.75 177.34,12.9 172.11,12.9 170.64,14.37 163.79,14.37 162.67,13.26 162.2,13.26 161.31,12.37 159.33,12.37 159.25,12.29 153.13,12.29 152.52,12.9 145.87,12.9 145.12,13.65 144.51,13.65 143.61,12.75 139.6,12.75 139.42,12.93 139.17,12.93 138.45,13.65 137.06,13.65 136.76,13.35 132.89,13.35 132.34,12.8 128.24,12.8 127.85,13.18 127.48,13.18 127.47,13.18 127.21,13.13 123.95,13.13 122.72,11.9 116.07,11.9 115.89,11.73 112.97,11.73 111.94,10.69 110.91,10.69 110.13,9.91 108.07,9.91 107.89,10.08 106.43,10.08 106.12,9.78 105.65,9.78 105.01,10.42 103.56,10.42 102.59,11.38 101.26,11.38 100.3,12.35 93.25,12.35 91.96,13.64 84.3,13.64 83.84,14.1 79.93,14.1 78.73,12.9 75.79,12.9 74.79,13.9 72.08,13.9 70.52,12.34 59.69,12.34 59.26,12.77 55.88,12.77 55.17,12.06 53.42,12.06 51.33,9.97 44.64,9.97 43.2,11.4 40.56,11.4 40.49,11.33 38.89,11.33 v1(36.88,9.32)
IM_5S_DAT: length 176.5
  TOP w0.076: 192.39,14.13 192.85,14.59 192.85,14.94 192.51,15.28 U4700.B2
  TOP w0.109: v1(37.51,9.32) 37.04,8.85 37.04,6.76 R5204.1 ; 192.39,14.13 192.23,13.97 192.23,13.84 191.69,13.31 190.96,13.31 190.55,12.9 189.69,12.9 189.21,12.42 R4718.2 188.43,12.54 187.1,12.54 v1(186.89,12.75) 185.27,14.37 v2(185.27,14.45)
  IN1 w0.079: v1(37.51,9.32) 39.17,10.97 40.71,10.97 40.79,11.05 43.08,11.05 44.53,9.6 51.43,9.6 53.56,11.73 55.3,11.73 56.02,12.44 59.12,12.44 59.55,12.01 70.68,12.01 72.24,13.56 74.63,13.56 75.63,12.57 78.87,12.57 80.07,13.77 83.7,13.77 84.2,13.26 91.86,13.26 93.1,12.02 100.16,12.02 101.13,11.05 102.45,11.05 103.42,10.08 104.88,10.08 105.51,9.45 106.26,9.45 106.56,9.75 107.76,9.75 107.93,9.58 111.69,9.58 112.04,9.93 112.04,10.31 113.12,11.4 116.04,11.4 116.22,11.57 122.92,11.57 123.86,12.51 126.46,12.51 126.78,12.64 127.36,12.82 127.52,12.85 127.71,12.85 128.1,12.46 133.19,12.46 133.74,13.01 135.52,13.01 136.03,12.5 139.35,12.5 140.14,11.71 142.49,11.71 143.46,12.11 144.66,13.32 144.98,13.32 145.74,12.56 152.38,12.56 152.98,11.96 159.39,11.96 159.46,12.03 161.45,12.03 162.34,12.93 163.02,12.93 164.11,14.02 169.87,14.02 171.23,12.66 171.23,11.22 171.6,10.84 178.69,10.84 180.51,12.66 182.26,12.66 184.05,14.45 v2(185.27,14.45)
IMVP_PSYS: length 176.5
  TOP w0.109: PR8836.2 80.44,103.77 v1(80.14,103.77) ; PR8236.2 53.06,8.83 52.75,9.14 52.75,9.84 53.24,10.32 PC8226.1 53.24,10.77 53.08,10.93 53.08,11.53 53.53,11.98 53.53,12.34 v1(53.69,12.49) 53.53,12.65 53.53,13.15 v1(53.8,13.41)
  IN2 w0.089: v1(53.8,13.41) 53.64,13.26 52.42,13.26 52.22,13.05 46.34,13.05 45.72,12.43 44.96,12.43 43.85,13.55 42.65,13.55 41.62,12.51 39.98,12.51 39.34,13.15 38.37,13.15 34.24,17.28 32.73,17.28 23.14,26.86 22.59,26.86 22.09,27.36 22.09,32.33 23.1,33.34 23.1,34.36 22.18,35.28 22.18,37.51 22.55,37.89 22.55,43.08 22.93,43.46 22.93,48.34 24.28,49.69 24.28,51.43 25.26,52.41 25.26,54.52 27.32,56.59 27.32,58.42 30.96,62.06 30.96,74.11 33.04,76.2 33.04,76.68 31.77,77.95 31.77,82.08 32.26,82.57 32.26,85.63 32.27,85.64 32.27,86.78 32.26,86.79 32.26,86.82 31.06,88.02 31.06,90.6 31.93,91.46 31.93,95.22 32.18,95.48 32.18,96.29 36.07,100.18 37.87,100.18 39.38,98.66 40.17,98.66 41.39,97.45 53.61,97.45 54.01,97.05 56.06,97.05 57.48,98.47 76.93,98.47 78.23,99.77 79.12,99.77 79.7,100.35 79.7,103.33 v1(80.14,103.77)
IN_CLK: length 123.7
  TOP w0.109: C3523.2 194.72,51.76 194.58,51.76 194.06,52.28 193.48,52.28 192.01,53.74 190.77,53.74 190.32,54.19 190.32,54.85 189.68,55.49 188.12,55.49 187.39,56.22 187.39,56.59 187.54,56.74 187.64,56.74 v1(187.95,56.43)
  IN3 w0.079: 110.36,79.74 110.34,79.74 110.32,79.75 108.89,79.75 108.26,80.38 108.26,80.74 108.06,80.94 107.98,80.94 v2(107.8,80.76)
  IN3 w0.089: 110.36,79.74 110.82,79.74 110.95,79.61 117.22,79.61 118.52,80.91 118.52,82.01 118.59,82.07 118.59,83.63 118.51,83.8 118.51,84.28 120.05,85.82 120.24,85.82 121.55,87.13 121.55,87.5 123.12,89.07 123.12,89.5 123.52,89.9 124.56,89.9 126.99,92.33 130.3,92.33 130.83,92.86 137.73,92.86 137.97,92.62 144.38,92.62 144.63,92.86 146.9,92.86 147.37,93.33 154.6,93.33 157.83,90.09 157.83,89.21 161.68,85.37 163.33,85.37 165.26,83.44 165.54,83.44 170.12,78.86 172.13,78.86 172.97,78.03 172.97,76.73 175.17,74.53 175.43,74.53 176.79,73.17 176.79,72.18 177.86,71.11 177.86,69.74 178.97,68.63 178.97,68.27 178.64,67.94 178.64,67.21 179.93,65.91 180.64,65.91 181.46,65.1 182.91,65.1 186.24,61.77 186.24,61.06 186.38,60.92 186.38,59.52 186.96,58.95 186.96,57.19 187.39,56.75 187.63,56.75 v1(187.95,56.43)
  BOTTOM w0.109: U400.T12 107.09,81.09 106.95,80.96 106.95,80.73 107.07,80.61 107.67,80.61 107.8,80.74 v2(107.8,80.76)
IN_CLK#: length 123.6
  TOP w0.109: C3524.2 194.98,51.39 194.84,51.53 194.49,51.53 193.97,52.05 193.38,52.05 191.92,53.52 190.68,53.52 190.09,54.1 190.09,54.76 189.58,55.27 188.02,55.27 187.16,56.13 187.16,56.68 187.44,56.96 187.72,56.96 v1(187.95,57.19)
  IN3 w0.079: v2(107.82,81.45) 107.82,81.28 108,81.1 108.13,81.1 108.42,80.81 108.42,80.45 108.95,79.91 110.32,79.91 110.34,79.93 110.36,79.93
  IN3 w0.089: 110.36,79.93 110.9,79.93 111.02,79.8 117.14,79.8 118.33,80.99 118.33,82.08 118.4,82.15 118.4,83.59 118.32,83.77 118.32,84.36 119.97,86.01 120.16,86.01 121.36,87.21 121.36,87.58 122.93,89.15 122.93,89.58 123.44,90.09 124.48,90.09 126.91,92.52 130.22,92.52 130.75,93.05 137.81,93.05 138.05,92.81 144.31,92.81 144.55,93.05 146.82,93.05 147.29,93.52 154.67,93.52 158.02,90.17 158.02,89.29 161.76,85.56 163.41,85.56 165.34,83.63 165.62,83.63 170.19,79.06 172.21,79.06 173.16,78.11 173.16,76.81 175.25,74.72 175.51,74.72 176.99,73.25 176.99,72.26 178.05,71.19 178.05,69.82 179.16,68.71 179.16,68.19 178.83,67.86 178.83,67.29 180.01,66.1 180.72,66.1 181.53,65.29 182.99,65.29 186.43,61.85 186.43,61.14 186.57,61 186.57,59.6 187.15,59.03 187.15,57.27 187.47,56.94 187.7,56.94 v1(187.95,57.19)
  BOTTOM w0.109: U400.T11 107.53,81.74 v2(107.82,81.45)
IN_D0: length 122.6
  TOP w0.109: C3521.2 194.98,53.63 194.89,53.54 193.35,53.54 193.02,53.88 193.02,54.3 193.18,54.46 193.39,54.46 193.49,54.36 v1(193.49,54.17)
  IN3 w0.079: 112.5,82.76 112.49,82.78 112.31,82.78 111.59,82.05 111.59,81.77 111.21,81.4 110.83,81.4 110.73,81.5 109.91,81.5 109.68,81.27 v2(109.67,81.27)
  IN3 w0.089: 112.5,82.76 115.35,82.76 115.7,83.11 115.7,85.16 115.99,85.44 117.9,85.44 119.21,86.75 119.21,88.79 119.57,89.15 120.52,89.15 121.12,89.75 121.26,89.75 125.72,94.21 131.93,94.21 132.15,93.98 134.34,93.98 135.37,95.01 137.41,95.01 139.35,96.95 149.6,96.95 150.02,96.53 156.15,96.53 157.42,95.26 157.42,95.14 161.91,90.65 161.91,88.82 163.7,87.03 164.49,87.03 165.39,86.13 165.39,85.15 167.23,83.31 168.58,83.31 171.78,80.11 172.44,80.11 174.14,78.41 174.14,77.06 175.26,75.94 175.69,75.94 178.09,73.54 178.09,73.19 179.32,71.96 179.32,71.45 180.2,70.57 180.31,70.57 181.2,69.68 181.2,67.76 181.6,67.37 182.11,67.37 187.97,61.51 187.97,61.08 188.83,60.22 188.83,59.23 188.6,59 188.6,57.73 189.53,56.8 189.53,55.9 191.41,54.02 192.63,54.02 193.17,54.55 193.36,54.55 193.49,54.43 v1(193.49,54.17)
  BOTTOM w0.109: v2(109.67,81.27) 109.23,81.71 U400.Y11
IN_D0#: length 122.6
  TOP w0.109: C3522.2 194.7,53.32 193.26,53.32 192.79,53.78 192.79,54.39 193.08,54.68 193.23,54.68 v1(193.49,54.94)
  IN3 w0.079: v2(109.68,81.88) 109.91,81.66 110.8,81.66 110.89,81.56 111.15,81.56 111.43,81.84 111.43,82.12 112.25,82.93 112.48,82.93 112.5,82.95
  IN3 w0.089: 112.5,82.95 115.27,82.95 115.51,83.19 115.51,85.24 115.91,85.63 117.83,85.63 119.02,86.83 119.02,88.87 119.49,89.34 120.44,89.34 121.04,89.94 121.18,89.94 125.64,94.4 132,94.4 132.23,94.17 134.27,94.17 135.29,95.2 137.33,95.2 139.27,97.14 149.68,97.14 150.1,96.72 156.23,96.72 157.61,95.34 157.61,95.22 162.1,90.73 162.1,88.9 163.78,87.22 164.56,87.22 165.58,86.21 165.58,85.23 167.31,83.5 168.66,83.5 171.86,80.3 172.52,80.3 174.33,78.49 174.33,77.14 175.34,76.13 175.77,76.13 178.28,73.62 178.28,73.27 179.51,72.03 179.51,71.53 180.28,70.76 180.39,70.76 181.39,69.76 181.39,67.84 181.67,67.56 182.19,67.56 188.16,61.59 188.16,61.16 189.02,60.3 189.02,59.15 188.79,58.92 188.79,57.81 189.72,56.88 189.72,55.98 191.49,54.21 192.55,54.21 193.09,54.74 193.29,54.74 v1(193.49,54.94)
  BOTTOM w0.109: v2(109.68,81.88) 109.68,81.95 U400.Y9
IN_D1: length 121.8
  TOP w0.109: C3507.2 194.98,55.69 194.89,55.6 194.52,55.6 194.31,55.81 194.31,56.41 193.71,57.01 193.27,57.01 192.26,58.01 191.95,58.01 191.52,58.44 190.11,58.44 v1(189.87,58.67)
  IN3 w0.079: v2(107.82,82) 107.6,82 107.5,82.11 107.5,82.23 107.64,82.37 108,82.37 108.13,82.24 110.84,82.24 111.2,82.39 112.24,83.44 112.39,83.44 112.4,83.42
  IN3 w0.089: 112.4,83.42 113.5,83.42 113.96,83.88 113.96,84.48 115.79,86.31 117.73,86.31 118.16,86.74 118.16,89.71 118.44,89.99 120.31,89.99 120.79,90.47 121.26,90.47 125.86,95.07 134.56,95.07 135.05,95.57 137.22,95.57 139.36,97.7 151.27,97.7 151.92,97.05 156.32,97.05 157.9,95.47 157.9,95.32 162.41,90.81 162.41,89.11 163.98,87.54 164.79,87.54 165.99,86.35 165.99,85.8 166.66,85.13 167.65,85.13 172.01,80.77 172.91,80.77 176.62,77.06 176.62,76.65 177.31,75.96 177.77,75.96 178.22,75.51 178.22,75.32 179.21,74.33 179.21,73.76 182.87,70.1 182.87,68.13 184.08,66.91 184.08,66.2 188.76,61.53 188.76,61.08 189.39,60.45 189.39,60.02 190.46,58.96 190.46,58.6 190.27,58.42 190.07,58.42 189.85,58.65 v1(189.87,58.67)
  BOTTOM w0.109: v2(107.82,82) 107.82,82.58 107.72,82.68 107.48,82.68 107.4,82.6 U400.T9
IN_D1#: length 121.8
  TOP w0.109: C3508.2 194.65,55.37 194.43,55.37 194.08,55.72 194.08,56.32 193.62,56.78 193.18,56.78 192.17,57.79 191.85,57.79 191.43,58.21 190.18,58.21 v1(189.87,57.91)
  IN3 w0.079: v2(106.99,82.1) 107.27,82.1 107.34,82.17 107.34,82.29 107.58,82.53 108.06,82.53 108.19,82.4 110.81,82.4 111.11,82.52 112.18,83.59 112.38,83.59 112.4,83.61
  IN3 w0.089: v1(189.87,57.91) 190.19,58.23 190.35,58.23 190.65,58.52 190.65,59.04 189.58,60.1 189.58,60.53 188.95,61.16 188.95,61.61 184.27,66.28 184.27,66.99 183.06,68.21 183.06,70.18 179.4,73.84 179.4,74.41 178.41,75.4 178.41,75.59 177.85,76.15 177.39,76.15 176.81,76.73 176.81,77.14 172.98,80.96 172.09,80.96 167.73,85.32 166.74,85.32 166.18,85.88 166.18,86.42 164.87,87.73 164.06,87.73 162.6,89.19 162.6,90.89 158.09,95.4 158.09,95.55 156.4,97.24 151.99,97.24 151.35,97.89 139.28,97.89 137.14,95.76 134.97,95.76 134.48,95.26 125.78,95.26 121.18,90.66 120.71,90.66 120.23,90.18 118.36,90.18 117.97,89.79 117.97,86.82 117.65,86.5 115.71,86.5 113.77,84.56 113.77,83.96 113.42,83.61 112.4,83.61
  BOTTOM w0.109: v2(106.99,82.1) 106.69,82.39 U400.P9
IN_D2: length 118.8
  TOP w0.109: C3505.2 194.55,57.66 194.37,57.66 193.78,58.25 193.44,58.25 193.19,58.5 192.78,58.5 192.59,58.69 192.22,58.69 191.92,59 190.62,59 188.79,60.83 187.66,60.83 187.28,60.44 187.28,60.28 v1(186.96,59.97)
  IN3 w0.079: 110.36,80.57 110.34,80.57 110.32,80.59 110.09,80.59 109.94,80.74 109.33,80.74 109.16,80.91 109.16,81.42 109.09,81.48 109.02,81.48 108.79,81.25 v2(108.79,81.25)
  IN3 w0.089: v1(186.96,59.97) 187.28,60.29 187.28,61.55 183.11,65.73 181.73,65.73 181.1,66.37 181.1,66.98 180.72,67.36 180.72,68.68 180.41,68.98 179.46,68.98 178.48,69.96 178.48,71.71 177.53,72.66 177.53,73.3 175.53,75.3 175.26,75.3 173.56,77 173.56,78.27 172.35,79.47 171.61,79.47 168.39,82.7 167.11,82.7 163.53,86.28 162.35,86.28 158.57,90.07 158.57,91.62 156.19,94 155.91,94 154.1,95.82 145.49,95.82 144.89,96.42 139.67,96.42 137.54,94.28 135.65,94.28 134.81,93.44 131.25,93.44 131.14,93.56 125.81,93.56 122.25,90 122.25,89.02 120.74,87.52 120.74,87.16 119.99,86.41 119.75,86.41 117.52,84.18 117.52,82.4 117.06,81.94 116.46,81.94 115.89,81.38 115.05,81.38 114.11,80.44 111.3,80.44 111.17,80.57 110.36,80.57
  BOTTOM w0.109: U400.V11 108.32,81.72 v2(108.79,81.25)
IN_D2#: length 118.7
  TOP w0.109: v1(187.72,59.97) 187.5,60.19 187.5,60.35 187.75,60.6 188.69,60.6 190.52,58.77 191.82,58.77 192.13,58.47 192.49,58.47 192.69,58.28 193.1,58.28 193.35,58.02 193.69,58.02 194.28,57.43 194.57,57.43 C3506.2
  IN3 w0.079: v2(108.78,81.88) 109.02,81.64 109.16,81.64 109.32,81.48 109.32,80.98 109.4,80.9 110.01,80.9 110.16,80.74 110.32,80.74 110.34,80.76 110.36,80.76
  IN3 w0.089: v1(187.72,59.97) 187.48,60.21 187.48,61.63 183.18,65.92 181.81,65.92 181.29,66.45 181.29,67.06 180.91,67.44 180.91,68.76 180.49,69.17 179.54,69.17 178.67,70.04 178.67,71.79 177.72,72.74 177.72,73.38 175.61,75.49 175.33,75.49 173.75,77.07 173.75,78.35 172.43,79.66 171.69,79.66 168.47,82.89 167.19,82.89 163.6,86.47 162.43,86.47 158.76,90.15 158.76,91.7 156.27,94.19 155.99,94.19 154.18,96.01 145.57,96.01 144.97,96.61 139.59,96.61 137.46,94.47 135.57,94.47 134.73,93.63 131.33,93.63 131.21,93.75 125.73,93.75 122.06,90.08 122.06,89.1 120.55,87.6 120.55,87.24 119.91,86.6 119.67,86.6 117.33,84.26 117.33,82.48 116.98,82.13 116.38,82.13 115.82,81.57 114.97,81.57 114.04,80.63 111.38,80.63 111.25,80.76 110.36,80.76
  BOTTOM w0.109: U400.V9 108.32,82.35 v2(108.78,81.88)
INB0_SCL: length 547.3
  TOP w0.109: U2000.A1 74.94,10.67 75.25,10.67 75.53,10.94 75.53,11.84 76.88,13.18 76.88,13.71 v1(76.65,13.94) ; U2008.A1 22.3,27.49 v1(22.68,27.87) ; v1(142.01,13.84) 141.99,13.84 141.56,14.26 U1804.A1 ; U1800.A1 194.45,2.47 194.22,2.7 194.22,2.84 193.61,3.45 v1(193.61,3.89) ; U1809.C3 182.16,29.59 181.55,30.21 180.68,30.21 180.31,30.58 179.86,30.58 179.84,30.6 v1(179.81,30.6) 179.79,30.6 179.4,30.21 179.4,28.79 180.06,28.12 U1809.A1 ; v1(167.09,72) 168.05,72 168.56,71.49 U1907.B3 ; v1(118.85,92.4) 119.5,91.75 U2001.A1 ; v1(25.12,25.75) 25.71,26.35 U1803.A1 ; U1806.B3 176.23,5.03 174.97,3.77 174.97,2.98 v1(175,2.94) 175.33,2.62 176.46,2.62 177.13,3.29 U1806.A1 ; v1(173.45,60.53) 172.81,60.53 170.66,62.67 170.66,65.65 169.57,66.74 169.57,67.34 168.15,68.76 v1(168.15,69.53) 168.16,69.54 U1907.A1 ; U1802.A1 25.75,35.17 25.57,34.99 25.57,34.49 25.22,34.14 v1(25.09,34.14) 25.09,34.05 24.7,33.66 24.26,33.66 23.98,33.94 23.98,34.16 24.03,34.29 24.03,36.12 23.87,36.27 v1(23.87,36.55) 24.13,36.55 24.46,36.22 24.81,36.22 U1802.C3 ; v1(175.05,56.19) 175.26,56.4 176.35,56.4 176.44,56.31 178.4,56.31 178.97,56.87 180.04,56.87 180.59,57.1 181.54,58.05 v1(182.23,58.05) ; U1905.A1 192.32,54.8 v1(192.25,54.73) ; U1807.A1 14.19,17.57 14.7,18.08 15.57,18.08 15.75,17.9 16.86,17.9 17.45,18.49 17.45,19.59 v1(17.88,20.02) ; v1(111.52,11.6) 111.52,13.14 U1903.A1 ; U1905.B3 190.83,55.63 v1(190.73,55.52)
  IN1 w0.079: v1(175,2.94) 175.36,2.59 177.91,2.59 178.86,3.54 181.17,3.54 182.68,5.06 184.63,5.06 185.85,3.83 186.18,3.83 186.41,3.61 191.6,3.61 192.12,4.12 193.44,4.12 193.61,3.96 v1(193.61,3.89) ; v1(38.53,13.55) 40.16,15.19 42.32,15.19 43.11,14.4 59.95,14.4 60.49,13.85 71.31,13.85 71.88,14.42 76.16,14.42 v1(76.65,13.94) 77.15,13.44 78.18,13.44 79.4,14.65 86.28,14.65 86.76,14.17 92.15,14.17 93.48,12.84 98.54,12.84 98.81,13.11 105,13.11 105.79,12.32 107.85,12.32 108.25,11.91 110.21,11.91 110.49,11.63 110.49,11.4 110.66,11.23 111.15,11.23 v1(111.52,11.6) 113.1,13.18 117.8,13.18 118.54,12.44 121.51,12.44 122.88,13.82 125.35,13.82 126.27,14.73 130.43,14.73 131.27,13.89 136.5,13.89 136.93,14.32 140.52,14.32 140.99,13.85 140.99,13.67 141.2,13.46 141.64,13.46 v1(142.01,13.84) 142.5,14.32 145.46,14.32 146.15,13.64 152.78,13.64 153.46,12.95 156.7,12.95 156.94,13.19 156.94,13.71 157.33,14.1 162.1,14.1 163.35,15.34 163.9,15.34 164.34,14.9 171.56,14.9 172.04,14.42 178.9,14.42 179.17,14.15 v1(181.56,14.15) 181.94,13.76 182.37,13.76 182.93,14.32 182.93,15.26 183.36,15.69 183.64,15.69 185.14,17.18 185.14,20.01 184.59,20.56 184.59,22.43 185.52,23.37 185.52,24.59 184.56,25.55 183.92,27.1 183.92,27.2 182.09,29.02 181.95,29.02 180.37,30.6 v1(179.81,30.6) 179.81,30.62 177.3,33.14 176.08,33.14 172.62,36.59 170.87,36.59 169.63,37.83 168.69,37.83 v1(168.63,37.89) ; v1(182.23,58.05) 182.79,58.05 182.83,58.09 187.78,58.09 190.35,55.52 v1(190.73,55.52) 191.14,55.11 191.14,54.66 191.5,54.3 191.82,54.3 v1(192.25,54.73)
  IN2 w0.089: v1(38.53,13.55) 38.09,13.99 37.81,13.99 34.33,17.47 32.79,17.47 25.12,25.14 v1(25.12,25.75) ; v1(168.15,69.53) 168.15,71.12 167.27,72 v1(167.09,72) ; v1(167.48,86.72) 167.95,86.26 168.43,86.26 168.62,86.06 168.62,83.19 170.2,81.61 170.2,80.33 169.94,80.06 169.94,79.23 169.78,79.08 169.78,75.98 171.73,74.04 171.73,72.01 172.31,71.44 172.31,65.35 171.8,64.84 171.8,63.76 173.67,61.88 173.67,61.05 173.45,60.83 v1(173.45,60.53) 173.86,60.12 173.86,59.89 175.66,58.1 175.66,56.8 v1(175.05,56.19) ; v1(25.09,34.14) 22.48,31.52 22.48,28.08 v1(22.68,27.87)
  IN3 w0.089: v1(118.85,92.4) 118.57,92.69 118.57,93.14 118.87,93.44 119.25,93.44 119.48,93.22 119.48,92.83 119.85,92.46 122.04,92.46 125.59,96.01 130.9,96.01 132.13,97.25 133.41,97.25 134.23,96.43 136.87,96.43 138.1,97.65 138.1,97.66 139,98.57 142.85,98.57 145.43,101.15 146.78,101.15 147.27,101.64 v2(147.27,101.69) 147.32,101.69 147.71,102.08 148.11,102.08 148.38,101.8 148.38,101.52 149.67,100.24 152.55,100.24 154.5,98.3 156.28,98.3 158.81,95.77 158.81,95.62 163.26,91.17 163.26,89.58 164.42,88.42 166.67,88.42 167.26,87.83 167.26,86.95 v1(167.48,86.72) ; v1(25.12,25.75) 25.47,26.11 25.47,26.54 24.15,27.87 v1(22.68,27.87) 21.65,26.83 21.65,24.94 20.87,24.16 20.48,24.16 18.2,21.88 18.2,20.34 v1(17.88,20.02) ; v1(193.61,3.89) 193.61,3.53 195.01,2.12 205.15,2.12 206.14,3.12 206.14,3.62 206.8,4.28 206.8,4.54 207.9,5.64 209.8,5.64 213.03,8.86 213.03,11.42 212.34,12.11 212.34,13.17 214.38,15.21 214.38,19.9 212.42,21.86 212.42,23.98 208.97,27.43 204.2,27.43 202.64,28.99 202.5,28.99 200.67,30.83 199.16,30.83 198.56,31.42 198.23,31.42 197.77,30.97 195.06,30.97 193.89,32.14 193.29,32.14 192.57,32.85 192.57,36.39 192.96,36.78 192.96,37.94 193.69,38.67 196.78,38.67 197.23,39.11 199.48,39.11 v1(199.88,38.71)
  BOTTOM w0.109: v1(199.88,38.71) 199.8,38.79 U1801.A1 ; v1(175,2.94) 175,3.2 175.46,3.66 175.46,5.68 176.07,6.29 176.74,6.29 177.01,6.55 177.01,6.98 177.78,7.74 181,7.74 181.15,7.9 181.15,8.51 181.33,8.68 181.33,12.65 181.97,13.29 181.97,13.73 v1(181.56,14.15) ; v2(147.27,101.69) 147.27,102.17 R1901.2 ; v1(175.05,56.19) 174.23,55.37 174.23,52.92 174.62,52.53 174.62,51.82 174,51.2 174,50.6 174.6,50.01 174.6,49.05 173.84,48.28 173.84,47.62 173.06,46.85 173.06,45.97 171.14,44.05 170.7,44.05 169.7,43.04 169.7,41.43 169.59,41.32 169.59,39.53 168.63,38.56 v1(168.63,37.89)
INB0_SDA: length 554.7
  TOP w0.109: U2001.C3 U2001.B3 120.02,93.08 119,94.1 118.63,94.1 118.39,93.86 118.39,93.46 118.6,93.25 118.81,93.25 v1(119.02,93.04) 119.14,92.92 119.14,92.85 119.36,92.32 119.53,92.15 U2001.A2 ; U1903.B3 109.07,14.99 108.93,14.85 108.93,13.85 110.64,12.14 110.64,11.86 v1(110.9,11.6) 111.12,11.83 111.12,13 109.68,14.45 U1903.A2 ; v1(174.42,56.34) 174.71,56.63 176.44,56.63 176.53,56.53 178.3,56.53 178.86,57.1 179.98,57.1 180.46,57.3 182.07,58.9 v1(182.38,58.9) ; v1(179.98,29.99) 179.98,29.93 179.69,29.64 179.69,28.93 180.09,28.52 U1809.A2 ; U1905.C3 190.86,56.03 v1(190.73,56.16) ; v1(194.24,3.89) 194.24,3.14 194.51,2.87 U1800.A2 ; v1(191.62,54.71) 191.92,55 U1905.A2 ; v1(175.69,3.12) 176.45,3.12 176.73,3.4 U1806.A2 ; v1(141.37,13.84) 141.16,14.05 U1804.A2 ; U2008.B3 21.9,26.53 22.13,26.3 23.38,26.3 23.87,26.8 23.87,27.27 23.64,27.5 23.03,27.5 v1(22.78,27.25) 22.53,27 U2008.A2 ; v1(25.07,26.39) 25.31,26.64 U1803.A2 ; v1(173.45,59.89) 173.25,60.09 172.92,60.09 170.43,62.58 170.43,65.55 169.34,66.64 169.34,67.25 167.67,68.92 167.67,70.55 168.13,71.02 U1907.A2 ; U2000.A2 74.92,10.44 75.35,10.44 75.76,10.84 75.76,11.74 77.1,13.09 77.1,13.76 v1(77.28,13.94) 77.75,14.41 78.1,14.41 78.36,14.15 78.36,13.06 77.09,11.79 77.09,9.72 76.65,9.27 74.47,9.27 74.04,9.7 U2000.C3 ; v1(17.88,19.37) 17.88,18.59 16.96,17.68 15.49,17.68 15.36,17.8 14.88,17.8 14.59,17.51 U1807.A2 ; U1807.C3 15.26,16.6 15.58,16.28 16.66,16.28 17.09,16.71 17.09,17.24 17.82,17.97 v1(18.78,17.97) ; U1802.A2 25.35,35.06 v1(25.09,34.81)
  IN1 w0.079: v1(191.62,54.71) 191.62,55.26 v1(190.73,56.16) 189.94,56.16 187.83,58.27 183.02,58.27 v1(182.38,58.9) ; v1(194.24,3.89) 193.85,4.28 192.06,4.28 191.54,3.76 186.47,3.76 186.25,3.99 185.92,3.99 184.64,5.26 182.66,5.26 181.1,3.7 178.8,3.7 178.22,3.12 v1(175.69,3.12) ; v1(38.52,14.23) 39.66,15.36 42.36,15.36 43.17,14.55 60.01,14.55 60.56,14.01 71.23,14.01 71.83,14.6 76.62,14.6 v1(77.28,13.94) 77.63,13.6 78.11,13.6 79.35,14.83 86.38,14.83 86.87,14.35 92.2,14.35 93.55,13 98.04,13 98.3,13.27 105.07,13.27 105.84,12.49 107.98,12.49 108.38,12.09 110.41,12.09 v1(110.9,11.6) 112.66,13.36 117.88,13.36 118.62,12.62 121.46,12.62 122.91,14.07 125.04,14.07 125.91,14.93 130.6,14.93 131.47,14.07 136.19,14.07 136.62,14.5 140.71,14.5 v1(141.37,13.84) 142.04,14.5 145.57,14.5 146.25,13.82 152.88,13.82 153.59,13.11 155.5,13.11 156.67,14.27 162.06,14.27 163.35,15.57 163.93,15.57 164.36,15.14 171.78,15.14 172.34,14.57 181.76,14.57 v1(182.19,14.15) 182.7,14.65 182.7,15.25 183.29,15.85 183.58,15.85 184.98,17.25 184.98,19.95 184.43,20.5 184.43,22.81 185.34,23.72 185.34,24.54 184.43,25.46 183.76,27.07 183.76,27.13 182.03,28.86 181.8,28.86 181.36,29.3 180.48,29.3 180.09,29.69 180.09,29.88 v1(179.98,29.99) 179.92,30.05 179.77,30.05 178.9,30.93 178.9,31.3 177.24,32.97 176.02,32.97 172.58,36.41 170.83,36.41 169.97,37.27 168.54,37.27 168.18,37.63 v1(168.18,38.37)
  IN2 w0.089: v1(174.42,56.34) 175.48,57.4 175.48,58.02 174.14,59.36 173.78,59.36 173.45,59.68 v1(173.45,59.89) 173.23,59.89 173,60.12 173,60.88 173.45,61.34 173.45,61.85 171.62,63.69 171.62,64.92 172.13,65.42 172.13,71.33 171.55,71.9 171.55,73.94 169.61,75.89 169.61,79.24 169.76,79.39 169.76,80.14 170.02,80.4 170.02,81.54 168.27,83.3 168.27,85.17 168.12,85.32 166.67,85.32 166.47,85.52 166.47,86.36 v1(166.79,86.68) ; v1(38.52,14.23) 37.84,14.23 34.41,17.65 32.87,17.65 25.52,24.99 25.52,25.93 v1(25.07,26.39) ; v1(25.09,34.81) 22.27,31.99 22.27,27.57 22.59,27.25 v1(22.78,27.25)
  IN3 w0.089: v1(194.24,3.89) 194.24,3.26 195.2,2.3 204.79,2.3 205.23,2.74 205.23,3.86 205.92,4.54 205.92,4.82 206.34,5.25 207.24,5.25 207.83,5.84 209.75,5.84 212.85,8.94 212.85,11.35 212.16,12.03 212.16,13.24 214.18,15.26 214.18,19 212.21,20.96 212.21,23.93 208.9,27.25 204.13,27.25 202.59,28.79 202.42,28.79 200.56,30.65 198.32,30.65 197.98,30.79 194.99,30.79 193.84,31.93 193.24,31.93 192.4,32.78 192.4,36.47 192.76,36.83 192.76,38.02 193.61,38.87 196.72,38.87 197.14,39.29 199.92,39.29 v1(200.51,38.71) ; v1(119.02,93.04) 119.78,92.28 122.13,92.28 125.65,95.81 130.95,95.81 132.21,97.07 133.34,97.07 134.16,96.24 136.95,96.24 139.09,98.37 142.98,98.37 145.51,100.89 147.03,100.89 147.43,101.29 147.51,101.29 v2(147.9,101.69) 149.53,100.06 152.45,100.06 154.41,98.11 156.22,98.11 158.61,95.72 158.61,95.57 163.08,91.09 163.08,89.51 164.35,88.24 166.55,88.24 167.03,87.75 167.03,86.92 v1(166.79,86.68) ; v1(18.78,17.97) 18.78,18.47 v1(17.88,19.37) 18.38,19.88 18.38,21.81 20.56,23.99 20.95,23.99 21.82,24.86 21.82,26.3 v1(22.78,27.25) 24.21,27.25 v1(25.07,26.39)
  BOTTOM w0.109: v1(174.42,56.34) 174.42,55.88 174,55.46 174,52.83 174.39,52.43 174.39,51.92 173.78,51.3 173.78,50.1 173.18,49.5 173.18,47.28 172.83,46.94 172.83,46.06 171.56,44.79 170.9,44.79 169.47,43.36 169.47,41.58 169.37,41.48 169.37,39.62 168.18,38.44 v1(168.18,38.37) ; v2(147.9,101.69) 147.9,102.31 148.28,102.69 148.8,102.69 R1902.2 ; U1801.A2 200.2,39.01 v1(200.51,38.71) ; v1(175.69,3.12) 175.69,5.59 176.17,6.07 176.86,6.07 177.24,6.45 177.24,6.88 177.87,7.52 181.1,7.52 181.38,7.8 181.38,8.41 181.56,8.58 181.56,12.55 182.19,13.18 182.19,14.14 v1(182.19,14.15)

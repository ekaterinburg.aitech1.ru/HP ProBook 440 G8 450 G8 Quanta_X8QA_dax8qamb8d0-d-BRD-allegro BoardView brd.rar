# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_1_DQ_4<6>: length 79.5
  IN1 w0.079: v1(51.72,21.53) 50.47,22.77 50.47,27.46 57.55,34.54 67.86,34.54 88.23,54.92 88.23,60.98 92.09,64.84 92.74,64.84 95.95,68.04 99.42,68.04 v2(100.25,67.21)
  BOTTOM w0.079: v2(100.25,67.21) 100.38,67.34 100.92,67.34 101.12,67.14 U400.B43
  BOTTOM w0.109: v1(51.72,21.53) JDIM2900.50
M_1_DQ_4<7>: length 78.7
  IN1 w0.079: v1(51.72,22.8) 50.75,23.76 50.75,27.35 57.67,34.26 67.98,34.26 88.63,54.92 88.63,60.97 92.17,64.52 92.84,64.52 96.08,67.76 98.49,67.76 v2(99.14,67.11)
  BOTTOM w0.079: U400.A43 100.67,67.09 100.48,66.89 99.36,66.89 v2(99.14,67.11)
  BOTTOM w0.109: v1(51.72,22.8) 50.72,21.8 JDIM2900.46
M_1_DQ_5<0>: length 90.5
  IN3 w0.089: v1(44.46,27.1) 44.48,27.11 44.48,27.8 49.69,33.01 55.85,33.01 55.94,33.1 55.94,33.34 56.03,33.43 56.21,33.43 56.3,33.34 56.3,33.11 56.39,33.01 56.56,33.01 56.65,33.1 56.65,33.45 56.74,33.54 56.92,33.54 57.01,33.45 57.01,33.11 57.11,33.01 57.27,33.01 57.36,33.1 57.36,33.45 57.45,33.54 57.63,33.54 57.72,33.45 57.72,33.11 57.82,33.01 57.98,33.01 58.07,33.1 58.07,33.45 58.16,33.54 58.34,33.54 58.43,33.45 58.43,33.11 58.53,33.01 58.7,33.01 58.78,33.1 58.78,33.45 58.87,33.54 59.05,33.54 59.14,33.45 59.14,33.11 59.24,33.01 59.41,33.01 59.5,33.1 59.5,33.45 59.58,33.54 59.76,33.54 59.85,33.45 59.85,33.11 59.95,33.01 60.12,33.01 60.21,33.1 60.21,33.45 60.3,33.54 60.47,33.54 60.56,33.45 60.56,33.11 60.66,33.01 60.83,33.01 60.92,33.1 60.92,33.45 61.01,33.54 61.19,33.54 61.27,33.45 61.27,33.11 61.37,33.01 61.54,33.01 61.63,33.1 61.63,33.45 61.72,33.54 61.9,33.54 61.99,33.45 61.99,33.11 62.08,33.01 62.25,33.01 62.34,33.1 62.34,33.45 62.43,33.54 62.61,33.54 62.7,33.45 62.7,33.11 62.8,33.01 62.96,33.01 63.05,33.1 63.05,33.45 63.14,33.54 63.32,33.54 63.41,33.45 63.41,33.11 63.51,33.01 63.8,33.01 77.67,46.88 79.94,46.88 88.56,55.5 94.29,55.5 97.64,58.85 97.64,64.39 96.26,65.76 96.26,66.47 97.29,67.49 99.33,67.49 v2(100.26,68.42)
  BOTTOM w0.079: v2(100.26,68.42) 100.63,68.42 U400.A40
  BOTTOM w0.109: v1(44.46,27.1) JDIM2900.21
M_1_DQ_5<1>: length 91.9
  IN3 w0.089: v1(44.46,25.83) 44.06,26.24 44.06,27.8 50.09,33.83 50.38,33.83 50.47,33.74 50.47,33.39 50.56,33.3 50.74,33.3 50.83,33.39 50.83,33.74 50.92,33.83 51.09,33.83 51.18,33.74 51.18,33.39 51.27,33.3 51.45,33.3 51.54,33.39 51.54,33.74 51.63,33.83 51.8,33.83 51.89,33.74 51.89,33.39 51.98,33.3 52.16,33.3 52.25,33.39 52.25,33.74 52.34,33.83 52.52,33.83 52.6,33.74 52.6,33.39 52.69,33.3 52.87,33.3 52.96,33.39 52.96,33.74 53.05,33.83 53.23,33.83 53.32,33.74 53.32,33.39 53.4,33.3 53.58,33.3 53.67,33.39 53.67,33.74 53.76,33.83 53.94,33.83 54.03,33.74 54.03,33.39 54.12,33.3 54.29,33.3 54.38,33.39 54.38,33.74 54.47,33.83 54.65,33.83 54.74,33.74 54.74,33.45 54.83,33.36 55,33.36 55.09,33.45 55.09,33.74 55.18,33.83 64.2,33.83 77.55,47.18 79.82,47.18 88.44,55.8 94.23,55.8 97.33,58.9 97.33,64.21 95.96,65.58 95.96,66.67 97.08,67.79 98.52,67.79 v2(99.15,68.42)
  BOTTOM w0.079: U400.B40 101.22,68.52 100.77,68.07 99.51,68.07 99.16,68.42 v2(99.15,68.42)
  BOTTOM w0.109: v1(44.46,25.83) 43.46,26.83 JDIM2900.17
M_1_DQ_5<2>: length 92.5
  IN3 w0.089: v1(44.22,22.79) 43.84,22.79 43.75,22.88 43.75,23.99 43.84,24.08 44.7,24.08 44.79,24.16 44.79,24.34 44.7,24.43 43.84,24.43 43.75,24.52 43.75,27.9 49.97,34.12 64.08,34.12 77.43,47.47 79.7,47.47 88.32,56.09 94.19,56.09 97.03,58.93 97.03,63.95 95.65,65.33 95.65,66.8 96.9,68.04 98.27,68.04 98.59,68.36 v2(98.59,68.42)
  BOTTOM w0.079: v2(98.59,68.42) 98.63,68.42 99.14,67.91 100.83,67.91 101.15,68.23 101.69,68.23 102.03,68.57 U400.D40
  BOTTOM w0.109: JDIM2900.16 43.22,21.79 v1(44.22,22.79)
M_1_DQ_5<3>: length 93.6
  IN3 w0.089: v1(44.22,21.52) 43.38,22.35 43.38,24.17 43.29,24.26 42.87,24.26 42.77,24.35 42.77,24.52 42.87,24.61 43.29,24.61 43.38,24.7 43.38,27.95 49.85,34.41 63.96,34.41 77.31,47.76 79.58,47.76 88.2,56.38 94.12,56.38 96.75,59 96.75,63.75 95.35,65.15 95.35,66.95 96.47,68.07 96.47,68.53 96.74,68.8 97.18,68.8 97.47,68.51 v2(97.47,68.42)
  BOTTOM w0.079: v2(97.47,68.42) 98.19,67.7 101,67.7 101.17,67.54 102.58,67.54 102.73,67.7 102.73,68.27 U400.E41
  BOTTOM w0.109: v1(44.22,21.52) JDIM2900.20
M_1_DQ_5<4>: length 91
  IN3 w0.089: v2(99.24,69.27) 98.25,70.26 95.01,70.26 94.23,69.48 94.23,69 93.17,67.93 93.17,67 92.48,66.32 92.48,64.96 84.81,57.29 84.81,56.57 79.3,51.07 77.79,51.07 63.61,36.88 52.61,36.88 52.52,36.79 52.52,36.49 52.43,36.41 52.26,36.41 52.17,36.49 52.17,36.79 52.08,36.88 51.9,36.88 51.81,36.79 51.81,36.49 51.72,36.41 48.51,36.41 39.45,27.34 39.45,25.59 40.02,25.02 40.02,23.51 40.25,23.28 40.59,23.28 v1(40.72,23.41)
  BOTTOM w0.079: U400.A38 100.65,69.83 99.8,69.83 99.24,69.27 v2(99.24,69.27)
  BOTTOM w0.109: JDIM2900.8 41.22,22.91 v1(40.72,23.41)
M_1_DQ_5<5>: length 92
  IN3 w0.089: v2(98.13,69.27) 98.13,69.31 97.48,69.95 95.12,69.95 94.56,69.39 94.56,68.91 93.46,67.81 93.46,66.86 92.79,66.19 92.79,64.86 87.59,59.66 87.59,58.95 79.42,50.77 77.91,50.77 63.73,36.59 56.64,36.59 56.55,36.5 56.55,36.2 56.46,36.11 56.28,36.11 56.19,36.2 56.19,36.5 56.1,36.59 55.93,36.59 55.84,36.5 55.84,36.2 55.75,36.11 55.57,36.11 55.48,36.2 55.48,36.5 55.39,36.59 55.21,36.59 55.13,36.5 55.13,36.2 55.04,36.11 54.86,36.11 54.77,36.2 54.77,36.5 54.68,36.59 54.5,36.59 54.41,36.5 54.41,36.2 54.33,36.11 54.15,36.11 54.06,36.2 54.06,36.5 53.97,36.59 53.79,36.59 53.7,36.5 53.7,36.2 53.61,36.11 53.44,36.11 53.35,36.2 53.35,36.5 53.26,36.59 53.08,36.59 52.99,36.5 52.99,36.2 52.9,36.11 48.63,36.11 39.75,27.24 39.75,25.79 v1(40.46,25.08)
  BOTTOM w0.079: v2(98.13,69.27) 98.17,69.27 98.55,69.65 99.25,69.65 99.6,70.01 101.05,70.01 101.31,69.75 U400.B38
  BOTTOM w0.109: v1(40.46,25.08) 40.3,25.08 39.97,25.42 JDIM2900.3
M_1_DQ_5<6>: length 92.8
  IN3 w0.089: v1(40.46,26.35) 40.15,26.35 40.06,26.44 40.06,27.13 48.75,35.82 56.86,35.82 56.95,35.91 56.95,36.21 57.04,36.3 57.21,36.3 57.3,36.21 57.3,35.91 57.39,35.82 57.57,35.82 57.66,35.91 57.66,36.21 57.75,36.3 57.93,36.3 58.01,36.21 58.01,35.91 58.1,35.82 58.28,35.82 58.37,35.91 58.37,36.21 58.46,36.3 58.64,36.3 58.73,36.21 58.73,35.91 58.81,35.82 58.99,35.82 59.08,35.91 59.08,36.21 59.17,36.3 59.35,36.3 59.44,36.21 59.44,35.91 59.53,35.82 59.7,35.82 59.79,35.91 59.79,36.21 59.88,36.3 60.06,36.3 60.15,36.21 60.15,35.91 60.24,35.82 60.41,35.82 60.5,35.91 60.5,36.21 60.59,36.3 60.77,36.3 60.86,36.21 60.86,35.91 60.95,35.82 61.13,35.82 61.21,35.91 61.21,36.21 61.3,36.3 61.48,36.3 61.57,36.21 61.57,35.91 61.66,35.82 61.84,35.82 61.93,35.91 61.93,36.21 62.01,36.3 62.19,36.3 62.28,36.21 62.28,35.91 62.37,35.82 62.55,35.82 62.64,35.91 62.64,36.21 62.73,36.3 62.9,36.3 62.99,36.21 62.99,35.91 63.08,35.82 63.37,35.82 78.03,50.48 79.54,50.48 87.89,58.82 87.89,59.54 93.26,64.92 93.26,65.4 93.9,66.04 93.9,66.72 93.75,66.88 93.75,67.69 94.94,68.88 94.94,69.34 95.25,69.65 97.35,69.65 97.57,69.43 v2(97.57,69.27)
  BOTTOM w0.079: v2(97.57,69.27) 98.12,69.82 99.12,69.82 99.49,70.18 101.51,70.18 101.94,69.75 U400.D38
  BOTTOM w0.109: JDIM2900.7 40.97,26.61 40.71,26.35 v1(40.46,26.35)
M_1_DQ_5<7>: length 93.4
  IN3 w0.089: v2(99.8,69.27) 98.51,70.56 94.9,70.56 93.88,69.54 93.88,69.06 92.87,68.05 92.87,67.14 92.18,66.45 92.18,65.07 84.48,57.37 84.48,56.66 79.18,51.36 77.67,51.36 63.49,37.17 51.49,37.17 51.4,37.08 51.4,36.79 51.31,36.7 51.13,36.7 51.04,36.79 51.04,37.08 50.96,37.17 50.78,37.17 50.69,37.08 50.69,36.79 50.6,36.7 48.39,36.7 39.14,27.45 39.14,25.46 39.72,24.89 39.72,23.14 v1(40.72,22.14)
  BOTTOM w0.079: v2(99.8,69.27) 99.8,69.3 100.13,69.62 100.49,69.62 100.64,69.48 101.19,69.48 101.24,69.53 101.52,69.53 101.56,69.57 101.82,69.57 101.91,69.48 102.31,69.48 102.58,69.75 U400.E38
  BOTTOM w0.109: JDIM2900.4 40.22,21.64 v1(40.72,22.14)
M_1_DQ_6<0>: length 73.4
  IN1 w0.079: v2(103.97,65.31) 103.97,65.09 102.66,63.78 102.66,63.04 100.82,61.2 100.82,57.66 77.11,33.95 76.89,33.95 76.32,34.51 76.21,34.51 76.1,34.4 76.1,34.29 76.72,33.67 76.72,33.56 76.61,33.45 76.5,33.45 75.88,34.06 75.77,34.06 75.66,33.95 75.66,33.84 76.27,33.23 76.27,33.11 76.16,33 76.05,33 75.43,33.62 75.32,33.62 75.21,33.51 75.21,33.4 75.83,32.78 75.83,32.67 75.71,32.55 75.61,32.55 74.99,33.17 74.88,33.17 74.77,33.06 74.77,32.95 75.38,32.34 75.38,32.22 75.27,32.11 75.16,32.11 74.58,32.69 74.39,32.69 70.34,28.63 60.92,28.63 v1(59.22,26.94)
  BOTTOM w0.109: U400.J47 104.33,65.66 v2(103.97,65.31) ; JDIM2900.79 58.97,27.19 v1(59.22,26.94)
M_1_DQ_6<1>: length 72.9
  IN1 w0.079: v2(102.68,66.23) 101.34,64.89 101.34,63.47 99.75,61.88 99.75,58.56 77.09,35.9 75.64,35.9 69.76,30.03 60.26,30.03 57.8,27.56 57.8,25.7 57.34,25.24 57.34,23.42 v1(56.72,22.8)
  BOTTOM w0.109: v1(56.72,22.8) 55.72,21.8 JDIM2900.66 ; U400.G47 102.93,66.23 v2(102.68,66.23)
M_1_DQ_6<2>: length 74.4
  IN1 w0.079: v2(103.97,66.07) 104.35,65.69 104.35,64.13 101.17,60.95 101.17,57.61 75.18,31.62 74.97,31.62 74.48,32.11 74.36,32.11 74.25,32 74.25,31.89 74.74,31.4 74.74,31.28 74.63,31.17 74.52,31.17 73.98,31.71 73.87,31.71 73.76,31.6 73.76,31.49 74.3,30.95 74.3,30.84 74.19,30.73 74.08,30.73 73.53,31.27 73.42,31.27 73.31,31.16 73.31,31.05 73.85,30.5 73.85,30.39 73.74,30.28 73.63,30.28 73.15,30.76 72.86,30.76 70.46,28.35 61.36,28.35 59.99,26.98 59.99,26.44 v1(59.22,25.67)
  BOTTOM w0.109: v2(103.97,66.07) 104.21,66.31 U400.J45 ; v1(59.22,25.67) 60.12,26.57 60.12,27.3 59.97,27.46 JDIM2900.83
M_1_DQ_6<3>: length 73.3
  IN1 w0.079: v2(102.97,66.72) 102.64,66.72 101.09,65.17 101.09,63.65 99.44,62 99.44,58.65 78.44,37.65 78.28,37.65 77.74,38.19 77.63,38.19 77.52,38.08 77.52,37.97 78.06,37.43 78.06,37.32 77.95,37.21 77.84,37.21 77.27,37.77 77.16,37.77 77.05,37.66 77.05,37.55 77.61,36.98 77.61,36.87 77.5,36.76 77.39,36.76 76.8,37.35 76.69,37.35 76.58,37.24 76.58,37.13 77.17,36.54 77.17,36.43 77.06,36.31 76.94,36.31 76.41,36.85 76.19,36.85 69.64,30.31 60.14,30.31 56.97,27.13 v1(56.97,26.9)
  BOTTOM w0.109: v2(102.97,66.72) 103.38,66.31 U400.G45 ; JDIM2900.71 v1(56.97,26.9)
M_1_DQ_6<4>: length 74.8
  IN1 w0.079: v2(103.97,67.87) 104.47,67.38 104.47,65.99 104.54,65.92 104.54,63.92 101.42,60.81 101.42,57.46 73.75,29.79 73.5,29.79 73,30.29 72.89,30.29 72.78,30.18 72.78,30.07 73.27,29.57 73.27,29.46 73.16,29.35 73.05,29.35 72.56,29.84 72.34,29.84 70.57,28.07 62.37,28.07 61.45,27.16 61.45,25.16 60.6,24.31 60.6,23.19 v1(60.22,22.81)
  BOTTOM w0.109: U400.J42 104.24,67.61 v2(103.97,67.87) ; JDIM2900.80 59.22,21.81 v1(60.22,22.81)
M_1_DQ_6<5>: length 76
  IN1 w0.079: v1(60.22,21.54) 60.88,22.21 60.88,24.18 61.74,25.03 61.74,27.04 62.49,27.79 72.09,27.79 72.22,27.92 72.22,28.1 71.67,28.66 71.67,28.77 71.78,28.88 71.89,28.88 72.41,28.36 72.52,28.36 72.63,28.48 72.63,28.59 72.11,29.1 72.11,29.19 72.23,29.3 72.36,29.3 72.86,28.8 73.16,28.8 101.67,57.32 101.67,60.65 105.28,64.26 105.28,67.45 v2(104.86,67.87)
  BOTTOM w0.109: U400.J41 104.8,67.87 v2(104.86,67.87) ; v1(60.22,21.54) JDIM2900.84
M_1_DQ_6<6>: length 74.9
  IN1 w0.079: v1(56.72,21.53) 55.55,22.7 55.55,25.35 56.26,26.06 56.26,27.22 59.91,30.87 69.41,30.87 77.81,39.27 79.27,39.27 98.75,58.76 98.75,62.18 100.61,64.03 100.61,65.59 102.7,67.69 102.88,67.69 103.08,67.9 v2(103.11,67.9)
  BOTTOM w0.109: v1(56.72,21.53) JDIM2900.70 ; v2(103.11,67.9) 103.14,67.9 U400.G41
M_1_DQ_6<7>: length 74.8
  IN1 w0.079: v2(103.08,67.31) 102.77,67.31 100.86,65.4 100.86,63.85 99.15,62.14 99.15,58.76 79.07,38.68 78.81,38.68 78.5,38.99 78.39,38.99 78.28,38.88 78.28,38.76 78.66,38.38 78.66,38.27 78.55,38.16 78.44,38.16 77.91,38.68 77.62,38.68 69.53,30.59 60.03,30.59 56.54,27.1 56.54,25.93 56.02,25.41 56.02,25.18 56.16,25.04 56.37,25.04 v1(56.97,25.63)
  BOTTOM w0.109: U400.G42 103.38,67.61 v2(103.08,67.31) ; v1(56.97,25.63) 55.97,26.63 JDIM2900.67
M_1_DQ_7<0>: length 91.2
  IN3 w0.089: v2(105.76,69.07) 105.75,69.07 105.33,68.65 105.33,64.26 103.55,62.48 102.87,62.48 100.81,60.43 100.81,58.06 94.49,51.74 90.12,51.74 81.5,43.13 79.23,43.13 64.04,27.94 63.65,27.94 63.56,28.02 63.56,28.22 63.47,28.31 63.29,28.31 63.21,28.22 63.21,28.02 63.12,27.94 62.94,27.94 62.85,28.02 62.85,28.22 62.76,28.31 62.58,28.31 62.49,28.22 62.49,28.02 62.41,27.94 62.23,27.94 62.14,28.02 62.14,28.22 62.05,28.31 61.87,28.31 61.78,28.22 61.78,28.02 61.69,27.94 61.52,27.94 61.43,28.02 61.43,28.22 61.34,28.31 61.16,28.31 61.07,28.22 61.07,28.02 60.98,27.94 60.81,27.94 60.72,28.02 60.72,28.22 60.63,28.31 60.45,28.31 60.36,28.22 60.36,28.02 60.27,27.94 60.09,27.94 60,28.02 60,28.22 59.92,28.31 59.74,28.31 59.65,28.22 59.65,28.02 59.56,27.94 59.38,27.94 59.29,28.02 59.29,28.22 59.2,28.31 59.03,28.31 58.94,28.22 58.94,28.02 58.85,27.94 58.67,27.94 58.58,28.02 58.58,28.22 58.49,28.31 58.32,28.31 58.23,28.22 58.23,28.02 58.14,27.94 57.96,27.94 57.87,28.02 57.87,28.22 57.78,28.31 57.6,28.31 57.52,28.22 57.52,28.02 57.43,27.94 57.25,27.94 57.16,28.02 57.16,28.22 57.07,28.31 56.89,28.31 56.8,28.22 56.8,28.02 56.62,27.84 50.34,27.84 49.2,26.7 49.2,23.31 v1(49.72,22.79)
  BOTTOM w0.109: U400.N38 105.76,69.21 v2(105.76,69.07) ; v1(49.72,22.79) 48.72,21.79 JDIM2900.38
M_1_DQ_7<1>: length 90.4
  IN3 w0.089: v2(104.86,69.07) 104.42,68.62 104.42,63.73 103.48,62.79 102.74,62.79 100.53,60.58 100.53,58.18 94.39,52.04 90,52.04 81.38,43.42 79.11,43.42 64.29,28.6 56.48,28.6 56.39,28.51 56.39,28.3 56.3,28.21 56.13,28.21 56.04,28.3 56.04,28.51 55.95,28.6 55.77,28.6 55.68,28.51 55.68,28.31 55.59,28.22 55.42,28.22 55.33,28.31 55.33,28.51 55.24,28.6 55.06,28.6 54.97,28.51 54.97,28.3 54.88,28.21 54.71,28.21 54.62,28.3 54.62,28.51 54.53,28.6 54.35,28.6 54.26,28.51 54.26,28.29 54.17,28.2 53.99,28.2 53.9,28.29 53.9,28.51 53.82,28.6 53.64,28.6 53.55,28.51 53.55,28.29 53.46,28.2 53.28,28.2 53.19,28.29 53.19,28.51 53.1,28.6 52.93,28.6 52.84,28.51 52.84,28.29 52.75,28.2 52.57,28.2 52.48,28.29 52.48,28.51 52.39,28.6 52.22,28.6 52.13,28.51 52.13,28.29 52.04,28.2 51.86,28.2 51.77,28.29 51.77,28.51 51.68,28.6 51.5,28.6 51.42,28.51 51.42,28.31 51.33,28.22 51.15,28.22 51.06,28.32 51.06,28.51 50.97,28.6 50.18,28.6 48.9,27.32 48.9,22.34 v1(49.72,21.52)
  BOTTOM w0.109: U400.L38 104.97,69.07 v2(104.86,69.07) ; v1(49.72,21.52) JDIM2900.42
M_1_DQ_7<2>: length 91.4
  IN3 w0.089: v1(46.22,22.79) 45.7,23.31 45.7,27.76 50.06,32.12 64.17,32.12 78.04,46 80.31,46 88.93,54.61 94.09,54.61 98.27,58.8 98.27,61.69 99.81,63.23 100.04,63.23 100.94,64.13 100.94,69.04 101.05,69.31 102.3,70.56 105.17,70.56 v2(105.75,69.98)
  BOTTOM w0.109: U400.L36 105.46,70.42 105.75,70.13 v2(105.75,69.98) ; JDIM2900.24 45.22,21.79 v1(46.22,22.79)
M_1_DQ_7<3>: length 92.4
  IN3 w0.089: v1(46.22,21.52) 45.39,22.34 45.39,27.87 49.94,32.42 64.05,32.42 77.92,46.29 80.19,46.29 88.81,54.91 94.05,54.91 97.97,58.82 97.97,61.82 99.68,63.54 100.05,63.54 100.68,64.17 100.68,69.05 100.85,69.45 102.21,70.81 105.55,70.81 v2(106.39,69.98)
  BOTTOM w0.109: v2(106.39,69.98) 106.39,70.17 U400.N36 ; v1(46.22,21.52) JDIM2900.28
M_1_DQ_7<4>: length 88.3
  IN3 w0.089: v2(103.97,69.07) 103.55,68.65 103.55,63.29 103.35,63.09 102.66,63.09 100.29,60.72 100.29,58.34 94.28,52.33 89.88,52.33 81.26,43.71 78.99,43.71 64.17,28.89 63.88,28.89 63.79,28.98 63.79,29.32 63.7,29.41 63.52,29.41 63.43,29.32 63.43,28.98 63.34,28.89 63.16,28.89 63.08,28.98 63.08,29.34 62.99,29.43 62.81,29.43 62.72,29.34 62.72,28.98 62.63,28.89 62.45,28.89 62.36,28.98 62.36,29.36 62.28,29.44 62.11,29.44 62.01,29.34 62.01,28.98 61.92,28.89 61.74,28.89 61.65,28.98 61.65,29.36 61.56,29.44 61.4,29.44 61.3,29.34 61.3,28.98 61.21,28.89 61.03,28.89 60.94,28.98 60.94,29.36 60.85,29.44 60.69,29.44 60.59,29.34 60.59,28.98 60.5,28.89 60.32,28.89 60.23,28.98 60.23,29.36 60.14,29.44 59.97,29.44 59.88,29.34 59.88,28.98 59.79,28.89 59.61,28.89 59.52,28.98 59.52,29.36 59.43,29.44 59.26,29.44 59.16,29.34 59.16,28.98 59.08,28.89 58.9,28.89 58.81,28.98 58.81,29.36 58.72,29.44 58.55,29.44 58.45,29.34 58.45,28.98 58.36,28.89 58.19,28.89 58.1,28.98 58.1,29.36 58.01,29.44 57.84,29.44 57.74,29.34 57.74,28.98 57.65,28.89 57.48,28.89 57.39,28.98 57.39,29.36 57.3,29.44 57.13,29.44 57.03,29.34 57.03,28.98 56.94,28.89 50.06,28.89 48.46,27.3 v1(48.46,27.09)
  BOTTOM w0.109: U400.H38 103.97,69.37 v2(103.97,69.07) ; v1(48.46,27.09) JDIM2900.37
M_1_DQ_7<5>: length 89.9
  IN3 w0.089: v2(103.85,69.98) 103.47,70.36 102.39,70.36 101.24,69.21 101.24,64.13 98.58,61.47 98.58,58.77 94.12,54.32 89.05,54.32 80.43,45.7 78.16,45.7 64.28,31.82 54.56,31.82 54.47,31.73 54.47,31.53 54.38,31.44 54.2,31.44 54.11,31.53 54.11,31.73 54.02,31.82 53.84,31.82 53.76,31.73 53.76,31.53 53.67,31.44 53.49,31.44 53.4,31.53 53.4,31.73 53.31,31.82 53.13,31.82 53.04,31.73 53.04,31.53 52.96,31.44 52.78,31.44 52.69,31.53 52.69,31.73 52.6,31.82 52.42,31.82 52.33,31.73 52.33,31.53 52.24,31.44 52.07,31.44 51.98,31.53 51.98,31.73 51.89,31.82 51.71,31.82 51.62,31.73 51.62,31.53 51.53,31.44 51.35,31.44 51.27,31.53 51.27,31.73 51.16,31.83 50.94,31.83 50.86,31.76 50.86,31.53 50.77,31.44 50.55,31.44 50.48,31.51 50.48,31.7 50.39,31.79 50.13,31.79 46,27.65 46,25.95 46.19,25.76 46.37,25.76 v1(46.46,25.85)
  BOTTOM w0.109: JDIM2900.25 45.46,26.04 45.65,25.85 v1(46.46,25.85) ; v2(103.85,69.98) 103.85,70.1 104.16,70.42 U400.H36
M_1_DQ_7<6>: length 88.5
  IN3 w0.089: v1(46.46,27.12) 46.33,27.26 46.33,27.57 49.91,31.15 54.66,31.15 54.74,31.23 54.74,31.44 54.83,31.53 55.01,31.53 55.1,31.44 55.1,31.23 55.19,31.15 55.37,31.15 55.46,31.23 55.46,31.44 55.54,31.53 55.72,31.53 55.81,31.44 55.81,31.23 55.9,31.15 56.08,31.15 56.17,31.23 56.17,31.44 56.26,31.53 56.43,31.53 56.52,31.44 56.52,31.23 56.61,31.15 56.79,31.15 56.88,31.23 56.88,31.44 56.97,31.53 57.15,31.53 57.23,31.44 57.23,31.23 57.32,31.15 57.5,31.15 57.59,31.23 57.59,31.44 57.68,31.53 57.86,31.53 57.95,31.44 57.95,31.23 58.03,31.15 58.21,31.15 58.3,31.23 58.3,31.44 58.39,31.53 58.57,31.53 58.66,31.44 58.66,31.23 58.75,31.15 58.92,31.15 59.01,31.23 59.01,31.44 59.1,31.53 59.28,31.53 59.37,31.44 59.37,31.23 59.46,31.15 59.63,31.15 59.72,31.23 59.72,31.44 59.81,31.53 59.99,31.53 60.08,31.44 60.08,31.23 60.17,31.15 60.35,31.15 60.43,31.23 60.43,31.44 60.52,31.53 60.7,31.53 60.79,31.44 60.79,31.23 60.88,31.15 61.06,31.15 61.15,31.23 61.15,31.44 61.23,31.53 61.41,31.53 61.5,31.44 61.5,31.23 61.59,31.15 61.77,31.15 61.86,31.23 61.86,31.44 61.95,31.53 62.12,31.53 62.21,31.44 62.21,31.23 62.3,31.15 62.48,31.15 62.57,31.23 62.57,31.44 62.66,31.53 62.83,31.53 62.92,31.44 62.92,31.23 63.01,31.15 63.19,31.15 63.28,31.23 63.28,31.44 63.37,31.53 63.55,31.53 63.63,31.44 63.63,31.23 63.72,31.15 64.02,31.15 78.28,45.41 80.55,45.41 89.17,54.03 94.16,54.03 98.88,58.75 98.88,61.36 101.47,63.95 101.47,69.11 102.34,69.98 v2(103.13,69.98)
  BOTTOM w0.109: v2(103.13,69.98) 103.51,70.36 U400.G36 ; v1(46.46,27.12) JDIM2900.29
M_1_DQ_7<7>: length 88.3
  IN3 w0.089: v1(48.46,25.82) 47.9,26.38 47.9,27.15 49.94,29.18 52.27,29.18 52.35,29.27 52.35,29.65 52.44,29.74 52.62,29.74 52.71,29.65 52.71,29.27 52.8,29.18 52.98,29.18 53.07,29.27 53.07,29.65 53.15,29.74 53.33,29.74 53.42,29.65 53.42,29.27 53.51,29.18 53.69,29.18 53.78,29.27 53.78,29.65 53.87,29.74 54.04,29.74 54.13,29.65 54.13,29.27 54.22,29.18 54.4,29.18 54.49,29.27 54.49,29.65 54.58,29.74 54.76,29.74 54.84,29.65 54.84,29.27 54.93,29.18 55.11,29.18 55.2,29.27 55.2,29.65 55.29,29.74 55.47,29.74 55.56,29.65 55.56,29.27 55.64,29.18 55.82,29.18 55.91,29.27 55.91,29.65 56,29.74 56.18,29.74 56.27,29.65 56.27,29.27 56.36,29.18 56.53,29.18 56.62,29.27 56.62,29.65 56.71,29.74 64.6,29.74 78.87,44 81.14,44 89.76,52.62 94.17,52.62 99.99,58.44 99.99,60.79 102.74,63.54 102.74,63.83 102.87,63.95 102.87,64.64 102.28,65.22 102.28,67.13 102.74,67.58 102.74,68.72 103.06,69.04 v2(103.06,69.07)
  BOTTOM w0.109: U400.G38 103.06,69.11 v2(103.06,69.07) ; JDIM2900.41 49.46,26.82 v1(48.46,25.82)
M_A_A0: length 65.2
  IN1 w0.102: v2(125.88,67.97) 125.87,68 125.12,68.35 124.41,68.35 123.98,68.22 123.79,68.03 123.79,65.05 125.63,59.76 125.63,55.29 127.14,53.78 127.14,47.27 130.38,44.03 130.38,42.09 141.46,31.01 143.96,30.45 147.52,26.89 147.52,23.89 147.53,23.82 147.6,23.67 v1(147.9,23.28)
  BOTTOM w0.14: JDIM2800.144 152.17,22.31 151.99,23.03 151.64,23.38 151.08,23.56 150.14,23.56 v1(147.9,23.28) ; v2(125.88,67.97) U400.BV41
M_A_A1: length 61.2
  IN1 w0.102: v2(129.63,59.36) 129.23,58.97 129.23,56.79 132.69,53.34 132.69,50.8 141.78,41.7 141.78,41.39 141.31,40.92 141.31,40.78 141.46,40.63 141.6,40.63 142.15,41.19 142.3,41.19 142.44,41.04 142.44,40.9 141.89,40.34 141.89,40.2 142.03,40.06 142.17,40.06 142.73,40.61 142.87,40.61 143.02,40.47 143.02,40.32 142.49,39.8 142.49,39.59 142.62,39.45 142.79,39.45 143.04,39.7 143.18,39.7 143.32,39.55 143.32,39.41 143.08,39.17 143.08,39 146.08,36 146.77,36 152.34,30.42 152.34,29.74 153.61,28.46 153.61,27.67 153.17,27.23 153.17,25.01 v1(152.95,24.78)
  BOTTOM w0.14: JDIM2800.133 149.43,27.5 149.25,27.32 149.25,26.91 149.94,25.42 150.7,24.65 152.24,24.65 152.37,24.78 v1(152.95,24.78) ; v2(129.63,59.36) 130.02,59.76 130.02,61.97 129.54,62.46 129.54,63.02 U400.CE52
M_A_A2: length 62.9
  IN1 w0.102: v1(149.17,21.5) 149.55,21.13 151.65,21.13 152.11,21.59 152.11,23.33 152.01,23.44 151.7,23.44 151.6,23.54 151.6,23.74 151.7,23.84 152.01,23.84 152.11,23.94 152.11,24.15 152.01,24.25 151.38,24.25 151.27,24.36 151.27,24.55 151.37,24.65 151.93,24.65 152.11,24.83 152.11,25.13 152.33,25.36 152.33,28.02 149.69,30.66 149.69,31.35 146.26,34.78 145.58,34.78 136.2,44.15 136.2,45.55 131.43,50.33 131.43,53.38 128.42,56.39 128.42,59.38 128.92,59.87 128.92,61.58 125.93,64.56 v2(125.93,65.37)
  BOTTOM w0.14: v2(125.93,65.37) 126.22,65.66 U400.BV47 ; v1(149.17,21.5) JDIM2800.132
M_A_A3: length 59.9
  IN1 w0.102: v2(129.63,61.04) 130.07,60.6 130.07,56.41 133.11,53.38 133.11,50.95 143.73,40.33 143.73,38.94 146.27,36.4 146.94,36.4 152.75,30.59 152.75,29.9 154.03,28.62 154.03,27.5 153.59,27.05 153.59,24.69 153.44,24.53 153.44,22.76 153.34,22.66 153.06,22.66 152.95,22.77 v1(152.95,23.51)
  BOTTOM w0.14: v2(129.63,61.04) 129.63,62.02 129.17,62.48 U400.CD53 ; JDIM2800.131 148.93,26.79 149.7,25.03 150.52,24.21 152.25,24.21 v1(152.95,23.51)
M_A_A4: length 60.9
  IN1 w0.102: v2(129.63,59.92) 129,59.3 129,56.67 132.27,53.4 132.27,50.64 141.2,41.71 141.2,41.41 140.79,41 140.79,40.71 145.91,35.59 146.6,35.59 151.94,30.25 151.94,29.57 153.2,28.31 153.2,27.85 152.75,27.4 152.75,25.18 152.53,24.95 152.53,21.41 151.82,20.71 148.12,20.71 147.9,20.93 147.9,21.27 v1(148.17,21.55)
  BOTTOM w0.079: U400.CD51 129.17,63.58 128.94,63.35 128.94,62.31 129.25,62 129.25,60.3 v2(129.63,59.92)
  BOTTOM w0.14: v1(148.17,21.55) JDIM2800.128
M_A_A5: length 62.7
  IN1 w0.102: v1(148.18,22.19) 148.5,22.19 148.84,22.52 148.84,22.91 149.62,23.69 149.62,27.67 147.52,29.76 147.52,30.45 145.36,32.61 144.68,32.61 143.51,33.78 143.25,33.78 142.48,33.02 142.34,33.02 142.2,33.16 142.2,33.3 143.02,34.13 143.02,34.27 142.87,34.41 142.73,34.41 141.91,33.59 141.77,33.59 141.62,33.74 141.62,33.88 142.44,34.7 142.44,34.84 142.3,34.99 142.15,34.99 141.33,34.17 141.19,34.17 141.05,34.31 141.05,34.45 141.83,35.24 141.83,35.45 129.23,48.05 129.23,53.74 127.1,55.88 127.1,59.83 v2(126.45,60.48)
  BOTTOM w0.079: U400.BY50 127.31,63.94 127.49,63.76 127.49,62.49 127.06,62.06 127.06,61.09 v2(126.45,60.48)
  BOTTOM w0.14: JDIM2800.126 147.68,21.68 v1(148.18,22.19)
M_A_A6: length 62
  IN1 w0.102: v1(147.9,27.1) 147.88,27.1 144,30.98 143.45,30.98 143.05,31.38 141.67,31.38 134.04,39 134.04,39.15 134.37,39.47 134.37,39.62 134.22,39.76 134.08,39.76 133.76,39.43 133.61,39.43 133.47,39.58 133.47,39.75 134.26,40.54 134.26,40.72 134.15,40.84 133.98,40.84 133.18,40.03 133.02,40.03 132.89,40.15 132.89,40.32 133.7,41.13 133.7,41.29 133.56,41.43 133.42,41.43 132.61,40.61 132.43,40.61 132.32,40.73 132.32,40.9 133.13,41.71 133.13,41.85 132.99,42 132.84,42 132.68,41.83 132.02,41.17 131.87,41.17 131.74,41.3 131.74,41.47 132.1,41.83 132.56,42.29 132.56,42.42 132.42,42.57 132.26,42.57 131.53,41.83 131.45,41.76 131.29,41.76 131.17,41.88 131.17,42.05 131.99,42.87 131.99,43 131.84,43.14 131.69,43.14 131.05,42.5 130.9,42.5 130.78,42.61 130.78,42.81 131.37,43.4 131.37,43.62 127.56,47.43 127.56,53.77 125.85,55.48 125.85,61.55 v2(126.45,62.15)
  BOTTOM w0.079: v2(126.45,62.15) 126.83,62.54 126.83,62.89 127.23,63.29 U400.BY52
  BOTTOM w0.14: v1(147.9,27.1) 147.93,27.13 JDIM2800.127
M_A_A7: length 62.8
  IN1 w0.102: v2(126.45,59.92) 126.85,59.53 126.85,55.69 128.81,53.72 128.81,47.9 140.05,36.66 140.05,36.4 139.41,35.76 139.41,35.62 139.56,35.47 139.7,35.47 140.32,36.09 140.47,36.09 140.61,35.95 140.61,35.8 139.89,35.07 139.89,34.93 140.03,34.79 140.18,34.79 140.95,35.56 141.09,35.56 141.24,35.42 141.24,35.27 140.56,34.6 140.56,34.21 142.17,32.6 143.1,32.6 143.2,32.7 143.2,33.09 143.3,33.2 143.5,33.2 143.61,33.09 143.61,32.7 144.1,32.2 145.2,32.2 146.88,30.52 147.12,30.28 147.12,29.59 149.2,27.51 149.2,23.85 147.95,22.6 147.63,22.6 v1(147.19,22.16)
  BOTTOM w0.079: 127.53,61.8 127.53,62.22 128.12,62.8 128.12,64.04 U400.CA50
  BOTTOM w0.14: JDIM2800.122 146.68,21.65 v1(147.19,22.16) ; v2(126.45,59.92) 127.53,61 127.53,61.8
M_A_A8: length 60.3
  IN1 w0.102: v2(126.45,61.6) 126.06,61.21 126.06,55.67 127.98,53.76 127.98,47.58 134.84,40.72 134.84,40.42 134.57,40.16 134.57,39.99 134.72,39.84 134.84,39.84 135.19,40.2 135.36,40.2 135.5,40.06 135.5,39.94 134.67,39.1 134.67,38.95 134.81,38.81 134.95,38.81 135.76,39.62 135.94,39.62 136.05,39.51 136.05,39.34 135.24,38.52 135.24,38.38 135.38,38.24 135.53,38.24 136.36,39.06 136.5,39.06 136.65,38.91 136.65,38.78 135.82,37.95 135.82,37.8 135.96,37.66 136.1,37.66 136.92,38.48 137.08,38.48 137.21,38.35 137.21,38.19 136.42,37.4 136.42,37.2 141.84,31.78 143.22,31.78 143.61,31.39 144.86,31.39 146.3,29.94 146.3,29.26 148.36,27.2 148.36,26.29 v1(147.9,25.83)
  BOTTOM w0.079: v2(126.45,61.6) 126.83,61.98 126.83,62.22 U400.BY53
  BOTTOM w0.14: JDIM2800.125 147.43,26.31 v1(147.9,25.83)
M_A_A9: length 64.5
  IN1 w0.102: v1(145.34,26.19) 143.08,28.45 140,28.45 134.7,33.76 134.7,33.9 135.13,34.32 135.13,34.47 134.98,34.61 134.84,34.61 134.42,34.19 134.27,34.19 134.13,34.33 134.13,34.47 134.55,34.9 134.55,35.04 134.41,35.18 134.26,35.18 133.84,34.76 133.7,34.76 133.55,34.91 133.55,35.05 133.98,35.47 133.98,35.62 133.83,35.76 133.69,35.76 133.26,35.34 133.12,35.34 132.98,35.48 132.98,35.62 133.4,36.05 133.4,36.19 133.26,36.33 133.11,36.33 132.69,35.91 132.55,35.91 132.4,36.06 132.4,36.2 132.83,36.62 132.83,36.77 132.68,36.91 132.54,36.91 132.11,36.49 131.97,36.49 131.83,36.63 131.83,36.77 132.25,37.2 132.25,37.34 132.11,37.48 131.96,37.48 131.54,37.06 131.4,37.06 131.25,37.21 131.25,37.35 131.68,37.77 131.68,37.92 131.53,38.06 131.39,38.06 130.96,37.64 130.82,37.64 130.68,37.78 130.68,37.92 131.1,38.35 131.1,38.49 130.96,38.63 130.81,38.63 130.39,38.21 130.25,38.21 130.1,38.36 130.1,38.5 130.53,38.92 130.53,39.07 130.38,39.22 130.24,39.22 129.93,38.91 129.79,38.91 129.65,39.06 129.65,39.2 129.89,39.45 129.89,39.7 126.28,43.32 126.28,45.26 125.56,45.97 125.56,53.35 124.66,54.25 124.66,58.13 v2(123.78,59.01)
  BOTTOM w0.14: JDIM2800.121 146.43,27.4 145.34,26.32 v1(145.34,26.19) ; v2(123.78,59.01) 125.04,60.27 125.04,63.14 125.19,63.29 125.52,63.29 125.98,63.75 U400.BU50
M_A_A10: length 63.7
  IN1 w0.102: v1(154.84,23.42) 154.84,23.78 154.43,24.2 154.43,26.71 154.86,27.14 154.86,28.94 153.56,30.24 153.56,30.93 147.27,37.21 146.63,37.21 145.51,38.33 145.51,38.63 145.97,39.09 145.97,39.24 145.83,39.38 145.68,39.38 145.16,38.85 145.01,38.85 144.87,39 144.87,39.14 145.4,39.67 145.4,39.81 145.25,39.95 145.11,39.95 144.81,39.66 144.69,39.66 144.55,39.8 144.55,39.97 144.82,40.24 144.82,40.39 133.94,51.26 133.94,53.38 130.63,56.69 130.63,61.21 127.1,64.74 127.07,64.77 127.07,65.89 126.38,66.58 126.38,66.88 v2(125.93,67.32)
  BOTTOM w0.14: v1(154.84,23.42) 154.4,22.98 154.4,21.3 154.68,21.03 JDIM2800.146 ; U400.BV42 126.22,67.61 v2(125.93,67.32)
M_A_A11: length 62.7
  IN1 w0.102: v2(123.78,59.57) 124.89,58.46 124.89,54.53 125.93,53.49 125.93,46.18 126.68,45.43 126.68,43.49 135.69,34.48 135.69,34.29 135.29,33.88 135.29,33.74 135.44,33.6 135.58,33.6 135.98,34 136.12,34 136.27,33.86 136.27,33.71 135.87,33.31 135.87,33.17 136.01,33.02 136.15,33.02 136.56,33.42 136.7,33.42 136.84,33.28 136.84,33.14 136.67,32.97 136.44,32.73 136.44,32.59 136.59,32.45 136.73,32.45 137.13,32.85 137.27,32.85 137.42,32.71 137.42,32.56 137.19,32.33 137.02,32.16 137.02,32.02 137.16,31.87 137.3,31.87 137.71,32.27 137.85,32.27 137.99,32.13 137.99,31.99 137.59,31.58 137.59,31.44 137.74,31.3 137.88,31.3 138.28,31.7 138.42,31.7 138.57,31.56 138.57,31.41 138.17,31.01 138.17,30.87 140.17,28.86 143.25,28.86 145.73,26.38 145.73,25.97 145.38,25.62 145.38,24.11 145.67,23.82 v1(145.67,22.14)
  BOTTOM w0.14: v2(123.78,59.57) 124.43,60.21 124.43,63.47 124.57,63.61 U400.BT51 ; v1(145.67,22.14) 146.17,21.63 JDIM2800.120
M_A_A12: length 63.4
  IN1 w0.102: v1(147.9,24.56) 148.78,25.44 148.78,27.36 146.71,29.42 146.71,30.11 145.03,31.79 143.78,31.79 143.39,32.19 142.01,32.19 138.76,35.44 138.76,35.7 139.44,36.38 139.44,36.5 139.3,36.64 139.13,36.64 138.41,35.93 138.27,35.93 138.12,36.07 138.12,36.21 138.87,36.96 138.87,37.1 138.72,37.24 138.58,37.24 137.84,36.5 137.69,36.5 137.55,36.65 137.55,36.79 138.37,37.61 138.37,37.75 138.22,37.9 138.08,37.9 137.26,37.08 137.12,37.08 136.97,37.22 136.97,37.36 137.72,38.11 137.72,38.42 128.39,47.74 128.39,53.77 126.57,55.6 126.57,58.69 126.48,58.78 126.48,58.78 v2(126.45,58.8)
  BOTTOM w0.14: JDIM2800.119 145.93,27.53 144.9,26.51 144.9,25.96 145.26,25.6 146.8,25.6 147.84,24.56 v1(147.9,24.56) ; U400.BU53 125.98,59.27 v2(126.45,58.8)
M_A_A13: length 62.3
  IN1 w0.102: v2(129.59,67.97) 129.08,67.46 129.08,65.38 129.97,64.48 129.97,64.16 130.71,63.42 131.55,63.42 132.46,62.51 132.46,58.39 132.84,58.01 132.84,56.56 136.04,53.36 136.04,52.04 156.5,31.59 156.5,30.18 156.98,29.7 156.98,26.47 156.6,26.1 156.6,23.12 157.02,22.71 v1(158.17,22.71)
  BOTTOM w0.14: v2(129.59,67.97) 129.88,68.26 U400.CF41 ; JDIM2800.158 157.68,22.21 v1(158.17,22.71)
M_A_ACT#: length 63.2
  IN1 w0.102: v1(144.23,22.15) 145.12,22.15 145.24,22.27 145.24,22.51 145.13,22.61 144.75,22.61 144.63,22.74 144.63,22.93 144.75,23.06 145.08,23.06 145.22,23.2 145.22,23.66 144.98,23.91 144.98,25.99 142.91,28.05 139.84,28.05 128.93,38.95 128.93,39.23 129.28,39.58 129.28,39.72 129.14,39.87 128.99,39.87 128.58,39.45 128.43,39.45 128.29,39.59 128.29,39.74 128.71,40.16 128.71,40.3 128.56,40.44 128.42,40.44 128,40.03 127.86,40.03 127.71,40.17 127.71,40.31 128.13,40.73 128.13,40.87 127.99,41.02 127.84,41.02 127.43,40.6 127.28,40.6 127.14,40.74 127.14,40.89 127.56,41.31 127.56,41.45 127.41,41.59 127.27,41.59 126.85,41.18 126.71,41.18 126.56,41.32 126.56,41.46 126.98,41.88 126.98,42.03 126.84,42.17 126.69,42.17 126.28,41.75 126.13,41.75 125.98,41.9 125.98,42.06 126.39,42.47 126.39,42.63 125.87,43.15 125.87,45.09 125.17,45.79 125.17,53.29 124.41,54.05 124.41,57.27 v2(123.78,57.89)
  BOTTOM w0.14: v2(123.78,57.89) 124.99,59.1 v1(124.99,59.15) 124.99,59.48 125.35,59.84 U400.BT53 ; JDIM2800.114 144.68,21.71 v1(144.23,22.15)
M_A_ALERT#: length 64.3
  IN1 w0.102: v2(123.19,55.19) 123.19,53.82 124.03,52.98 124.03,44.85 124.24,44.64 124.24,41.32 130.38,35.19 130.38,33.76 136.28,27.86 137.72,27.86 138.96,26.62 138.96,24.99 139.77,24.18 142.5,24.18 143.25,23.42 v1(144.23,23.42)
  BOTTOM w0.14: U400.AU50 117.32,63.66 117.32,61.33 116.63,60.65 116.63,55.34 118.67,53.31 120.88,53.31 122.76,55.19 v2(123.19,55.19) ; v1(144.23,23.42) 144.93,22.72 144.93,22.2 145.17,21.96 JDIM2800.116
M_A_BG#0: length 64.4
  IN1 w0.102: v1(143.91,25.52) 142.97,24.58 139.94,24.58 139.37,25.16 139.37,26.79 137.89,28.27 136.45,28.27 134.74,29.97 134.74,30.28 135.18,30.71 135.18,30.86 135.03,31 134.89,31 134.37,30.49 134.23,30.49 134.09,30.63 134.09,30.77 134.6,31.29 134.6,31.43 134.46,31.58 134.31,31.58 133.8,31.06 133.65,31.06 133.51,31.21 133.51,31.35 134.03,31.87 134.03,32.01 133.88,32.15 133.74,32.15 133.22,31.64 133.08,31.64 132.94,31.78 132.94,31.92 133.43,32.41 133.43,32.56 133.28,32.7 133.14,32.7 132.65,32.21 132.5,32.21 132.36,32.36 132.36,32.5 132.88,33.02 132.88,33.16 132.73,33.3 132.59,33.3 132.07,32.79 131.93,32.79 131.79,32.93 131.79,33.07 132.3,33.59 132.3,33.71 132.16,33.85 131.99,33.85 131.5,33.36 131.35,33.36 131.21,33.51 131.21,33.65 131.72,34.16 131.72,34.41 124.65,41.49 124.65,44.71 124.43,44.93 124.43,53.08 123.62,53.9 123.62,56.21 123.39,56.44 123.39,61.97 v2(123.78,62.36)
  BOTTOM w0.079: v2(123.78,62.36) 123.66,62.49 123.66,62.89 123.43,63.12 U400.BL52
  BOTTOM w0.14: JDIM2800.115 144.93,27.3 144.47,26.85 144.47,26.09 v1(143.91,25.52)
M_A_BG#1: length 65
  IN1 w0.102: v2(123.78,61.24) 123.96,61.24 124.03,61.31 124.48,61.31 124.74,61.06 124.74,60.5 125.02,60.22 125.02,59.81 125.4,59.43 125.4,55.01 126.72,53.69 126.72,47.12 128.34,45.5 128.34,45.35 127.9,44.92 127.9,44.78 128.04,44.64 128.2,44.64 128.63,45.07 128.77,45.07 128.91,44.92 128.91,44.78 128.08,43.95 128.08,43.81 128.23,43.66 128.37,43.66 129.2,44.49 129.34,44.49 129.49,44.35 129.49,44.2 128.67,43.39 128.67,43.22 128.81,43.09 128.94,43.09 129.62,43.76 129.77,43.76 129.97,43.56 129.97,43.1 129.86,42.99 129.45,42.99 129.33,42.87 129.33,42.64 129.41,42.57 129.84,42.57 129.97,42.44 129.97,41.93 141.82,30.08 143.76,30.08 147.11,26.72 147.11,25.22 147.04,25.14 v1(146.63,25.14)
  BOTTOM w0.079: U400.BN50 123.82,64.01 123.82,62.85 124.14,62.53 124.14,61.6 v2(123.78,61.24)
  BOTTOM w0.14: JDIM2800.113 144.43,27.4 143.43,25.73 143.43,25.37 143.76,25.04 145.55,25.04 146.43,25.12 v1(146.63,25.14)
M_A_BS#0: length 63.6
  IN1 w0.102: v1(154.84,22.15) 154.58,21.89 154.3,21.89 153.91,22.29 153.91,22.42 154.01,22.52 154.3,22.52 154.4,22.63 154.4,22.83 154.3,22.93 153.95,22.93 153.85,23.03 153.85,23.23 153.95,23.34 154.3,23.34 154.4,23.44 154.4,23.64 154.3,23.74 153.98,23.74 153.85,23.87 153.85,24.28 154.01,24.44 154.01,26.88 154.45,27.32 154.45,28.77 153.16,30.07 153.16,30.76 147.11,36.81 146.44,36.81 144.14,39.11 144.14,40.5 133.53,51.11 133.53,53.39 130.38,56.54 130.38,61.01 126.87,64.51 126.67,64.72 126.67,65.94 v2(125.93,66.67)
  BOTTOM w0.14: v1(154.84,22.15) 155.3,22.6 155.55,22.6 155.68,22.48 JDIM2800.150 ; U400.BV44 126.22,66.96 v2(125.93,66.67)
M_A_BS#1: length 62.1
  IN1 w0.102: v2(127.76,67.32) 128.29,66.79 128.29,66.51 128.78,66.02 128.78,65.38 129.72,64.44 129.72,64.01 130.68,63.04 131.62,63.04 132.24,62.42 132.24,56.68 135.62,53.3 135.62,51.89 155.75,31.76 155.75,31.58 155.22,31.05 155.22,30.89 155.35,30.76 155.5,30.76 155.8,31.05 155.97,31.05 156.09,30.94 156.09,30.77 155.8,30.48 155.8,30.3 156.54,29.57 156.54,26.62 156.2,26.28 156.2,24.7 156.11,24.61 155.78,24.61 155.69,24.7 v1(155.69,25.14)
  BOTTOM w0.14: U400.CB42 128.05,67.61 v2(127.76,67.32) ; JDIM2800.145 154.43,26.4 v1(155.69,25.14)
M_A_CAS#: length 62.6
  IN1 w0.102: v2(127.76,66.67) 128.52,65.92 128.52,65.32 129.42,64.42 129.42,63.89 131.47,61.85 131.47,57.04 135.2,53.3 135.2,51.73 154.02,32.92 154.02,32.77 153.82,32.58 153.82,32.43 153.96,32.29 154.11,32.29 154.3,32.49 154.45,32.49 154.6,32.34 154.6,32.19 154.39,31.98 154.39,31.84 154.53,31.7 154.67,31.7 154.88,31.91 155.03,31.91 155.18,31.75 155.18,31.58 154.78,31.18 154.78,30.75 156.13,29.4 156.13,26.81 155.25,25.93 155.25,24.52 155.57,24.2 156.06,24.2 156.13,24.13 156.13,23.9 156.03,23.8 155.76,23.8 155.66,23.7 155.66,23.3 v1(156.17,22.78)
  BOTTOM w0.14: JDIM2800.156 157.17,21.78 v1(156.17,22.78) ; U400.CB44 128.05,66.96 v2(127.76,66.67)
M_A_CB0: length 2.9
  TOP w0.109: R2802.2 138.67,22.18 v1(138.68,22.18)
  BOTTOM w0.109: JDIM2800.92 139.17,21.68 v1(138.68,22.18)
M_A_CB1: length 4.4
  TOP w0.109: v1(137.93,25.21) 138.01,25.3 R2803.2
  BOTTOM w0.109: v1(137.93,25.21) 138.93,26.21 JDIM2800.91
M_A_CB2: length 4.5
  TOP w0.109: v1(142.43,25.15) 142.12,25.45 R2804.2
  BOTTOM w0.109: v1(142.43,25.15) 141.43,26.15 JDIM2800.101
M_A_CB3: length 2.2
  TOP w0.109: R2805.2 143.12,27.05 v1(142.43,27.05)
  BOTTOM w0.109: v1(142.43,27.05) JDIM2800.105
M_A_CB4: length 4.1
  TOP w0.109: v1(138.68,23.45) 138.74,23.39 139.34,23.39 R2806.2
  BOTTOM w0.109: v1(138.68,23.45) 138.17,22.95 JDIM2800.88
M_A_CB5: length 2.2
  TOP w0.109: R2807.2 138.22,26.82 v1(137.93,27.12)
  BOTTOM w0.109: v1(137.93,27.12) JDIM2800.87
M_A_CB6: length 3.1
  TOP w0.109: v1(140.68,22.2) 140.29,21.82 R2808.2
  BOTTOM w0.109: JDIM2800.100 141.17,21.7 v1(140.68,22.2)
M_A_CB7: length 1.9
  TOP w0.109: v1(142.17,21.51) 142.82,21.51 R2809.2
  BOTTOM w0.109: v1(142.17,21.51) JDIM2800.104
M_A_CKE0: length 62.3
  IN1 w0.102: v1(146.63,23.87) 146,24.5 146,25.38 146.34,25.72 146.34,26.64 143.5,29.47 141.56,29.47 141.06,29.98 140.91,29.98 140.51,29.58 140.37,29.58 140.23,29.72 140.23,29.86 140.63,30.26 140.63,30.41 140.48,30.55 140.34,30.55 139.94,30.15 139.8,30.15 139.65,30.3 139.65,30.44 140.05,30.84 140.05,30.98 139.91,31.13 139.76,31.13 139.36,30.73 139.22,30.73 139.08,30.87 139.08,31.01 139.48,31.41 139.48,31.56 127.29,43.74 127.29,45.68 126.35,46.62 126.35,53.55 125.14,54.76 125.14,59.17 124.33,59.99 124.33,60.14 v2(123.78,60.68)
  BOTTOM w0.079: v2(123.78,60.68) 123.15,61.32 123.15,63.53 123.43,63.81 U400.BL50
  BOTTOM w0.14: v1(146.63,23.87) 146.61,23.88 144.7,24.64 143.78,24.64 143.13,25.28 143.13,26.14 143.43,26.83 JDIM2800.109
M_A_CKE1: length 59.4
  IN1 w0.102: v2(123.78,57.33) 124.17,56.94 124.17,53.83 124.81,53.19 124.81,45.29 125.26,44.84 125.26,41.76 136.12,30.9 136.12,30.67 135.59,30.14 135.59,29.99 135.73,29.85 135.87,29.85 136.45,30.43 136.59,30.43 136.74,30.28 136.74,30.14 136.16,29.56 136.16,29.42 136.3,29.27 136.45,29.27 137.03,29.85 137.17,29.85 137.31,29.71 137.31,29.56 136.95,29.21 136.95,29.03 137.06,28.93 137.25,28.93 137.53,29.21 137.81,29.21 139.58,27.44 142.66,27.44 144.37,25.73 144.37,24.93 v1(143.53,24.1)
  BOTTOM w0.14: v1(143.53,24.1) 143.68,23.96 JDIM2800.110 ; U400.BU52 125.69,63 125.69,59.24 v2(123.78,57.33)
M_A_CLKN0: length 59.6
  IN1 w0.079: v2(128.43,60.96) 128.26,60.79 128.14,60.79 127.82,60.47 127.82,56.26 130.59,53.49 130.59,48.65 130.94,48.3 131.37,48.3 131.79,48.73 131.94,48.73 132.22,48.45 132.22,48.32 131.77,47.88 131.77,47.51 132.11,47.18 132.38,47.18 132.75,47.55 132.95,47.55 133.21,47.29 133.21,47.07 132.85,46.71 132.85,46.38 133.19,46.04 133.49,46.04 133.96,46.51 134.16,46.51 134.39,46.28 134.39,46.04 133.97,45.62 133.97,45.27 134.3,44.94 134.63,44.94 135.04,45.35 135.23,45.35 135.43,45.14 135.43,44.91 135.07,44.55 135.07,44.16 145.22,34.01 145.95,34.01 148.9,31.05 148.9,30.33 151.57,27.67 151.57,25.79 151.46,25.69 151.35,25.69 v1(151.02,26.02)
  BOTTOM w0.079: U400.CC53 128.53,62.88 128.45,62.96 128.37,62.96 128.3,62.89 128.3,62.43 128.37,62.35 128.52,62.35 128.61,62.27 128.61,62 128.86,61.75 128.86,60.79 128.79,60.71 128.64,60.71 128.43,60.91 v2(128.43,60.96)
  BOTTOM w0.109: v1(151.02,26.02) 151.02,25.75 150.93,25.66 150.7,25.66 150.42,25.95 150.42,26.75 150.8,27.13 150.8,27.35 150.93,27.48 JDIM2800.139
M_A_CLKN1: length 61.3
  IN1 w0.079: v2(125.02,67.97) 124.76,67.72 124.59,67.72 124.42,67.54 124.42,65.27 127.37,62.32 127.37,56.07 129.83,53.6 129.83,48.34 144.96,33.21 145.61,33.21 148.12,30.7 148.12,30.01 150.22,27.92 150.22,22.87 150.71,22.37 151.28,22.37 v1(151.47,22.17)
  BOTTOM w0.109: JDIM2800.140 151.17,21.07 151.02,21.23 151.02,22.27 151.12,22.38 151.27,22.38 v1(151.47,22.17) ; U400.BT41 125.3,68.26 v2(125.02,67.97)
M_A_CLKP0: length 59.7
  IN1 w0.079: v1(151.02,25.25) 151.02,25.3 151.24,25.52 151.53,25.52 151.74,25.72 151.74,27.74 149.07,30.4 149.07,31.12 146.02,34.18 145.29,34.18 135.24,44.23 135.24,44.48 135.6,44.84 135.6,45.21 135.3,45.51 134.97,45.51 134.56,45.11 134.37,45.11 134.14,45.34 134.14,45.55 134.56,45.98 134.56,46.35 134.22,46.68 133.89,46.68 133.42,46.21 133.26,46.21 133.02,46.45 133.02,46.64 133.37,47 133.37,47.36 133.02,47.71 132.68,47.71 132.31,47.35 132.18,47.35 131.94,47.58 131.94,47.81 132.38,48.25 132.38,48.52 132.01,48.89 131.72,48.89 131.3,48.47 131.01,48.47 130.75,48.72 130.75,53.56 127.99,56.33 127.99,60.4 128.14,60.55 128.29,60.55 v2(128.43,60.4)
  BOTTOM w0.079: v2(128.43,60.4) 128.46,60.43 128.48,60.43 128.61,60.55 128.85,60.55 129.02,60.72 129.02,61.81 128.76,62.07 128.76,62.88 128.53,63.11 U400.CC52
  BOTTOM w0.109: JDIM2800.137 150.43,27.52 150.57,27.38 150.57,27.23 150.19,26.84 150.19,25.85 150.61,25.43 150.85,25.43 v1(151.02,25.25)
M_A_CLKP1: length 61.4
  IN1 w0.079: v2(125.02,67.32) 124.79,67.55 124.66,67.55 124.58,67.47 124.58,65.34 127.53,62.39 127.53,56.14 130,53.67 130,48.4 145.03,33.38 145.68,33.38 148.29,30.76 148.29,30.08 150.38,27.99 150.38,22.94 150.78,22.54 151.39,22.54 151.47,22.62 v1(151.47,22.94)
  BOTTOM w0.109: U400.BT42 125.3,67.61 v2(125.02,67.32) ; v1(151.47,22.94) 151.14,22.6 151.03,22.6 150.79,22.37 150.79,21.24 150.68,21.13 JDIM2800.138
M_A_CS#0: length 57.2
  IN1 w0.102: v2(129.7,65.32) 130.17,64.84 130.46,64.84 133.1,62.2 133.28,61.77 133.28,56.56 137.02,52.82 137.02,51.93 157.11,31.84 157.11,30.43 157.59,29.95 157.59,25.76 v1(156.99,25.16)
  BOTTOM w0.14: v1(156.99,25.16) 156.54,25.16 156.23,25.46 156.23,26 155.75,26.48 155.34,26.48 155.17,26.66 155.17,27.15 155.43,27.41 JDIM2800.149 ; U400.CF47 v2(129.7,65.32)
M_A_CS#1: length 58.4
  IN1 w0.079: v2(129.59,67.32) 130.15,66.76 130.15,65.9 130.42,65.63 130.62,65.63 130.86,65.39
  IN1 w0.102: v1(158.43,25.69) 158.95,26.22 158.95,27.2 159.66,27.91 159.66,31.01 138.28,52.4 138.28,52.83 134.06,57.05 134.06,62.01 133.93,62.32 130.86,65.39
  BOTTOM w0.14: U400.CF42 129.88,67.61 v2(129.59,67.32) ; v1(158.43,25.69) 158.33,25.69 157.43,26.59 JDIM2800.157
M_A_DQSN0: length 68
  IN3 w0.089: v1(173.14,24.64) 173.33,24.83 173.65,24.83 173.91,25.1 173.91,26.3 173.46,26.76 173.46,28.25 165.3,36.41 157.92,36.41 150.92,43.41 147.29,43.41 136.61,54.09 136.61,58.02 136.05,58.58 136.05,59.42 135.13,60.34 135.13,61.36 134.92,61.57 134.59,61.57 v2(134.45,61.7)
  BOTTOM w0.079: v2(134.45,61.7) 134.1,62.05 134.1,62.71 134.03,62.88 134.03,63.03 134.13,63.21 134.24,63.33 134.39,63.33 134.49,63.43 134.49,64.04 U400.CR50
  BOTTOM w0.109: v1(173.14,24.64) 173,24.78 172.77,24.78 172.42,25.13 172.42,26.26 172.92,26.77 JDIM2800.219
M_A_DQSN1: length 67.9
  IN3 w0.089: v2(131.86,61.12) 132.12,61.12 132.26,60.98 132.26,52.8 145.63,39.43 147.35,39.43 154.34,32.43 163.66,32.43 168.83,27.26 168.83,24.8 169.19,24.45 169.19,22.76 169.07,22.65 168.93,22.65 v1(168.68,22.9)
  BOTTOM w0.079: v2(131.86,61.12) 131.33,61.65 131.33,62.41 131.39,62.47 131.39,62.68 131.34,62.86 131.34,63.08 131.45,63.48 131.47,63.55 131.47,64.01 U400.CK50
  BOTTOM w0.109: v1(168.68,22.9) 168.44,22.66 168.12,22.66 167.79,22.33 167.79,21.29 167.68,21.18 JDIM2800.198
M_A_DQSN2: length 72.8
  IN1 w0.079: v1(178.83,22.96) 178.58,22.71 178.38,22.71 178.13,22.96 178.13,23.83 177.84,24.12 177.84,26.21 175.73,28.32 174.1,28.32 172.47,29.96 166.22,29.96 165.65,30.52 163.33,30.52 137.38,56.48 137.38,60.6 137.2,60.77 137.2,62.37 135.7,63.87 135.49,63.87 134.71,64.65 134.71,66.52 134.87,66.67 v2(135.08,66.67)
  BOTTOM w0.109: JDIM2800.240 178.18,21.21 178.03,21.36 178.03,22.38 178.33,22.68 178.55,22.68 v1(178.83,22.96) ; U400.CV44 135.37,66.96 v2(135.08,66.67)
M_A_DQSN3: length 71.6
  IN3 w0.079: 131.99,65.07 131.99,65.09 131.96,65.12 131.96,66.15 132.13,66.32 132.13,66.47 v2(132.34,66.67)
  IN3 w0.089: v1(163.11,25.55) 163.27,25.72 163.61,25.72 163.93,26.03 163.93,26.99 162.79,28.13 160.79,28.13 160.03,28.89 149.88,28.89 148.68,30.09 148.68,30.22 148.91,30.44 148.91,30.75 148.48,31.17 148.18,31.17 147.95,30.95 147.83,30.95 147.53,31.24 147.53,31.37 147.76,31.6 147.76,31.9 147.33,32.32 147.25,32.32 147.03,32.32 146.8,32.1 146.68,32.1 146.38,32.39 146.38,32.52 146.57,32.7 146.57,33.04 146.17,33.43 145.84,33.43 145.65,33.25 145.53,33.25 145.1,33.67 145.1,34.85 128.62,51.33 128.62,58.58 129.07,59.03 129.07,61.6 131.72,64.26 131.99,64.52 131.99,65.07
  BOTTOM w0.109: v1(163.11,25.55) 162.92,25.75 162.59,25.75 162.28,26.05 162.28,27.21 162.43,27.35 JDIM2800.177 ; U400.CM44 132.62,66.96 v2(132.34,66.67)
M_A_DQSN4: length 53
  IN1 w0.079: v2(121.5,59.8) 121.5,59.87 121.37,60 121.13,60 120.88,59.75 120.88,53.82 122.37,52.34 122.37,44.83 122.2,44.66 122.2,39.07 130.33,30.94 130.33,30.32 130.11,30.1 129.47,30.1 129.37,29.99 129.37,29.64 129.5,29.5 130.78,29.5 131.07,29.22 131.07,28.8 130.76,28.49 129.54,28.49 129.33,28.28 129.33,27.97 129.52,27.79 130.86,27.79 131.18,27.47 131.18,26.31 130.76,25.89 130.53,25.89 v1(130.36,25.72)
  BOTTOM w0.079: v2(121.5,59.8) 121.34,59.96 121.24,59.96 120.86,60.34 120.86,62.15 121.18,62.47 121.18,62.68 121.13,62.86 121.13,63.08 121.26,63.52 121.26,63.72 121.51,63.97 U400.BG50
  BOTTOM w0.109: v1(130.36,25.72) 130.21,25.87 129.83,25.87 129.42,26.28 JDIM2800.53
M_A_DQSN5: length 48
  IN3 w0.089: v2(118.96,57.66) 118.96,57.8 118.96,57.8 119.16,57.88 119.2,57.88 119.35,57.74 119.35,54.03 121.46,51.91 121.46,47.52 124.02,44.96 124.02,24.36 124.56,23.82 124.56,22.32 124.5,22.27 v1(124.16,22.27)
  BOTTOM w0.079: v2(118.96,57.66) 118.81,57.81 118.57,57.81 118.39,57.98 118.39,62.28 118.6,62.49 118.6,62.77 118.58,62.86 118.58,63.08 118.69,63.46 118.69,63.89 118.96,64.16 U400.BA50
  BOTTOM w0.109: v1(124.16,22.27) 124.39,22.03 124.39,21.79 124.27,21.67 124.27,21.26 124.18,21.17 JDIM2800.32
M_A_DQSN6: length 54.7
  IN3 w0.079: v2(121.36,66.67) 121.52,66.67 121.74,66.45 121.74,65.07 121.71,65.04 121.71,65.02
  IN3 w0.089: v1(135.68,23.03) 135.93,22.77 136.07,22.77 136.17,22.87 136.17,23.91 134.72,25.36 134.72,39.59 124.76,49.55 124.76,54.32 123.18,55.91 123.18,62.95 121.71,64.42 121.71,65.02
  BOTTOM w0.109: v2(121.36,66.67) 121.64,66.96 U400.BH44 ; JDIM2800.74 134.68,21.1 134.77,21.2 134.77,22.5 135.06,22.79 135.44,22.79 v1(135.68,23.03)
M_A_DQSN7: length 50.4
  IN1 w0.079: v2(119.53,66.67) 119.34,66.67 119.16,66.49 119.16,64.25 117.19,62.29 117.19,53.21 119.62,50.78 119.62,46.66 118.54,45.58 118.54,37.53 119.79,36.28 119.79,35.54 119.6,35.35 119.23,35.35 119.15,35.27 119.15,34.84 119.23,34.76 119.6,34.76 119.79,34.57 119.79,27.99 120.12,27.66 120.12,25.77 119.85,25.49 119.49,25.49 v1(119.31,25.32)
  BOTTOM w0.109: JDIM2800.11 118.93,27.4 118.54,27.01 118.54,25.79 118.84,25.49 119.14,25.49 v1(119.31,25.32) ; v2(119.53,66.67) 119.81,66.96 U400.BD44
M_A_DQSN8: length 3.8
  TOP w0.109: v1(140.43,25.76) 140.04,25.38 R2816.2
  BOTTOM w0.109: v1(140.43,25.76) 139.93,26.26 JDIM2800.95
M_A_DQSP0: length 68.1
  IN3 w0.089: v2(134.45,61.14) 134.45,61.17 134.63,61.35 134.83,61.35 134.92,61.27 134.92,60.25 135.84,59.33 135.84,58.49 136.4,57.94 136.4,54 147.2,43.19 150.83,43.19 157.83,36.19 165.22,36.19 173.24,28.16 173.24,26.67 173.7,26.21 173.7,25.19 173.56,25.05 173.32,25.05 173.14,25.23 v1(173.14,25.41)
  BOTTOM w0.079: v2(134.45,61.14) 134.12,61.48 134.12,61.81 133.94,61.99 133.94,62.68 133.88,62.85 133.88,63.07 134,63.31 134,63.92 134.06,63.98 134.29,63.98 134.34,63.93 134.34,63.68 U400.CR51
  BOTTOM w0.109: JDIM2800.221 173.43,27.48 173.21,27.26 173.21,26.65 172.71,26.14 172.71,25.25 172.89,25.07 173.03,25.07 173.14,25.18 v1(173.14,25.41)
M_A_DQSP1: length 67.8
  IN3 w0.089: v2(131.86,61.67) 132.47,61.07 132.47,52.89 145.72,39.65 147.44,39.65 154.43,32.65 163.75,32.65 169.05,27.35 169.05,24.89 169.4,24.54 169.4,22.67 169.16,22.43 168.88,22.43 168.68,22.23 v1(168.68,22.14)
  BOTTOM w0.079: U400.CK51 131.87,63.61 131.94,63.54 131.94,63.38 131.86,63.3 131.61,63.3 131.55,63.23 131.5,63.06 131.5,62.88 131.54,62.7 131.54,62.4 131.49,62.35 131.49,61.71 131.68,61.52 131.8,61.52 131.86,61.58 v2(131.86,61.67)
  BOTTOM w0.109: JDIM2800.200 168.18,21.2 168.07,21.3 168.07,22.21 168.24,22.38 168.44,22.38 v1(168.68,22.14)
M_A_DQSP2: length 72.9
  IN1 w0.079: v2(134.17,66.67) 134.41,66.67 134.52,66.57 134.52,64.57 135.41,63.68 135.62,63.68 137.01,62.29 137.01,60.69 137.18,60.52 137.18,56.4 163.25,30.33 165.57,30.33 166.14,29.76 172.39,29.76 174.02,28.13 175.65,28.13 177.65,26.13 177.65,24.04 177.93,23.75 177.93,22.88 178.3,22.51 178.51,22.51 v1(178.83,22.2)
  BOTTOM w0.109: v1(178.83,22.2) 178.63,22.4 178.45,22.4 178.31,22.26 178.31,21.48 178.68,21.12 JDIM2800.242 ; v2(134.17,66.67) 134.51,66.67 134.61,66.78 U400.CT44
M_A_DQSP3: length 71.5
  IN3 w0.079: v2(131.42,66.67) 131.92,66.67 131.98,66.62 131.98,66.39 131.8,66.21 131.8,65.12 131.77,65.09 131.77,65.07
  IN3 w0.089: 131.77,65.07 131.77,64.61 131.76,64.6 131.57,64.41 128.85,61.69 128.85,59.11 128.41,58.67 128.41,51.24 144.89,34.76 144.89,33.58 145.44,33.03 145.74,33.03 145.93,33.22 146.08,33.22 146.35,32.95 146.35,32.79 146.16,32.61 146.16,32.3 146.59,31.88 146.89,31.88 147.12,32.11 147.24,32.11 147.29,32.06 147.54,31.81 147.54,31.68 147.31,31.46 147.31,31.15 147.74,30.73 148.04,30.73 148.27,30.96 148.4,30.96 148.69,30.66 148.69,30.53 148.47,30.31 148.47,30 149.79,28.67 159.94,28.67 160.7,27.91 162.7,27.91 163.71,26.9 163.71,26.12 163.52,25.93 163.34,25.93 163.11,26.16 v1(163.11,26.31)
  BOTTOM w0.109: v2(131.42,66.67) 131.71,66.96 U400.CK44 ; v1(163.11,26.31) 163.11,26.26 162.89,26.04 162.71,26.04 162.57,26.17 162.57,27.09 162.92,27.44 JDIM2800.179
M_A_DQSP4: length 52.8
  IN1 w0.079: v2(121.5,60.35) 121.5,60.31 121.38,60.2 121.05,60.2 120.69,59.83 120.69,53.74 122.17,52.26 122.17,44.91 122.01,44.74 122.01,38.99 130.14,30.86 130.14,30.4 130.03,30.29 129.39,30.29 129.17,30.07 129.17,29.56 129.42,29.31 130.7,29.31 130.87,29.14 130.87,28.88 130.68,28.68 129.46,28.68 129.14,28.36 129.14,27.89 129.44,27.59 130.78,27.59 130.99,27.39 130.99,26.39 130.68,26.08 130.45,26.08 130.36,26.17 v1(130.36,26.48)
  BOTTOM w0.079: v2(121.5,60.35) 121.5,60.21 121.44,60.14 121.28,60.14 121.02,60.4 121.02,62.09 121.34,62.4 121.34,62.7 121.29,62.88 121.29,63.06 121.35,63.26 121.39,63.29 121.64,63.29 121.77,63.42 121.77,63.65 121.71,63.7 121.6,63.7 U400.BG51
  BOTTOM w0.109: v1(130.36,26.48) 130.36,26.25 130.27,26.16 129.95,26.16 129.71,26.4 129.71,27.32 129.93,27.54 JDIM2800.55
M_A_DQSP5: length 48
  IN3 w0.089: v2(118.96,58.22) 119.08,58.1 119.29,58.1 119.56,57.83 119.56,54.12 121.68,52 121.68,47.61 124.24,45.05 124.24,24.45 124.78,23.91 124.78,22.47 v1(124.98,22.27)
  BOTTOM w0.079: v2(118.96,58.22) 118.96,58.18 118.75,57.97 118.63,57.97 118.55,58.04 118.55,62.22 118.76,62.43 118.76,62.79 118.74,62.88 118.74,63.06 118.79,63.25 118.86,63.3 119.13,63.3 119.21,63.37 119.21,63.72 119.14,63.79 119.01,63.79 118.96,63.73 U400.BA51
  BOTTOM w0.109: JDIM2800.34 124.68,21.15 124.56,21.26 124.56,21.55 124.68,21.67 124.68,21.96 v1(124.98,22.27)

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
THERM_SDA: length 283.9
  IN1 w0.079: v1(22.03,55.07) 23.51,56.55 24.27,56.55 28.15,60.43 35,60.43 40.81,54.61 41.48,54.61 42.35,55.48 46.8,55.48 47.93,56.61 50.85,56.61 51.83,55.63 58.31,55.63 59.04,54.9 61.58,54.9 61.64,54.96 62.26,54.96 v1(62.54,54.69)
  IN3 w0.089: v2(158.7,18.01) 158.7,18.79 157.45,20.04 142.49,20.04 142.47,20.07 120.57,20.07 119.9,20.74 116.74,20.74 115.64,21.84 113.7,21.84 112.9,21.05 111.46,21.05 110.19,19.78 104.97,19.78 104.88,19.68 97.08,19.68 96.97,19.78 93.8,19.78 92.93,18.91 92.93,17.11 92.38,16.56 89.36,16.56 86.94,18.97 84.42,18.97 83.05,17.6 82.23,17.6 80.99,16.36 79.23,16.36 78.37,17.22 71.64,17.22 69.37,14.94 67.91,14.94 67.63,15.22 62.67,15.22 62.39,14.94 61.07,14.94 60.5,14.37 59.18,14.37 58.36,15.19 54.37,15.19 54.08,15.48 49.03,15.48 47.25,17.26 35.22,17.26 31.96,20.52 28.51,20.52 26.86,22.16 26.86,23.47 26.19,24.15 26.19,26.85 24.38,28.65 23.42,28.65 22.77,29.3 22.77,30.54 21.79,31.52 21.79,34.77 22.09,35.06 22.09,44.51 23.63,46.06 23.63,53.47 v1(22.03,55.07)
  BOTTOM w0.109: U5403.7 160.27,16 158.7,17.57 v2(158.7,18.01) ; U5400.7 90.8,79.14 90.91,79.02 90.91,72.42 90.47,71.98 90.47,70.3 90.17,70 Q5404.4 89.41,70 89.31,69.9 R5417.2 87.5,69.9 86.82,69.21 86.32,69.21 86.03,68.92 86.03,68.57 87.02,67.58 87.02,66.03 87.62,65.44 87.62,63.61 87.29,63.28 87.29,60.14 85.98,58.82 84.66,58.82 82.17,56.34 75.76,56.34 73.56,54.14 62.75,54.14 62.54,54.36 v1(62.54,54.69)
THERMDA_1: length 55.4
  TOP w0.109: Q5403.2 74.28,45.69 Q5403.3 71.52,44.74 v1(71.28,44.99) C5411.1 69.73,45.73 v1(68.88,46.58)
  IN3 w0.089: v1(97.5,77.49) 97.21,77.2 97.03,77.13 96.55,76.65 96.55,74.73 95.67,73.85 95.39,73.85 95.01,73.48 95.01,72.94 92.39,70.32 92.39,69.67 91.39,68.67 91.39,68.09 89.79,66.49 89.79,64.98 86.51,61.7 86.07,61.7 80.96,56.6 80.14,56.6 78.63,55.09 78.11,55.09 69.6,46.58 v1(68.88,46.58)
  BOTTOM w0.109: v1(97.5,77.49) 97.5,77.58 97.14,77.94 96.61,77.94 95.41,79.14 U5400.2
THERMDC_1: length 49.4
  TOP w0.109: v1(69.34,47.06) 69.59,47.32 v1(70.05,47.32) 70.05,47 C5411.2 72.15,46.51 Q5403.1
  IN3 w0.089: v1(69.34,47.06) 69.8,47.06 78.02,55.29 78.58,55.29 80.07,56.78 80.85,56.78 85.98,61.9 86.43,61.9 89.61,65.09 89.61,66.56 91.21,68.16 91.21,68.74 92.21,69.74 92.21,70.39 94.83,73.02 94.83,73.55 95.32,74.03 95.6,74.03 96.37,74.81 96.37,76.74 96.86,77.23 v1(96.86,77.49)
  BOTTOM w0.109: U5400.3 95.55,78.49 96.54,77.49 v1(96.86,77.49)
TILE_I2C_INT_EC: length 17.3
  TOP w0.076: U4700.D5 v2(193.49,16.99)
  BOTTOM w0.076: v2(193.49,16.99) 193.17,16.99 193.03,16.85 192.23,16.85
  BOTTOM w0.109: 192.23,16.85 191.73,16.85 191.54,16.66 190.89,16.66 190.55,16.32 190.55,15.49 190.7,15.34 190.7,14.55 191.06,14.2 191.06,13.66 191.13,13.49 191.38,13.24 191.38,12.41 191.6,12.19 191.82,12.19 191.97,12.04 191.97,11.73 192.81,10.89 196.04,10.89 196.39,11.25 197.23,11.25 197.59,10.89 R4233.1 198.1,11.13 198.22,11.25 198.96,11.25 199.09,11.12 R4749.2
TILE_TAG_I2C_SCL: length 74.5
  TOP w0.076: U4700.J8 v2(197.39,18.94)
  IN3 w0.076: 193.01,15.45 193.46,15.45 193.86,15.05 195.02,15.05 196.29,15.57 196.7,15.98 198.84,15.98 199.03,16.18 199.03,17.15 197.39,18.79 v2(197.39,18.94)
  IN3 w0.089: v1(140.16,9.57) 140.19,9.61 143.56,9.61 144.2,10.25 147.1,10.25 147.72,9.63 147.72,9.5 147.95,9.27 149.12,9.27 149.56,9.7 160.35,9.7 160.98,10.34 163.68,10.34 164.14,9.88 165.19,9.88 165.81,9.26 171.19,9.26 171.58,8.87 172.55,8.87 172.58,8.91 178.14,8.91 181.05,11.82 181.05,12.46 181.65,13.06 182.27,13.06 184.26,15.05 184.26,15.33 184.86,15.92 186.66,15.92 186.97,15.61 187.38,15.61 187.96,15.04 189.66,15.04 189.74,15.11 189.74,15.4 190.21,15.86 190.65,16.05 191.83,16.05 192.43,15.45 193.01,15.45
  BOTTOM w0.076: v2(197.39,18.94) 197.38,18.94 v1(197.38,18.21) 197.94,18.21 R4231.1
  BOTTOM w0.109: CON7704.6 138.12,9.08 138.75,9.72 R4727.2 138.88,9.95 139.47,9.95 139.85,9.57 v1(140.16,9.57)
TILE_TAG_I2C_SDA: length 82.7
  TOP w0.076: U4700.J9 v2(197.39,19.59)
  TOP w0.109: R4728.2 135.47,8.48 v1(134.98,7.99)
  IN3 w0.076: 193.18,15.27 193.42,15.27 193.8,14.89 195.06,14.89 196.4,15.45 196.77,15.82 198.91,15.82 199.18,16.1 199.18,17.22 197.76,18.64 197.76,19.22 v2(197.39,19.59)
  IN3 w0.089: 193.18,15.27 192.36,15.27 191.76,15.87 190.68,15.87 190.31,15.71 189.92,15.32 189.92,14.81 189.42,14.31 189.05,14.31 188.55,14.81 186.93,14.81 186.79,14.96 186.79,15.54 186.59,15.75 184.99,15.75 184.45,15.21 184.45,14.99 182.34,12.88 181.72,12.88 181.23,12.38 181.23,11.75 178.21,8.73 172.66,8.73 172.62,8.69 171.5,8.69 171.11,9.08 165.74,9.08 165.12,9.7 164.07,9.7 163.61,10.16 161.11,10.16 160.48,9.53 149.63,9.53 149.2,9.09 147.97,9.09 147.89,9.02 147.11,9.02 146.69,9.43 146.69,9.63 146.46,9.85 145.73,9.85 144.98,9.09 143.93,9.09 143.79,8.94 143.16,8.94 142.73,8.51 140.4,8.51 140.21,8.71 136.46,8.71 136.13,8.38 135.37,8.38 v1(134.98,7.99)
  BOTTOM w0.076: v2(197.39,19.59) 197.88,19.1 197.97,19.1 R4232.1
  BOTTOM w0.109: v1(134.98,7.99) 135.47,8.48 136.07,8.48 136.69,7.86 137.38,7.86 137.62,8.1 CON7704.7
TOUCH_INT#: length 198.5
  IN2 w0.089: v2(142.54,76.05) 142.54,76.05 142.85,75.74 143.56,75.74 144.93,74.37 146.8,74.37 147.07,74.1 147.59,74.1 147.95,73.73 147.95,72.32 146.85,71.22 145.43,71.22 144.44,70.23 144.44,66.26 144.88,65.82 144.88,63.61 143.95,62.68 143.95,59.39 144.59,58.75 144.59,58.28 144.94,57.94 144.94,57.51 144.64,57.21 144.39,57.21 144.06,56.88 144.06,56.52 145.77,54.81 146.45,54.81 147.65,53.62 150.17,53.62 150.76,53.03 152.41,53.03 152.66,52.78 152.66,51.83 152.96,51.53 152.96,50.8 152.56,50.41 152.56,48.68 153.13,48.12 153.69,48.12 153.96,47.85 156.12,47.85 157.21,46.76 157.21,46.63 158.38,45.47 158.38,44.41 159.43,43.36 159.43,42.59 159.64,42.38 159.69,42.38 v1(160.28,41.8)
  BOTTOM w0.109: U400.DR21 142.54,76.81 v2(142.54,76.05) ; CON3400.39 29.69,44.75 R3400.2 30.03,44.92 30.35,45.24 30.35,45.3 32.01,46.95 34.28,46.95 38.47,42.76 39.14,42.76 42.36,39.54 42.36,38.5 44.07,36.8 44.35,36.8 44.52,36.62 44.81,36.62 48,33.43 103.08,33.43 104.2,32.31 118.88,32.31 124.01,37.43 155.29,37.43 157.13,39.27 157.5,39.27 159.23,40.99 159.47,40.99 v1(160.28,41.8)
TOUCH_PWR_EN: length 198.3
  TOP w0.109: v1(26.75,49.79) 26.65,49.89 R3422.1
  IN2 w0.089: v2(146.28,76.52) 146.52,76.77 147.17,76.77 147.28,76.66 148.13,76.66 148.84,75.95 148.84,74.31 149.05,74.11 149.05,72.66 146.79,70.4 146.79,68.49 147.91,67.38 147.91,66.43 148.05,66.29 148.05,65.5 148.26,64.99 148.26,63.74 147.67,63.15 146.61,63.15 146.13,62.67 146.13,61.75 148.08,59.79 148.08,58.18 147.87,57.97 147.87,57.65 148.42,57.1 149.01,57.1 150.73,55.37 151.72,55.37 153.55,53.55 153.55,52.2 154.39,51.36 155.9,51.36 157.49,49.77 157.49,48.21 158.54,47.15 158.54,46.56 159.79,45.31 v1(160.14,45.31)
  BOTTOM w0.109: U400.DW24 145.97,75.96 146.28,76.27 v2(146.28,76.52) 146.49,76.74 147.75,76.74 R1548.2 ; v1(160.14,45.31) 160.04,45.21 160.04,44.7 159.16,43.82 159.16,42.22 157.12,40.18 156.75,40.18 154.91,38.35 149.75,38.35 149.52,38.58 123.86,38.58 118.46,33.18 104.56,33.18 103.31,34.43 49.03,34.43 45.01,38.45 45.01,40.51 44.45,41.07 42.78,41.07 41.15,42.7 41.15,43.81 40.54,44.42 40.54,45.06 40.28,45.31 39.83,45.31 38.36,46.77 35.1,46.77 34.33,47.55 29.64,47.55 v1(28.9,48.28) 28.65,48.28 27.89,49.04 27.64,49.04 26.89,49.79 v1(26.75,49.79)
TOUCH_RST#: length 201.7
  IN2 w0.089: v1(161.17,43.53) 160.88,43.83 160.88,45.12 160.3,45.7 159.66,45.7 158.72,46.63 158.72,47.23 157.67,48.28 157.67,49.84 155.98,51.53 154.46,51.53 153.72,52.27 153.72,53.62 151.8,55.55 150.81,55.55 148.69,57.67 148.69,57.94 148.26,58.36 148.26,60.05 147.02,61.29 147.02,62.24 148.44,63.66 148.44,65.02 148.23,65.53 148.23,66.36 148.08,66.51 148.08,67.54 147.72,67.9 147.72,68.63 147.88,68.78 147.88,71.24 149.25,72.61 149.25,74.19 149.05,74.4 149.05,76.01 148.19,76.86 147.37,76.86 147.26,76.97 145.02,76.97 144.17,77.82 v2(142.87,77.82)
  BOTTOM w0.109: CON3400.26 29.01,38.25 29.46,38.7 29.46,39.54 R3406.2 29.85,40.78 30.32,41.25 30.45,41.25 30.72,41.51 30.72,44.73 30.93,44.94 30.93,45.23 32.18,46.48 34.43,46.48 38.38,42.53 39.05,42.53 42.13,39.44 42.13,38.41 44.98,35.56 45.55,35.56 47.9,33.2 103,33.2 104.11,32.09 118.99,32.09 124.1,37.2 156.93,37.2 158.59,38.87 158.59,40.03 159.32,40.77 159.61,40.77 160.1,41.25 160.51,41.25 160.7,41.44 160.7,43.06 v1(161.17,43.53) ; U400.DR18 143,77.96 v2(142.87,77.82)
TP_3: length 6.6
  BOTTOM w0.109: U400.DW52 145.36,63.14 145.6,63.38 147.94,63.38 148.26,63.06 149.63,63.06 150.14,63.57 150.14,64.49 TP1028.1
TP_4: length 7.6
  BOTTOM w0.109: TP1029.1 150.2,62.84 148.17,62.84 147.85,63.16 145.94,63.16 145.41,62.63 U400.DV53
TP_L34: length 1.6
  TOP w0.109: TP1030.1 137.57,81.17 v2(138.2,80.54)
  BOTTOM w0.109: U400.DD13 138.27,80.61 v2(138.2,80.54)
TP_M34: length 5.4
  BOTTOM w0.109: TP1004.1 141.4,58.53 139.44,60.49 139.44,60.94 138.86,61.51 138.86,62.57 U400.DF53
TP_SCAN_DISABLE#: length 202.3
  TOP w0.109: v1(34.62,5.39) 34.5,5.52 34.5,6.94 35.1,7.54 35.41,7.54 35.58,7.72 R5218.1 35.58,8.86 Q5202.3
  TOP w0.14: U4700.D8 v2(193.49,19.59)
  IN3 w0.076: 195.71,14.78 196.57,15.13 196.92,15.49 199.03,15.49 199.51,15.97 199.51,17.35 198.55,18.31 198.55,19.78 196.92,21.41 194.82,21.41 193.49,20.08 v2(193.49,19.59)
  IN3 w0.089: 195.71,14.78 195.17,14.56 193.66,14.56 193.3,14.91 192.21,14.91 191.61,15.51 190.76,15.51 190.51,15.41 190.27,15.18 190.27,14.67 189.56,13.96 188.91,13.96 188.42,14.45 186.63,14.45 186.05,13.87 183.93,13.87 182.96,12.9 182.96,11.69 182.47,11.2 181.48,11.2 177.8,7.52 172.16,7.52 172.01,7.36 171.3,7.36 169.94,8.73 165.59,8.73 165.11,9.2 162.62,9.2 162.44,9.39 161.69,9.39 161.03,9.26 160.69,9.11 160.2,8.63 159.3,8.63 159,8.32 156.13,8.32 155.67,8.78 v1(155.57,8.78) 154.78,8.78 154.39,8.39 151.72,8.39 151.37,8.74 148.11,8.74 148.04,8.66 146.96,8.66 146.76,8.86 145.25,8.86 145.12,8.74 144.08,8.74 143.93,8.59 143.31,8.59 142.88,8.16 140.08,8.16 139.94,8.3 136.6,8.3 135.81,7.52 133.55,7.52 132.66,8.41 126.7,8.41 126.32,8.02 126.32,7.32 125.98,6.98 125.49,6.98 125.36,7.12 125.02,7.26 123.4,7.26 123.17,7.02 119.58,7.02 118.47,8.13 113.64,8.13 112.52,7.01 112.52,6.78 112.16,6.42 110.26,6.42 110.06,6.63 110.06,7.06 109.83,7.29 109.07,7.29 108.91,7.14 105.45,7.14 105.22,7.36 104.72,7.36 104.52,7.16 103.34,7.16 102.48,7.52 101.75,8.25 99.2,8.25 98.25,9.2 90.82,9.2 90.17,9.85 86.8,9.85 86.14,9.2 74.97,9.2 74.77,8.99 66.26,8.99 65.56,8.29 65.56,5.34 64.84,4.63 63.3,4.63 62.78,4.1 60.49,4.1 59.81,4.78 58.78,4.78 58.57,4.58 56.34,4.58 54.52,6.39 52.49,6.39 51.88,7 51.26,7.25 50.68,7.25 50.15,6.73 48.29,6.73 47.4,5.84 44.85,5.84 44.3,5.28 42.52,5.28 42.02,5.78 40.87,5.78 40.59,6.07 v2(40.3,6.07) 40.12,5.89 35.76,5.89 35.26,5.39 v1(34.62,5.39)
  BOTTOM w0.109: v2(40.3,6.07) 39.85,6.07 39.69,6.23 CON5202.1 ; CON5200.8 156.29,8.5 156.01,8.78 v1(155.57,8.78)
TPCLK-1: length 4.7
  TOP w0.109: v1(37.07,4.83) 37.07,4.83 C5204.1 36.39,5.69 R5203.2
  BOTTOM w0.109: v1(37.07,4.83) 37.17,4.83 37.64,5.31 37.77,5.31 38.12,5.66 38.4,5.66 38.69,5.95 CON5202.3
TPDATA-1: length 4.5
  TOP w0.109: v1(37.77,4.84) 37.33,5.28 C5205.1 37.33,5.69 R5204.2
  BOTTOM w0.109: v1(37.77,4.84) 37.83,4.84 38.28,5.28 38.76,5.28 39.19,5.71 CON5202.2
TPM_PIRQ#: length 30.5
  TOP w0.109: v1(165.67,68.07) 165.47,67.87 165.47,66.76 165.41,66.7 165.41,66.28 165.65,66.04 R5100.2 165.79,65.48 165.39,65.08 U5100.18
  IN1 w0.079: v1(165.67,68.07) 165.22,68.52 164.27,68.52 163.98,68.81 155.54,68.81 155.37,68.97 154.38,68.97 154.14,68.73 151.43,68.73 150.89,69.27 150.29,69.27 148.9,70.66 145.24,70.66 144.29,71.61 144.29,71.96 143.77,72.47 142.61,72.47 142.45,72.63 v2(142.45,73.21)
  BOTTOM w0.109: U400.DR30 142.58,73.34 v2(142.45,73.21)
TPM_PLTRST#: length 3.5
  TOP w0.109: U5100.17 165.89,64.97 166.55,65.63 R5125.2 166.79,66.04 166.94,66.2 166.94,66.32 167.05,66.42 R5120.2 167.88,66.42 Q5101.3
TPM_PP: length 2.7
  TOP w0.109: R5128.1 R5124.1 164.47,57.73 164.88,57.31 R5126.2 165.56,57.52 R5123.2
TPS2546_EN: length 1.7
  TOP w0.109: U6203.5 199.9,82.92 200.4,83.42 R6203.1
TX0_HDMI+: length 14.6
  TOP w0.109: v1(204.92,54.3) 204.92,54.14 204.77,54 204.44,54 R3502.1 204.18,54.03 203.94,54.03 203.78,54.19 203.78,55.43 202.31,56.89 201.98,56.89 201.9,56.97 U3501.22
  IN1 w0.079: v1(204.92,54.3) 205.02,54.2 205.15,54.2 205.26,54.3 205.26,56.7 205.64,57.09 206.37,57.09 206.8,56.65 206.8,53.5 206.98,53.33 207.24,53.33 207.5,53.59 CON3501.7
TX0_HDMI-: length 14.5
  TOP w0.109: U3501.21 201.91,56.57 202,56.67 202.22,56.67 203.55,55.33 203.55,54.1 203.84,53.81 204.18,53.81 R3502.2 204.37,53.77 204.69,53.77 v1(204.92,53.54)
  IN1 w0.079: CON3501.9 207.14,53.16 206.91,53.16 206.64,53.43 206.64,56.58 206.3,56.92 205.71,56.92 205.42,56.63 205.42,54.05 v1(204.92,53.54)
TX1_HDMI+: length 6.2
  TOP w0.109: CON3501.4 205.69,55.04 205.38,55.04 205.26,55.16 205.26,55.93 204.74,56.45 204.4,56.45 R3501.1 204.18,56.45 203.8,56.45 202.62,57.63 202.16,57.63 202.02,57.77 U3501.24
TX1_HDMI-: length 6.2
  TOP w0.109: U3501.23 201.96,57.37 202,57.4 202.15,57.4 202.16,57.41 202.52,57.41 203.71,56.22 204.18,56.22 R3501.2 204.4,56.22 204.65,56.22 205.03,55.84 205.03,55.06 205.28,54.81 205.44,54.81 CON3501.6
TX2_HDMI+: length 8.1
  TOP w0.109: CON3501.1 207.11,56.41 206.97,56.41 206.74,56.64 206.74,56.94 205.2,58.49 204.39,58.49 R3500.1 204.16,58.47 204.04,58.47 v1(203.5,59) 203.5,58.59 203.39,58.48 203.06,58.48 202.66,58.88 202.05,58.88 201.96,58.97 U3501.27
TX2_HDMI-: length 8.1
  TOP w0.109: U3501.26 201.97,58.57 202.06,58.66 202.57,58.66 202.97,58.26 203.39,58.26 203.5,58.15 v1(203.5,57.73) 204.01,58.24 204.19,58.24 R3500.2 204.41,58.27 205.1,58.27 206.52,56.85 206.52,56.55 206.88,56.19 207.11,56.19 CON3501.3
TXC_HDMI+: length 7.3
  TOP w0.109: CON3501.10 205.61,51.96 204.89,51.96 204.72,52.13 204.4,52.13 R3503.1 204.17,52.12 203.88,52.12 203.35,52.65 203.35,53.52 203.06,53.81 203.06,54.75 202.04,55.77 U3501.19
TXC_HDMI-: length 7.2
  TOP w0.109: CON3501.12 205.51,51.74 204.8,51.74 204.63,51.91 204.4,51.91 R3503.2 204.19,51.89 203.79,51.89 203.13,52.56 203.13,53.43 202.83,53.72 202.83,54.65 202.12,55.37 U3501.18
TXLOUT0+: length 9.5
  TOP w0.109: C3415.1 32.2,26.24 32.08,26.36 31.7,26.36 31.47,26.59 31.47,27.75 31.73,28.01 31.73,30.64 30.42,31.95 30.19,31.95 30.12,31.88 v1(30.12,31.68)
  BOTTOM w0.109: v1(30.12,31.68) 29.98,31.82 29.04,31.82 28.97,31.75 CON3400.13
TXLOUT0-: length 9.6
  TOP w0.109: v1(30.12,32.44) 30.38,32.17 30.51,32.17 31.95,30.73 31.95,27.91 31.7,27.66 31.7,26.68 31.79,26.59 32.1,26.59 32.2,26.68 C3417.1
  BOTTOM w0.109: v1(30.12,32.44) 29.72,32.04 29.16,32.04 28.95,32.25 CON3400.14
TXLOUT1+: length 6.7
  TOP w0.109: v1(29.7,33.11) 29.7,33.33 29.8,33.42 30.02,33.42 31.69,31.76 32.69,31.76 32.92,31.53 32.92,31.37 C3409.2
  BOTTOM w0.109: CON3400.16 28.99,33.25 29.17,33.43 29.58,33.43 29.7,33.31 v1(29.7,33.11)
TXLOUT1-: length 6.7
  TOP w0.109: v1(29.7,33.87) 29.92,33.65 29.96,33.65 29.97,33.65 30.11,33.65 31.78,31.98 32.79,31.98 33.14,31.63 33.14,31.37 C3411.2
  BOTTOM w0.109: v1(29.7,33.87) 29.49,33.65 29.1,33.65 29.01,33.75 CON3400.17
TYPEC1_USB0: length 32
  TOP w0.508: PC8006.2 181.07,88.09 181.37,87.79 v1(182.11,87.79)
  IN3 w0.508: v1(169.32,104.21) 168.07,104.21 167.74,103.88 166.88,103.88 165.81,102.82 165.17,102.82 164.89,102.54 164.89,101.8 165.63,101.06 166.52,101.06 170.66,96.92 170.66,94.69 173.2,92.15 173.3,92.15 175.23,90.22 178.74,90.22 179.73,89.23 179.73,88.75 180.69,87.79 v1(182.11,87.79)
  vias: v1(181.73,88.28)
TYPEC3_RX1N_C: length 4.8
  TOP w0.109: CON6300.A10 210.9,110.59 arc(210.8,110.62) 210.71,110.67 210.69,110.69 arc(210.61,110.75) 210.5,110.77 209.72,110.77 arc(209.59,110.74) 209.49,110.67 209.33,110.52 arc(209.26,110.41) 209.24,110.29 209.24,109.72 arc(209.22,109.62) 209.18,109.52 arc(209.07,109.4) 208.92,109.33 arc(208.91,109.33) 208.89,109.32 arc(208.73,109.29) 208.59,109.2 R6309.1 208.49,109.22 arc(208.37,109.3) 208.23,109.32 208.19,109.32 arc(208.13,109.31) 208.08,109.28 C6309.1
TYPEC3_RX1P_C: length 4.7
  TOP w0.109: C6308.1 208.03,109.61 arc(208.1,109.56) 208.19,109.55 208.26,109.55 arc(208.36,109.57) 208.45,109.63 R6308.1 208.6,109.67 arc(208.73,109.58) 208.87,109.55 arc(208.93,109.57) 208.98,109.62 arc(209.01,109.66) 209.01,109.72 209.01,110.29 arc(209.06,110.5) 209.17,110.67 209.33,110.83 arc(209.51,110.95) 209.72,110.99 210.62,110.99 arc(210.68,111) 210.73,111.04 210.75,111.05 arc(210.79,111.08) 210.85,111.09 CON6300.A11
TYPEC3_RX2N_C: length 7.1
  TOP w0.109: C6313.1 207.96,103.08 208.18,102.99 208.34,102.99 208.48,103.04 R6310.1 208.69,102.99 208.91,102.99 209.07,103.16 209.46,104.04 209.49,104.07 210.85,105.43 211.17,105.64 211.61,105.64 211.75,105.7 211.92,105.85 212.19,106.4 212.36,106.57 212.41,106.62 212.41,106.72 212.53,106.84 CON6300.B10
TYPEC3_RX2P_C: length 7.1
  TOP w0.109: CON6300.B11 212.45,106.34 212.38,106.27 212.1,105.72 211.87,105.5 211.65,105.42 211.24,105.42 210.99,105.26 209.65,103.91 209.26,103.03 209.07,102.84 209,102.77 208.93,102.77 208.66,102.66 R6311.1 208.43,102.69 208.24,102.77 208.11,102.77 207.84,102.5 C6312.1
TYPEC3_TX1N_C: length 6
  TOP w0.109: CON6300.B3 212.76,110.34 arc(212.47,110.42) 212.25,110.62 212.18,110.72 211.99,111.18 211.99,111.57 arc(211.96,111.72) 211.87,111.85 arc(211.72,111.95) 211.53,111.99 211.12,111.99 arc(210.95,112.02) 210.81,112.11 210.79,112.14 arc(210.67,112.21) 210.54,112.24 210.43,112.24 arc(210.3,112.21) 210.18,112.14 210.13,112.08 arc(210,112) 209.84,111.97 209.73,111.97 arc(209.52,111.92) R6305.1 arc(209.2,111.9) 209.03,111.94 208.78,111.94 arc(208.48,111.88) C6311.1
TYPEC3_TX1P_C: length 6
  TOP w0.109: CON6300.B2 212.48,110.84 arc(212.44,110.85) 212.4,110.88 212.32,110.95 212.21,111.23 212.21,111.57 arc(212.16,111.8) 212.03,112 arc(211.8,112.16) 211.53,112.21 211.12,112.21 arc(211.04,112.23) 210.97,112.27 210.94,112.3 arc(210.76,112.42) 210.54,112.46 210.43,112.46 arc(210.21,112.42) 210.02,112.3 209.97,112.24 arc(209.91,112.2) 209.84,112.19 209.6,112.19 arc(209.53,112.2) 209.47,112.24 R6304.1 209.24,112.26 arc(209.14,112.19) 209.02,112.16 208.88,112.16 arc(208.87,112.16) 208.86,112.16 208.58,112.16 arc(208.54,112.17) 208.5,112.19 C6310.1
TYPEC3_TX2N_C: length 4.7
  TOP w0.109: C6315.1 207.63,106.07 arc(207.7,106.03) 207.78,106.01 arc(207.84,106.02) 207.89,106.06 207.91,106.08 arc(207.95,106.1) 207.99,106.11 R6306.1 208.27,105.98 arc(208.52,105.81) 208.81,105.75 209.51,105.75 arc(209.61,105.77) 209.69,105.83 210.63,106.77 arc(210.65,106.8) 210.66,106.84 210.66,106.88 arc(210.67,106.95) 210.71,107 arc(210.81,107.07) 210.94,107.09 CON6300.A3
TYPEC3_TX2P_C: length 4.6
  TOP w0.109: CON6300.A2 210.84,106.59 arc(210.78,106.58) 210.72,106.55 209.85,105.67 arc(209.69,105.57) 209.51,105.53 R6307.1 208.15,105.62 arc(208.14,105.66) 208.12,105.7 208.06,105.76 208.02,105.78 arc(208,105.79) 207.97,105.79 207.62,105.79 arc(207.51,105.74) 207.46,105.63 C6314.1
TYPEC_CC1: length 44.3
  TOP w0.254: v2(212.1,109.58) 212.18,109.58 212.41,109.34 CON6300.B5
  TOP w0.381: C6107.2 187.37,86.76 187.36,86.77 v2(187.07,86.77)
  IN1 w0.381: v2(187.07,86.77) 187.48,86.77
  IN1 w0.508: v1(209.83,103.08) 209.21,103.71 206.98,103.71 206.42,103.15 205.78,103.15 202.58,99.95 201.89,99.95 201.17,99.22 201.17,94.16 200.3,93.29 199.77,93.29 199.07,92.59 198,92.59 196.7,91.29 195.77,91.29 193.81,89.33 193.64,88.92 192.56,87.83 188.54,87.83 187.48,86.77
  IN3 w0.457: 211.43,109.34 211.66,109.58 v2(212.1,109.58)
  IN3 w0.508: 211.43,109.34 211.12,109.04 211.12,106.73 210.44,106.04 210.44,104.67 209.83,104.07 v1(209.83,103.08)
  BOTTOM w0.203: U6100.46 187.15,86.69 v2(187.07,86.77)
  BOTTOM w0.254: v2(212.1,109.58) 211.8,109.58 211.65,109.73 D6309.1
TYPEC_CC2: length 45.8
  TOP w0.254: CON6300.A5 210.61,108.09 210.45,107.93 209.28,107.93 208.79,107.44 208.79,107.23 D6310.1
  TOP w0.381: C6108.2 187.58,85.68 v2(187.07,85.68)
  TOP w0.508: v1(209.57,107.45) 209.56,107.45 209.42,107.31 209.42,107.05 D6310.1
  IN1 w0.457: v2(187.07,85.68) 187.87,85.68 188.21,86.03
  IN1 w0.508: 188.21,86.03 188.57,86.38 193.7,86.38 194.19,86.87 194.72,88.65 196.25,90.17 197.25,90.17 198.09,91.01 199.46,91.01 202.21,93.75 202.21,98.5 202.64,98.93 203,98.93 205.31,101.24 209.34,101.24 211.02,102.93 v1(211.02,103.05)
  BOTTOM w0.203: v2(187.07,85.68) 187.36,85.68 187.57,85.89 U6100.44
  BOTTOM w0.508: v1(209.57,107.45) 209.56,107.45 209.45,107.34 209.45,106.12 v1(209.97,105.59) 210.39,105.18 210.39,103.99 211.02,103.35 v1(211.02,103.05)
TYPEC_SBU1: length 46.2
  TOP w0.109: v2(212.09,107.9) 212.15,107.84 CON6300.B8
  IN1 w0.079: v1(207.87,107.41) 207.87,107.19 207.67,106.98 207.16,106.98 206.96,106.78 205.29,106.78 199.81,101.29 199.81,96 198.3,94.49 198.12,94.49 197.97,94.33 196.44,94.33 195.02,92.91 195.02,92.66 195.12,92.56 195.12,92.17 193.62,90.68 193.34,90.68 192.51,89.84 192.36,89.84 191.92,89.39 191.92,89.22 191.58,88.88 188.22,88.88 187.18,87.84 186.85,87.84 186.5,87.49 186.5,84.43 v2(186.53,84.4)
  BOTTOM w0.109: v1(207.87,107.41) 207.87,107.03 208.23,106.68 208.61,106.68 208.74,106.55 208.74,106.26 D6306.1 209.01,106.34 209.01,107.15 R6314.2 208.94,107.56 209.34,107.96 210.4,107.96 210.61,108.18 211.81,108.18 v2(212.09,107.9) ; v2(186.53,84.4) 186.89,84.77 187.28,84.77 187.61,85.09 U6100.42
TYPEC_SBU2: length 48
  TOP w0.109: v1(209.67,110.26) 209.67,109.88 210.26,109.29 210.56,109.29 210.87,109.59 CON6300.A8
  IN1 w0.079: v1(208.61,110.72) 208.84,110.72 209.01,110.54 209.01,107.52 208.3,106.8 207.24,106.8 207.03,106.6 205.34,106.6 199.97,101.23 199.97,95.93 198.79,94.75 198.65,94.41 198.46,94.22 197.88,93.98 196.39,93.98 195.48,93.06 195.48,92.3 193.67,90.5 193.39,90.5 192.58,89.69 192.43,89.69 192.07,89.33 192.07,89.15 191.64,88.72 188.29,88.72 187.25,87.68 186.92,87.68 186.66,87.42 186.66,85.55 v2(187.07,85.13)
  BOTTOM w0.109: v1(209.67,110.26) 209.88,110.47 R6319.2 209.88,111.39 209.7,111.58 209.7,111.83 D6307.1 209.34,111.35 208.71,110.72 v1(208.61,110.72) ; v2(187.07,85.13) 187.25,85.13 187.61,85.49 U6100.43
TYPEC_VBUS: length 7.6
  TOP w0.216: CON6300.B4 212.46,109.84 212.17,110.14 v2(212.1,110.14)
  TOP w0.229: v2(212.09,107.34) 212.02,107.34 211.77,107.59 CON6300.A4
  TOP w0.254: v2(212.09,107.34) 212.09,107.34 CON6300.B9 ; CON6300.A4 210.59,107.59 v1(210.41,107.41) ; v2(212.1,110.14) 211.9,110.14 211.86,110.09 CON6300.A9 210.77,110.09 210.53,110.34 v1(210.36,110.34)
  TOP w0.381: v1(210.36,110.34) 210.36,109.78 v1(210.41,109.73)
  TOP w0.508: v1(210.06,106.91) 210.06,107.06 v1(210.41,107.41) ; v1(184.38,89.02) 184.05,89.02 PC8003.2
  vias: v1(185.01,89.04) v1(184.99,88.4) v1(185.62,88.92) v1(185.62,88.29) v1(185.7,87.65) v1(186.26,88.92) v1(186.26,88.29) v1(186.85,88.51) v1(187.12,89.08) v1(187.96,88.95) v1(192.89,104.72) v1(193.27,104.09) v1(193.52,104.72) v1(193.9,104.09) v1(194.16,104.72) v1(194.54,104.09) v1(194.79,104.72) v1(195.43,104.72) v1(202.44,101.78) v1(202.44,101.14) v1(203.07,101.78)
UART2_RXD: length 125.5
  IN1 w0.079: v1(187.22,75.97) 187.17,75.92 182.76,75.92 182.38,76.29 179.73,76.29 179.3,75.87 177.98,75.87 177.75,75.97 176.57,75.97 176.47,75.87 172.92,75.87 172.51,75.46 170.61,75.46 169.93,76.14 164.13,76.14 163.3,76.96 161.74,76.96 161.27,76.49 160.73,76.49 158.7,74.47 154.93,74.47 154.14,75.25 151.28,75.25 150.12,76.42 148.25,76.42 147.8,75.97 v2(147.42,75.97)
  IN2 w0.089: v2(147.42,75.97) 147.03,75.58 146.56,75.58 146.38,75.77 144.67,75.77 144.5,75.94 143.2,75.94 142.66,76.49 140.41,76.49 v2(139.93,76.01) ; v1(208.85,25.27) 208.65,25.47 206.24,25.47 204.76,26.95 204.14,26.95 203.34,27.75 202.5,27.75 201.37,28.89 199.16,28.89 198.16,29.89 198.03,29.94 197.74,30.23 194.01,30.23 193.4,30.84 193.1,30.84 191.4,32.54 191.4,34.11 189.25,36.25 189.25,37.91 188.26,38.9 188.26,43.81 186.92,45.16 186.92,45.92 186.48,46.35 186.48,47.29 185.96,47.82 185.96,50.14 185.32,50.78 185.32,55.4 185.1,55.62 185.1,58.61 185.75,59.26 185.75,63.75 188.43,66.44 188.43,72.22 187.36,73.29 187.36,75.83 v1(187.22,75.97)
  BOTTOM w0.109: CON7702.29 209.88,24.22 209.36,24.74 209.36,25.63 TP7707.1 208.68,25.96 R7723.2 208.2,25.22 208.81,25.22 v1(208.85,25.27) ; U400.DG23 139.93,76.12 v2(139.93,76.01)
UART2_TXD: length 130.4
  IN1 w0.079: v2(146.84,75.94) 147.19,75.58 148.53,75.58 148.74,75.79 150.52,75.79 151.26,75.05 153.26,75.05 154.27,74.05 158.5,74.05 160.3,75.84 163.24,75.84 163.83,75.26 166.94,75.26 167.66,75.98 169.86,75.98 170.54,75.3 172.58,75.3 172.97,75.69 176.55,75.69 176.67,75.81 177.72,75.81 178,75.69 178,75.69 179.35,75.69 179.79,76.14 182.32,76.14 182.72,75.74 186.36,75.74 186.58,75.52 187.33,75.52 187.78,75.97 v1(187.87,75.97)
  IN2 w0.089: v1(209.65,23.79) 209.65,24.23 209.38,24.5 209.38,25.34 209.04,25.68 208.53,25.68 208.5,25.65 206.32,25.65 204.83,27.13 204.21,27.13 203.41,27.93 202.58,27.93 201.44,29.06 199.23,29.06 198.26,30.04 198.13,30.09 197.81,30.41 194.09,30.41 193.48,31.02 193.17,31.02 191.57,32.61 191.57,34.18 189.43,36.33 189.43,37.98 188.47,38.95 188.47,43.86 187.12,45.21 187.12,46 186.69,46.43 186.69,47.34 186.14,47.9 186.14,50.21 185.51,50.84 185.51,55.54 185.28,55.77 185.28,58.52 185.95,59.19 185.95,63.7 188.61,66.37 188.61,72.29 187.54,73.36 187.54,75.64 v1(187.87,75.97) ; v2(139.33,76.02) 140.01,76.69 142.74,76.69 143.26,76.17 144.52,76.17 144.75,75.94 v2(146.84,75.94)
  BOTTOM w0.109: U400.DJ21 140.22,77.02 140.01,76.8 139.49,76.8 139.28,76.6 139.28,76.06 v2(139.33,76.02) ; v1(209.65,23.79) 209.06,24.38 209.04,24.38 TP7706.1 R7722.2 208.48,23.98 208.63,23.98 209.32,23.29 209.88,23.29 210.31,23.72 CON7702.28
UIM_CLK: length 7.2
  TOP w0.109: R4218.1 197.15,5.18 197.05,5.08 197.05,4.65 197.69,4.01 D4205.2 197.72,4.26 v1(197.5,4.8)
  BOTTOM w0.109: CON4202.32 194.67,2.39 195.07,2.8 195.79,3.09 v1(197.5,4.8)
UIM_CLK_400: length 91.7
  TOP w0.109: R4218.2 197.6,6.99 198.04,7.43 v1(198.04,7.59)
  IN1 w0.079: v1(198.04,7.59) 198.04,8 198.42,8.38 198.42,9.78 198.1,10.1 198.1,11.21 199.62,12.72 199.62,13.94 199.48,14.07 199.48,18.79 200.89,20.19 200.89,20.7 200.21,21.37 199.63,21.37 197.48,23.52 197,23.52 193.74,26.78 191.7,26.78 190.96,27.52 190.96,28.58 190.29,29.25 189.12,29.25 187.05,31.32 187.05,33.17 184.96,35.26 184.96,37.43 184.33,38.07 184.33,39.93 183.64,40.61 183.64,41.4 184.41,42.17 184.41,43.15 184,43.55 183.32,43.55 183.19,43.41 181.33,43.41 179.45,45.29 177.06,47.69 176.73,47.69 175.78,48.64 174.6,48.64 174.17,48.21 173.49,48.21 173.44,48.26 172.51,48.26 172.21,47.97 171.35,47.97 171.17,48.15 169.75,48.15 169.41,47.81 169.41,47.54 168.29,46.42 166.94,46.42 v1(165.53,45.01)
  IN2 w0.089: v1(161.75,57.31) 161.97,57.09 161.97,56.77 161.67,56.46 161.67,56.11 162.06,55.73 162.06,55.13 163.22,53.96 163.22,50.84 163.92,50.15 163.92,49.04 164.59,48.37 164.59,45.82 165.4,45.01 v1(165.53,45.01)
  BOTTOM w0.109: v1(161.75,57.31) 161.88,57.43 161.88,60.67 161,61.55 CON4204.3
UIM_CLK_600: length 26
  TOP w0.109: R4217.2 196.7,5.86 196.57,5.99 196.57,6.13 v1(196.2,6.5) ; v2(209.73,13.85) 209.04,14.54 209.04,15.47 208.61,15.9 207.87,15.9 207.4,16.37 205.66,16.37
  IN2 w0.089: v2(209.73,13.85) 209.06,13.85 208.38,13.17 208.38,11.02 206.25,8.88 206.25,7.82 205.43,7.01 205.43,6.75 204.78,6.09 203.76,6.09 203.63,5.97 201.06,5.97 200.71,6.32 196.38,6.32 v1(196.2,6.5)
UIM_DATA: length 42
  TOP w0.109: v1(213.1,17.78) 213.1,17.32 213.74,16.69 213.74,13.9 212.68,12.84 212.68,12.2 213.41,11.48 v1(213.41,11.12) ; R4220.1 214.98,10.03 D4203.2 214.48,10.25 213.61,11.12 v1(213.41,11.12) ; v1(213.41,11.12) R4219.1
  IN3 w0.089: v1(213.1,17.78) 213.08,17.8 211.83,17.8 211.42,17.4 211.42,11.63 211.08,11.29 211.08,10.34 209.88,9.15 209.22,9.15 208.25,8.18 206.82,8.18 205.79,7.14 205.43,7.14 204.57,6.27 203.88,6.27 203.12,5.51 200.07,5.51 198.83,4.26 197.02,4.26 v1(196.59,4.69)
  BOTTOM w0.109: CON4202.34 194.16,2.42 195.32,3.58 195.32,4.06 195.6,4.34 196.24,4.34 v1(196.59,4.69)
UIM_DATA_400: length 108.3
  TOP w0.109: v1(213.99,9.47) 213.86,9.61 R4221.2
  IN1 w0.079: v1(165.96,51.46) 165.96,52.96 166.29,53.28 172.28,53.28 172.62,53.61 174.42,53.61 174.72,53.91 177.34,53.91 177.91,54.48 180.77,54.48 181.32,53.92 182.14,53.92 183.51,52.55 184.96,52.55 185.16,52.35 186.77,50.73 186.77,48.43 188.09,47.11 191.81,47.11 192.34,47.64 193.38,47.64 193.67,47.34 193.67,45.49 191.7,43.52 191.7,41.14 192.03,40.81 192.03,38.89 192.21,38.71 192.21,32.79 193.27,31.74 193.67,31.74 194.45,30.95 196.94,30.95 197.02,30.87 197.41,30.87 198.3,30.5 200.65,30.5 202.28,28.88 202.62,28.54 203.44,28.54 204.42,27.56 204.69,27.56 206.48,25.78 207.97,25.78 208.17,25.98 210.77,25.98 212.89,23.86 213.02,23.86 214.51,22.37 214.51,17.18 212.98,15.65 212.14,15.65 211.89,15.4 211.89,12.98 213.99,10.88 v1(213.99,9.47)
  IN3 w0.089: v1(165.96,51.46) 165.7,51.46 163.48,53.68 163.21,53.68 162.22,54.67 159.09,54.67 158.91,54.85 v1(158.91,55.8)
  BOTTOM w0.109: v1(158.91,55.8) 158.75,55.97 v1(158.75,56.79) 158.75,57.68 159.56,58.49 159.56,59.74 160.1,60.28 CON4204.7
UIM_DATA_600: length 15.1
  TOP w0.109: R4219.2 212.96,10.69 212.98,10.72 212.98,11.32 212.32,11.99 212.32,13 213.31,13.99 213.31,15.97 212.62,16.66 212.14,16.66 211.61,16.13 208.23,16.13 206.71,17.64 205.66,17.64
UIM_RESET: length 15.9
  TOP w0.109: R4227.1 204.73,6.24 204.89,6.08 205.24,5.94 205.67,5.94 v1(205.67,5.94) 205.88,5.73 D4204.2
  BOTTOM w0.109: v1(205.67,5.94) 205.36,5.94 205,6.3 203.73,6.3 203.4,5.97 200.38,5.97 200.18,6.17 199.06,6.17 198.78,5.89 198.78,4.52 198.37,4.11 197.59,4.11 196.45,2.97 195.31,2.5 195.16,2.35 CON4202.30
UIM_RST_400: length 94.8
  TOP w0.109: R4227.2 204.28,6.67 v1(204.54,6.93)
  IN2 w0.089: v1(185.95,39.41) 185.95,38.02 189.97,33.99 189.97,32.45 192.65,29.77 192.96,29.77 193.61,29.12 197.34,29.12 197.41,29.05 197.44,29.03 197.55,28.98 199.05,27.48 199.05,27.26 199.38,26.93 199.92,26.93 200.23,26.62 201.63,26.62 201.91,26.33 202.75,26.33 203.55,25.53 204.17,25.53 205.08,24.63 205.08,23.59 207.08,21.59 207.59,21.59 208.15,21.02 208.15,19.25 208.55,18.85 208.55,16.36 209.46,15.45 209.66,15.45 210.03,15.07 210.03,14.85 209.76,14.57 209.03,14.57 207.24,12.78 207.24,11.83 204.54,9.14 v1(204.54,6.93)
  IN3 w0.089: v1(161.37,56.77) 162.61,56.77 165.78,53.59 166.75,53.59 167.67,52.67 168.36,52.67 170.86,50.17 171.36,50.17 172.53,49 173.21,49 173.67,48.54 175.09,48.54 179.25,44.38 181.75,44.38 182.03,44.11 182.03,43.68 182.57,43.13 182.57,39.5 183.67,38.41 184.94,38.41 v1(185.95,39.41)
  BOTTOM w0.109: CON4204.2 161.34,64.09 161.71,63.72 161.71,61.37 162.32,60.76 162.32,56.97 162.12,56.77 v1(161.37,56.77)
UIM_RST_600: length 20.2
  TOP w0.109: v1(206.3,6.02) 205.9,6.42 205.23,6.42 R4226.2 ; v2(209.7,16.51) 208.2,16.51 207.79,16.92 207.79,18.41 207.29,18.91 205.66,18.91
  IN2 w0.089: v2(209.7,16.51) 209.71,16.51 210.82,15.4 210.82,13.08 209.67,11.93 209.67,11.31 207.67,9.3 207.67,8.48 206.09,6.91 206.09,6.22 206.3,6.02 v1(206.3,6.02)
UIM_VPP_400: length 5.7
  BOTTOM w0.109: TP4201.1 158.93,58.6 159.33,59 159.33,59.83 159.96,60.46 159.96,62.38 160.41,62.82 CON4204.6
UIM_VPP_600: length 4.9
  TOP w0.109: v2(209.43,19) 207.8,19 206.61,20.18 205.66,20.18
  BOTTOM w0.109: v2(209.43,19) 209.43,18.4 TP4203.1
USB2_COMP: length 4.5
  BOTTOM w0.254: 140.09,88.63 140.09,87.81 138.69,86.41 U400.DE1
  BOTTOM w0.305: R1303.1 139.16,89.56 140.09,88.63
USB30_RX1+: length 88.7
  TOP w0.109: CON6201.6 205.42,94.47 205.23,94.66 204.82,94.66 204.34,94.19 203.68,94.19 202.31,92.82 201.36,92.82 201.19,92.65 U6201.9 U6201.2 199.99,92.65 199.84,92.81 199.7,92.81 199.52,92.98 199.52,93.9 198.43,94.99 198.43,96.11 198.28,96.25 198.18,96.25 v1(197.97,96.04)
  IN1 w0.079: v1(137.51,90.86) 137.71,90.67 137.71,90.66 137.72,90.64 137.72,90.5 137.94,90.28 148.89,90.28 150.99,92.39 154.37,92.39 157.66,89.09 159.73,89.09 160.11,88.71 166.8,88.71 167.58,87.93 169.76,87.93 169.97,87.72 174.6,87.72 175.36,86.96 179.55,86.96 181,88.42 181,89.33 181.56,89.89 182.75,89.89 183.16,90.29 183.16,90.78 183.87,91.49 184.86,91.49 184.93,91.46 186.92,91.46 187.17,91.56 189.47,91.56 190.24,92.33 192.63,92.33 193.14,92.83 193.14,93.72 193.39,93.98 193.85,93.98 194.71,94.84 194.71,95.29 195.33,95.91 196.19,95.91 196.25,95.85 197.3,95.85 197.7,96.25 197.75,96.25 v1(197.97,96.04)
  BOTTOM w0.109: U400.CV2 135.11,86.15 135.11,88.08 135.45,88.42 135.45,89.83 135.87,90.24 137.51,90.24 137.7,90.43 137.7,90.67 v1(137.51,90.86)
USB30_RX1-: length 88.7
  TOP w0.109: CON6201.5 205.42,94.96 205.33,94.86 204.74,94.86 204.26,94.38 203.6,94.38 202.23,93.02 201.42,93.02 201.29,93.15 U6201.10 U6201.1 200,93.15 199.86,93 199.78,93 199.72,93.06 199.72,93.98 198.63,95.07 198.63,96.19 198.36,96.45 198.11,96.45 197.97,96.6 v1(197.97,96.71)
  IN1 w0.079: v1(138.27,90.86) 138,90.86 137.88,90.74 137.88,90.56 138.01,90.44 148.82,90.44 150.93,92.55 154.43,92.55 157.73,89.25 159.8,89.25 160.17,88.87 166.87,88.87 167.65,88.09 169.82,88.09 170.03,87.88 174.67,87.88 175.43,87.12 179.48,87.12 180.84,88.48 180.84,89.39 181.49,90.05 182.69,90.05 183,90.36 183,90.84 183.8,91.65 184.89,91.65 184.97,91.61 186.89,91.61 187.14,91.72 189.41,91.72 190.17,92.48 192.57,92.48 192.98,92.9 192.98,93.79 193.33,94.14 193.79,94.14 194.56,94.91 194.56,95.36 195.26,96.07 196.26,96.07 196.31,96.01 197.23,96.01 197.63,96.41 197.88,96.41 197.97,96.5 v1(197.97,96.71)
  BOTTOM w0.109: v1(138.27,90.86) 138.07,90.86 137.9,90.69 137.9,90.37 137.59,90.06 135.94,90.06 135.64,89.75 135.64,88.34 135.42,88.13 135.42,88.1 135.31,87.99 135.31,86.48 135.42,86.37 U400.CV1
USB30_RX2+: length 112.7
  TOP w0.109: v1(196.3,71.05) 196.1,71.05 195.95,71.2 195.95,71.35 196.15,71.55 198.1,71.55 198.69,70.96 v1(198.69,70.19) 198.99,70.48 199.13,70.48 199.41,70.2 199.77,70.2 199.78,70.19 199.98,70.19 200.13,70.04 U6200.2 U6200.9 201.32,70.04 201.5,70.22 201.67,70.22 202.33,70.88 202.33,74.03 203.02,74.72 204.28,74.72 204.93,75.38 205.27,75.38 205.42,75.23 CON6202.6
  IN1 w0.079: v1(196.3,71.05) 196.04,71.05 195.94,70.95 195.94,70.68 196.09,70.53 197.25,70.53 197.85,69.93 197.85,68.62 197.13,67.91 193.09,67.91 191.76,69.23 191.76,73.5 188.83,76.43 184.7,76.43 184.14,76.98 179.88,76.98 179.32,77.54 179.17,77.54 177.42,79.3 171.73,79.3 170.66,80.36 170.15,80.36 169.82,80.03 169.16,80.03 168.83,80.36 164.05,80.36 163.29,81.12 156.73,81.12 156.66,81.05 152.23,81.05 151.62,81.65 148.64,81.65 148.33,81.97 144.54,81.97 143.84,81.26 142.35,81.26 142.02,80.94 136.29,80.94 135.45,81.77 135.45,83.57 135.81,83.93 135.81,84.3 137.01,85.5 137.54,85.5 139.25,87.21 139.45,87.21 140.05,87.81 140.05,88.77 139.09,89.73 137.71,89.73 137.49,89.52 137.49,88.88 137.22,88.61 136.71,88.61 136.27,89.05 135.39,89.05 v2(135.09,88.75)
  BOTTOM w0.109: v2(135.09,88.75) 135.09,88.88 135.03,88.94 134.83,88.94 134.71,88.82 134.71,88.49 134.91,88.29 134.91,85.46 U400.CU3
USB30_RX2-: length 112.7
  TOP w0.109: CON6202.5 205.42,75.85 205.15,75.58 204.85,75.58 204.19,74.92 202.93,74.92 202.12,74.12 202.12,70.97 201.58,70.42 201.45,70.42 201.33,70.54 U6200.10 U6200.1 200.12,70.54 199.98,70.4 199.78,70.4 199.77,70.39 199.5,70.39 199.29,70.61 199.29,70.78 v1(199.59,71.08) 198.84,71.08 198.18,71.75 196.06,71.75 195.75,71.43 195.75,71.26 v1(195.54,71.05)
  IN1 w0.079: v1(195.54,71.05) 195.78,70.81 195.78,70.61 196.03,70.37 197.18,70.37 197.69,69.87 197.69,68.69 197.07,68.06 193.16,68.06 191.92,69.3 191.92,73.56 188.9,76.59 184.76,76.59 184.21,77.14 179.95,77.14 179.39,77.7 179.24,77.7 177.48,79.46 171.79,79.46 170.73,80.52 170.09,80.52 169.76,80.19 169.23,80.19 168.9,80.52 164.11,80.52 163.36,81.27 156.66,81.27 156.6,81.21 152.29,81.21 151.69,81.81 148.71,81.81 148.39,82.13 144.48,82.13 143.77,81.42 142.28,81.42 141.96,81.09 136.35,81.09 135.61,81.84 135.61,83.5 135.97,83.86 135.97,84.24 137.07,85.34 137.61,85.34 139.31,87.05 139.52,87.05 140.21,87.74 140.21,88.83 139.16,89.89 137.64,89.89 137.34,89.58 137.34,88.95 137.16,88.77 136.77,88.77 136.34,89.2 135.16,89.2 v2(135.07,89.29)
  BOTTOM w0.109: v2(135.07,89.29) 134.92,89.14 134.74,89.14 134.51,88.91 134.51,88.4 134.71,88.2 134.71,85.53 134.42,85.24 U400.CT4
USB30_RX4+: length 189.9
  IN1 w0.079: v1(4.62,12.93) 4.42,13.12 4.19,13.12 3.74,13.58 3.74,14.33 9,19.59 9.89,19.59 10.65,20.34 11.86,20.34 14.51,22.99 15.73,22.99 17.11,24.37 17.11,26.31 18.64,27.84 18.64,29.92 21.56,32.83 21.56,34.58 22.48,35.5 22.48,36.34 24.55,38.42 25.97,38.42 26.55,38.99 27.53,38.99 28.22,39.67 30.74,39.67 31.09,40.03 38.07,40.03 38.43,39.67 44.29,39.67 44.75,40.13 48.93,40.13 51.24,42.44 51.68,42.44 51.69,42.44 51.74,42.44 55.47,46.17 59.53,46.17 64.34,50.98 64.34,51.78 70.25,57.7 70.25,61.74 73.65,65.14 73.65,65.93 75.24,67.52 76.01,67.52 77.69,69.19 77.69,69.76 80.05,72.13 80.05,72.46 83.26,75.66 83.43,75.66 83.94,76.18 83.94,76.92 84.65,77.62 84.65,79.14 85.49,79.98 85.97,79.98 87.09,81.1 89.54,81.1 91.02,82.58 91.59,82.58 91.78,82.76 94.75,82.76 99.51,87.52 104.82,87.52 105.04,87.3 108.17,87.3 109.66,85.8 110.39,85.8 110.92,85.28 110.92,84.75 111.16,84.5 111.16,82.63 111.59,82.2 111.59,81.79 111.83,81.56 111.88,81.56 112.77,80.67 114.44,80.67 115.27,81.51 116.11,81.51 116.37,81.77 119.31,81.77 119.89,82.34 119.96,82.34 120.18,82.56 120.18,84.15 124.04,88.01 124.45,88.01 125.29,88.86 125.29,89.1 126.41,90.21 128.04,90.21 128.19,90.06 132.87,90.06 133.75,89.18 133.75,88.78 134.85,87.67 134.85,86.27 133.76,85.18 133.76,84.58 133.56,84.38 v2(133.56,83.96)
  BOTTOM w0.109: CON7603.5 3.67,13.05 3.76,13.13 4.41,13.13 v1(4.62,12.93) ; v2(133.56,83.96) 133.52,83.96 U400.CN5
USB30_RX4-: length 189.8
  IN1 w0.079: v2(133.4,84.73) 133.5,84.73 133.6,84.84 133.6,85.24 134.69,86.33 134.69,87.61 133.59,88.71 133.59,89.12 132.81,89.9 128.12,89.9 127.97,90.05 126.47,90.05 125.45,89.03 125.45,88.79 124.51,87.86 124.11,87.86 120.34,84.08 120.34,82.49 120.03,82.19 119.96,82.19 119.38,81.61 116.43,81.61 116.17,81.35 115.33,81.35 114.5,80.52 112.7,80.52 111.82,81.4 111.76,81.4 111.44,81.73 111.44,82.13 111.01,82.56 111.01,84.43 110.76,84.68 110.76,85.21 110.32,85.65 109.6,85.65 108.1,87.15 104.98,87.15 104.76,87.36 99.58,87.36 94.82,82.6 91.84,82.6 91.66,82.42 91.08,82.42 89.6,80.94 87.15,80.94 86.04,79.82 85.55,79.82 84.8,79.07 84.8,77.55 84.1,76.85 84.1,76.11 83.5,75.51 83.32,75.51 80.21,72.39 80.21,72.06 77.85,69.69 77.85,69.13 76.08,67.36 75.31,67.36 73.81,65.86 73.81,65.07 70.41,61.67 70.41,57.64 64.49,51.72 64.49,50.91 59.6,46.01 55.54,46.01 51.81,42.28 51.62,42.28 51.3,42.28 48.99,39.97 44.81,39.97 44.35,39.52 38.36,39.52 38.01,39.87 31.16,39.87 30.8,39.52 28.28,39.52 27.6,38.83 26.62,38.83 26.04,38.26 24.62,38.26 22.63,36.27 22.63,35.44 21.71,34.52 21.71,32.77 18.8,29.85 18.8,27.77 17.27,26.24 17.27,24.31 15.8,22.83 14.57,22.83 11.92,20.19 10.72,20.19 9.96,19.43 9.06,19.43 3.9,14.26 3.9,13.64 4.26,13.28 4.5,13.28 4.62,13.4 v1(4.62,13.69)
  BOTTOM w0.109: U400.CN4 133,85.14 133,85.3 133.11,85.41 133.27,85.41 133.6,85.09 133.6,84.93 v2(133.4,84.73) ; v1(4.62,13.69) 4.72,13.59 4.72,13.51 4.54,13.33 3.84,13.33 3.62,13.55 CON7603.6
USB30_TX1+: length 82
  TOP w0.109: v2(199.12,89.93) 198.92,89.74 198.71,89.74 198.43,90.02 198.22,90.02 198.01,90.22 198.01,90.82 198.09,90.9 198.27,90.9 198.42,90.75 C6207.1
  IN1 w0.079: v2(199.12,89.93) 199.12,89.7 199.29,89.53 199.62,89.53 199.79,89.36 199.79,86.74 199.24,86.19 198.83,86.19 198.35,85.71 198.35,84.94 198.63,84.67 198.63,79.77 198,79.14 196.78,79.14 195.61,77.97 193.66,77.97 192.92,78.71 192.73,78.71 192.22,78.92 191.16,78.92 191.01,78.77 180.62,78.77 180.06,79.33 179.92,79.33 178.16,81.08 172.71,81.08 171.34,82.45 169.61,82.45 169.26,82.8 165.67,82.8 164.93,83.55 163.9,83.55 162.97,84.47 160.01,84.47 159.59,84.05 157.97,84.05 157.38,83.45 154.57,83.45 153.99,84.03 149.75,84.03 148.48,85.3 140.47,85.3 139.38,84.21 138.22,84.21 137.7,83.68 137.38,83.68 137.3,83.6 v2(137.3,83.36)
  BOTTOM w0.109: U400.DA8 136.68,83.2 136.84,83.36 v2(137.3,83.36)
USB30_TX1+_C: length 8.6
  TOP w0.109: CON6201.9 205.42,88.78 205.33,88.88 204.87,88.88 204.02,89.73 203.35,89.73 201.8,91.28 201.49,91.28 201.35,91.15 U6201.6 U6201.5 199.91,91.15 199.77,91.01 199.32,91.01 199.2,90.9 C6207.2
USB30_TX1-: length 82.1
  TOP w0.109: v2(199.12,89.17) 199.12,89.32 198.9,89.54 198.63,89.54 198.35,89.82 198.14,89.82 197.81,90.14 197.81,90.91 198.01,91.1 198.22,91.1 198.42,91.3 C6206.1
  IN1 w0.079: v2(199.12,89.17) 199.32,89.38 199.55,89.38 199.64,89.29 199.64,86.81 199.17,86.34 198.76,86.34 198.19,85.77 198.19,84.88 198.47,84.6 198.47,79.84 197.93,79.3 196.72,79.3 195.55,78.13 193.72,78.13 192.99,78.86 192.76,78.86 192.25,79.07 191.09,79.07 190.95,78.93 180.69,78.93 180.13,79.48 179.98,79.48 178.23,81.24 172.77,81.24 171.4,82.61 169.67,82.61 169.33,82.96 165.74,82.96 164.99,83.7 163.96,83.7 163.04,84.63 159.95,84.63 159.52,84.21 157.91,84.21 157.31,83.61 154.64,83.61 154.06,84.19 149.81,84.19 148.54,85.46 140.41,85.46 139.31,84.37 138.16,84.37 137.63,83.84 137.52,83.84 v2(137.31,84.05)
  BOTTOM w0.109: U400.DA7 136.96,83.69 v2(137.31,84.05)
USB30_TX1-_C: length 8.6
  TOP w0.109: C6206.2 199.2,91.35 199.34,91.21 199.67,91.21 200.11,91.65 U6201.4 U6201.7 201.29,91.65 201.46,91.48 201.88,91.48 203.44,89.93 204.1,89.93 204.95,89.08 205.33,89.08 205.42,89.16 CON6201.8
USB30_TX2+: length 75.6
  TOP w0.109: C6209.1 198.24,68.59 198.09,68.73 197.61,68.73 197.13,69.21 196.82,69.21 v1(196.74,69.14)
  IN1 w0.079: v2(136.17,82.64) 136.03,82.64 135.95,82.56 135.95,82 136.4,81.56 138,81.56 138.46,82.02 142.51,82.02 143.44,82.95 148.54,82.95 148.7,82.78 152.94,82.78 153.51,82.21 156.38,82.21 156.78,81.81 163.69,81.81 164.28,81.23 169.09,81.23 169.22,81.36 170.88,81.36 172.24,80 177.71,80 179.47,78.24 179.61,78.24 180.17,77.68 184.43,77.68 184.99,77.13 189.12,77.13 192.46,73.79 192.46,69.62 193.46,68.62 196.84,68.62 197.13,68.9 197.13,69.22 197.07,69.28 196.88,69.28 v1(196.74,69.14)
  BOTTOM w0.109: U400.CW8 135.52,83.04 135.44,82.97 135.44,82.81 135.54,82.71 136.1,82.71 v2(136.17,82.64)
USB30_TX2+_C: length 8.3
  TOP w0.109: CON6202.9 205.42,69.19 205.29,69.32 204.98,69.32 204.36,69.94 203.31,69.94 202.05,68.69 201.6,68.69 201.45,68.54 U6200.6 U6200.5 200.05,68.54 199.92,68.68 199.43,68.68 C6209.2
USB30_TX2-: length 75.6
  TOP w0.109: v1(197.15,69.65) 197.15,69.47 197.69,68.93 198.13,68.93 198.24,69.04 C6208.1
  IN1 w0.079: v2(136.08,83.38) 135.79,83.09 135.79,81.94 136.33,81.4 138.07,81.4 138.53,81.86 142.57,81.86 143.5,82.79 148.47,82.79 148.64,82.62 152.88,82.62 153.44,82.06 156.31,82.06 156.71,81.66 163.63,81.66 164.21,81.07 169.16,81.07 169.29,81.2 170.81,81.2 172.18,79.84 177.65,79.84 179.4,78.08 179.55,78.08 180.11,77.52 184.37,77.52 184.92,76.97 189.06,76.97 192.31,73.72 192.31,69.55 193.4,68.46 196.91,68.46 197.28,68.84 197.28,69.28 197.15,69.42 v1(197.15,69.65)
  BOTTOM w0.109: U400.CW7 v2(136.08,83.38)
USB30_TX2-_C: length 8.3
  TOP w0.109: C6208.2 199.42,68.88 199.97,68.88 200.13,69.04 U6200.4 U6200.7 201.44,69.04 201.59,68.9 201.97,68.9 203.22,70.15 204.44,70.15 205.07,69.52 205.27,69.52 205.42,69.67 CON6202.8
USB30_TX4+: length 198
  IN1 w0.079: v1(4.14,9.78) 3.84,10.08 3.84,11.16 2.93,12.07 2.93,14.18 8.76,20.01 9.62,20.01 10.41,20.8 11.7,20.8 14.53,23.62 15.7,23.62 16.56,24.48 16.56,26.32 18.24,27.99 18.24,30.23 21.16,33.15 21.16,34.75 21.92,35.51 21.92,37.16 23.56,38.8 25.81,38.8 26.45,39.44 27.44,39.44 28.06,40.06 30.58,40.06 30.93,40.41 38.4,40.41 39.29,41.3 42.37,41.3 42.72,40.95 47.42,40.95 47.95,41.48 49.74,41.48 51.15,42.9 51.62,42.9 55.28,46.56 59.3,46.56 63.93,51.19 63.93,52.23 69.19,57.49 69.19,61.38 73.16,65.34 73.16,66.78 73.78,67.41 74.29,67.92 75.87,67.92 77.13,69.18 77.13,69.81 79.4,72.08 79.4,72.46 82.74,75.79 82.74,76.25 84.02,77.53 84.02,79.27 85.32,80.57 85.92,80.57 86.85,81.5 89.39,81.5 90.96,83.07 91.49,83.07 92.2,83.78 94.3,83.78 98.48,87.96 103.35,87.96 104.19,88.8 107.24,88.8 109.73,86.31 110.93,86.31 111.89,85.35 111.89,83.09 112.18,82.8 112.54,82.8 113.04,82.3 115.78,82.3 115.91,82.17 119.14,82.17 119.47,82.49 119.47,84.14 119.68,84.35 119.84,84.35 123.9,88.42 124.31,88.42 124.91,89.02 124.91,89.27 126.3,90.66 128.15,90.66 128.3,90.51 133.28,90.51 134.32,89.47 134.32,88.76 135.27,87.81 135.27,86.27 134.46,85.47 134.46,84.55 133.98,84.07 133.98,83.72 v2(134.36,83.34)
  BOTTOM w0.109: U400.CR8 134.07,83.04 v2(134.36,83.34) ; v1(4.14,9.78) 3.86,10.06 3.86,10.26 3.61,10.51 2.49,10.51 2.37,10.63 2.37,11.11 2.49,11.23 2.59,11.23 2.77,11.05 CON7603.1
USB30_TX4-: length 198
  IN1 w0.079: v1(3.38,9.78) 3.68,10.08 3.68,11.1 2.77,12 2.77,14.24 8.7,20.17 9.56,20.17 10.35,20.95 11.64,20.95 14.46,23.78 15.63,23.78 16.4,24.55 16.4,26.38 18.08,28.06 18.08,30.3 21,33.22 21,34.82 21.76,35.58 21.76,37.22 23.49,38.96 25.75,38.96 26.39,39.6 27.37,39.6 27.99,40.21 30.51,40.21 30.87,40.57 38.34,40.57 39.23,41.46 42.44,41.46 42.78,41.11 47.36,41.11 47.88,41.64 49.67,41.64 51.09,43.06 51.55,43.06 55.21,46.71 59.24,46.71 63.78,51.25 63.78,52.3 69.04,57.55 69.04,61.44 73,65.4 73,66.85 74.22,68.07 75.81,68.07 76.97,69.24 76.97,69.87 79.24,72.14 79.24,72.52 82.58,75.86 82.58,76.32 83.86,77.6 83.86,79.33 85.25,80.72 85.85,80.72 86.78,81.65 89.32,81.65 90.89,83.22 91.42,83.22 92.13,83.93 94.23,83.93 98.42,88.12 103.29,88.12 104.12,88.95 107.3,88.95 109.79,86.46 111,86.46 112.04,85.42 112.04,83.15 112.24,82.95 112.61,82.95 113.1,82.46 115.84,82.46 115.97,82.32 119.08,82.32 119.31,82.56 119.31,84.2 119.62,84.51 119.77,84.51 123.84,88.57 124.24,88.57 124.75,89.08 124.75,89.33 126.24,90.81 128.22,90.81 128.37,90.66 133.35,90.66 134.48,89.53 134.48,88.82 135.43,87.88 135.43,86.21 134.62,85.4 134.62,84.48 134.36,84.22 v2(134.36,83.92)
  BOTTOM w0.109: v1(3.38,9.78) 3.66,10.06 3.66,10.17 3.52,10.32 2.4,10.32 2.17,10.55 2.17,11.19 2.41,11.43 2.64,11.43 2.76,11.55 CON7603.2 ; v2(134.36,83.92) 134.14,83.69 U400.CR7
USB_CHARGER_STATUS#: length 120.4
  TOP w0.076: 195.45,14.13 195.44,14.14 195.44,15.04 U4700.G2
  TOP w0.109: U6203.9 198.59,85.06 v1(198.97,85.06) ; 195.45,14.13 195.73,13.85 195.73,13.39 v2(195.74,13.38) 195.88,13.24 195.88,12.52 196.21,12.19 196.75,12.19 196.9,12.04 198.55,12.04 198.65,11.93 198.65,11.35 v1(198.75,11.25) 198.8,11.25 199.34,10.72 R4820.2
  IN1 w0.079: v1(175.16,41.93) 175.16,40.67 175.6,40.23 175.6,38.97 176.39,38.18 179.8,38.18 181.04,36.94 181.04,36.44 182.08,35.4 182.08,32.87 184,30.94 184,30.14 186.71,27.43 186.71,26.39 186.94,26.16 187.4,26.16 190.5,23.07 190.5,21.43 191.92,20.01 191.92,18.64 191.97,18.59 191.97,16.02 193.29,14.7 194.51,14.7 195.74,13.47 v2(195.74,13.38) ; v1(201.06,51.43) 202,52.37 202.13,52.37 202.41,52.65 202.41,53.44 203.25,54.28 203.25,57.82 204.82,59.4 204.82,60.94 204.5,61.26 203.96,61.26 203.53,61.69 203.53,62.53 201.79,64.28 201.79,68.93 201.4,69.32 201.4,70.51 201.98,71.09 201.98,74.37 v1(201.5,74.85)
  IN3 w0.089: v1(198.97,85.06) 198.97,80.6 199.95,79.63 199.95,78.86 200.32,78.49 200.32,77.8 200.57,77.54 201.27,77.54 201.81,77 201.81,75.16 v1(201.5,74.85)
  BOTTOM w0.109: v1(201.06,51.43) 200.81,51.69 196.98,51.69 196.21,52.45 192.99,52.45 192.45,52.98 191.44,52.98 191.11,52.65 190.68,52.65 190.02,53.31 189.1,53.31 187.59,51.8 187.44,51.8 186.79,51.15 186.08,51.15 185.85,50.93 183.75,50.93 182.22,49.39 181.58,49.39 180.32,48.13 179.63,48.13 177.92,46.43 177.92,45.27 177.17,44.51 177.17,43.94 v1(175.16,41.93)
USB_CYPRESS_BOT_DN: length 37.9
  TOP w0.109: v2(209.89,108.82) 209.69,108.82 209.57,108.7 209.57,108.55 209.67,108.44 210.19,108.44 210.83,109.08 210.85,109.09 CON6300.A7
  BOTTOM w0.109: U6100.21 194.81,84.29 194.97,84.45 196.49,84.45 197.28,84.78 198.39,85.89 198.75,86.77 198.75,87.68 198.26,88.87 198.18,88.95 198.11,89.11 198.11,89.3 199.03,91.5 199.03,91.98 199.21,92.42 200.11,93.32 201.08,94.29 201.39,95.03 201.39,96.44 201.16,96.99 201.16,102.77 201.81,104.32 202.22,104.73 203.39,105.22 203.39,105.22 203.43,105.24 205.47,107.28 205.89,107.69 205.89,108.58 205.97,108.66 206.1,108.66 D6314.2 206.17,108.5 206.45,108.22 207.78,108.22 207.91,108.35 208.95,108.35 209.42,108.82 v2(209.89,108.82)
USB_CYPRESS_BOT_DP: length 38
  TOP w0.109: CON6300.A6 210.66,108.59 210.58,108.51 210.28,108.21 209.58,108.21 209.34,108.45 209.34,108.79 209.5,108.95 v2(209.5,109.22)
  BOTTOM w0.109: U6100.20 196.48,84.69 197.15,84.97 198.2,86.02 198.53,86.81 198.53,87.63 198.07,88.74 197.99,88.82 197.89,89.07 197.89,89.34 198.8,91.55 198.8,92.02 199.02,92.54 200.89,94.42 201.17,95.08 201.17,96.39 200.94,96.94 200.94,102.81 201.62,104.45 202.09,104.92 203.31,105.43 205.16,107.28 205.66,107.78 205.66,108.66 205.93,108.93 206.35,108.93 206.62,108.66 D6314.1 206.76,108.45 207.69,108.45 207.82,108.58 208.86,108.58 v2(209.5,109.22)
USB_CYPRESS_TOP_DN: length 40
  TOP w0.109: v2(212.09,108.46) 212.2,108.34 CON6300.B7
  BOTTOM w0.109: U6100.19 194.79,85.09 194.82,85.11 196.21,85.11 196.86,85.38 197.79,86.31 198.02,86.86 198.02,87.59 197.66,88.45 197.58,88.53 197.38,89.01 197.38,89.42 198.27,91.57 198.27,92.03 198.6,92.84 200.12,94.36 200.12,95.91 199.87,96.52 199.87,101.62 201.17,104.76 201.72,105.31 201.74,105.31 202.32,105.55 202.33,105.56 202.7,105.71 202.71,105.71 203.01,105.83 203.03,105.85 203.03,105.85 204.77,107.58 204.77,107.59 205.15,107.98 205.15,109.83 205.61,110.28 206.44,110.28 207.23,109.5 207.41,109.5 207.52,109.39 D6313.2 207.52,109.28 207.78,109.02 208.16,109.02 208.76,109.62 209.53,109.62 209.67,109.57 210.07,109.17 211.23,108.69 211.86,108.69 v2(212.09,108.46)
USB_CYPRESS_TOP_DP: length 40
  TOP w0.109: v2(212.09,109.02) 212.26,108.84 CON6300.B6
  BOTTOM w0.109: v2(212.09,109.02) 211.98,108.91 211.28,108.91 210.19,109.36 209.79,109.76 209.58,109.85 208.67,109.85 208.2,109.38 D6313.1 207.97,109.63 207.88,109.72 207.32,109.72 206.54,110.5 205.51,110.5 204.93,109.92 204.93,108.07 204.54,107.68 204.54,107.68 202.9,106.04 202.89,106.03 202.89,106.02 202.67,105.93 202.65,105.93 201.59,105.49 200.98,104.88 199.65,101.66 199.65,96.47 199.9,95.87 199.9,94.45 198.41,92.97 198.05,92.08 198.05,91.61 197.17,89.51 197.16,89.47 197.16,88.97 197.39,88.4 197.47,88.33 197.47,88.33 197.79,87.55 197.79,86.9 197.6,86.43 196.74,85.57 196.17,85.34 194.95,85.34 194.79,85.49 U6100.18
USB_ID: length 3.8
  BOTTOM w0.109: U400.DF1 139.26,86.61 140.41,87.75 140.41,88.77 139.9,89.28 R1302.2
USB_OC1#: length 6.9
  BOTTOM w0.079: U400.DH52 139.98,63.13 139.98,62.47 140.12,62.34 140.12,61 140.4,60.72
  BOTTOM w0.109: R406.2 143.66,59.7 143.33,60.03 141.09,60.03 140.4,60.72

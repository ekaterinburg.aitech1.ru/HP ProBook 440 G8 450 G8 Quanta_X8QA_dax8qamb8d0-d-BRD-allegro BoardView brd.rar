# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI1_CLK_E2: length 7.6
  TOP w0.076: U4700.F12 195.14,21.87 195.46,22.19 195.46,22.5
  TOP w0.109: R4708.1 190.98,26.21 v1(190.98,25.42) 190.98,25.14 192.48,23.64 194.51,23.64 195.46,22.7 195.46,22.5
PCH_SPI1_CLK_R1: length 2.6
  TOP w0.109: R5602.2 163.16,72.79 C1100.1 161.93,72.79 161.87,72.84 R1100.2
PCH_SPI1_CLK_R2: length 23.1
  TOP w0.109: v2(140.5,70.59) 140.92,70.17 144.25,70.17 144.54,69.88 148.01,69.88 148.5,70.37 148.82,70.37 149.62,69.57 149.98,69.57 150.14,69.51 150.41,69.24 151.31,69.24 151.62,69.55 154.99,69.55 156.32,70.89 156.5,70.89 158.56,72.95 160.14,72.95 160.25,72.84 R1100.1
  BOTTOM w0.109: U400.DJ37 140.22,70.31 v2(140.5,70.59)
PCH_SPI1_SI: length 52.5
  TOP w0.109: U5100.21 163.89,65.38 v1(163.71,65.56) ; v1(160.31,89.26) 159.8,89.77 159.8,91.43 160.2,91.82 R5624.1 ; R5604.1 159.03,74.15 R5603.2 159.67,74.65 159.92,74.9 159.92,75.11 160.55,75.75 161.17,75.75 161.75,76.32 R5635.1 162.55,76.32 v1(162.69,76.46)
  BOTTOM w0.109: U5604.5 158.08,90.92 U5602.5 158.05,90.17 158.5,89.72 159.85,89.72 v1(160.31,89.26) 160.43,89.14 160.43,88.89 160.54,88.78 163.32,88.78 163.42,88.67 163.42,88.45 163.3,88.32 160.54,88.32 160.43,88.21 160.43,87.98 160.54,87.86 162.42,87.86 162.52,87.77 162.52,87.54 162.39,87.41 160.54,87.41 160.43,87.29 160.43,87.06 160.54,86.95 161.4,86.95 161.51,86.84 161.51,86.61 161.4,86.49 160.54,86.49 160.43,86.38 160.43,86.12 160.54,86.01 160.96,86.01 161.15,85.82 161.15,84.5 160.69,84.04 160.69,82.97 162.37,81.29 162.37,80.14 163.49,79.01 163.49,77.76 163.06,77.33 163.06,76.83 v1(162.69,76.46) 162.37,76.14 162.37,73.16 162.37,73.16 162.37,73.1 162.69,72.78 162.69,72.44 162.73,72.4 162.73,71.58 163.14,71.17 TP5602.1 163.25,70.5 163.25,66.02 v1(163.71,65.56)
PCH_SPI1_SI_E1: length 90.7
  TOP w0.109: R5603.1 159.54,75.25 160.4,76.11 161.02,76.11 162.11,77.2 162.8,77.2 163.21,76.79 164.94,76.79 165.87,75.85 165.87,75.74 v1(166.63,74.98) 166.63,74.41 v1(167.18,73.86) ; R4709.2 195.92,26.45 195.27,27.1 195.27,27.99 195.43,28.14 196.32,28.14 v2(196.7,28.52)
  BOTTOM w0.109: v1(167.18,73.86) 167.43,73.61 167.43,72.31 167.58,72.16 167.58,71.73 168.22,71.09 168.22,70.67 168.58,70.3 168.58,67.12 170.13,65.57 170.13,61.01 169.48,60.36 169.48,50.79 169.68,50.59 169.68,47.93 169.53,47.79 169.53,46.64 168.91,46.02 168.91,44.56 168.17,43.82 168.17,42.06 168.12,42.01 168.12,38.99 166.74,37.61 166.74,34 167.9,32.83 170.72,32.83 171.5,32.06 176.34,32.06 177.86,33.58 181.34,33.58 181.71,33.21 183.82,33.21 184.95,32.08 192.2,32.08 194.59,29.69 196.39,29.69 196.7,29.38 v2(196.7,28.52)
PCH_SPI1_SI_E2: length 5.7
  TOP w0.076: U4700.H11 196.41,21.31 196.72,21.61 196.72,22.63 196.9,22.81 196.9,22.91
  TOP w0.109: 196.9,22.91 196.9,24.05 v1(197.13,24.28) 196.6,24.81 R4709.1
PCH_SPI1_SI_R1: length 12.9
  TOP w0.109: R1238.1 R5604.2 158.33,73.44 v1(157.35,72.46) 157.35,72.43 156.3,71.38 156.12,71.38 155.33,70.59 151.96,70.59 151.36,69.99 150.33,69.99 150.13,70.07 149.81,70.07 149.41,70.47 149.13,70.47 148.82,70.79 R1104.2
PCH_SPI1_SI_R2: length 8.9
  TOP w0.109: R1104.1 147.75,70.38 144.89,70.38 144.29,70.97 140.66,70.97 140.57,71.06 v2(140.57,71.39)
  BOTTOM w0.109: U400.DJ35 140.57,71.36 v2(140.57,71.39)
PCH_SPI1_SO: length 41.5
  TOP w0.109: v1(166.39,70.07) 165.76,69.44 163.73,69.44 163.35,69.07 163.35,68.66 163.22,68.53 163.22,68.16 162.61,67.55 R5108.2 162.57,67.29 162.57,66.76 162.39,66.58 U5100.24
  BOTTOM w0.109: U5604.2 167.61,93.46 U5602.2 168.02,93.49 168.91,92.61 168.91,89.7 167.5,88.29 164.33,88.29 161.94,85.9 161.94,84.08 161.43,83.57 161.43,83.26 164.23,80.46 164.23,77.93 164.77,77.39 164.77,77.31 165.25,76.84 165.25,75.34 166.33,74.25 166.33,73.72 165.78,73.18 165.78,72.29 R5606.1 165.89,71.93 165.89,71.4 165.53,71.04 TP5603.1 166.04,70.79 166.06,70.81 R5605.2 166.27,70.4 166.42,70.26 166.42,70.1 v1(166.39,70.07)
PCH_SPI1_SO_E1: length 71.9
  TOP w0.109: R4711.2 192.66,26.85 192.76,26.94 192.76,27.51 v2(191.84,28.42)
  BOTTOM w0.109: R5605.1 166.72,70.54 167.28,69.98 167.28,69.16 167.85,68.59 167.85,66.37 168.83,65.38 168.83,63.14 169.3,62.68 169.3,61.21 168.76,60.67 168.76,50.21 168.95,50.02 168.95,48.27 168.79,48.12 168.79,46.94 168.11,46.27 168.11,45 167.42,44.31 167.42,43.07 166.62,42.27 166.62,40.28 166,39.66 166,33.69 167.6,32.1 170.42,32.1 171.18,31.33 176.64,31.33 178.15,32.84 181.04,32.84 181.41,32.47 183.51,32.47 184.64,31.34 190.12,31.34 191.84,29.61 v2(191.84,28.42)
PCH_SPI1_SO_E2: length 6.7
  TOP w0.109: R4711.1 193.11,24.54 193.61,24.04 195.03,24.04 v1(195.11,23.96) 195.11,23.66 195.84,22.93 195.84,21.94 U4700.G12
PCH_SPI1_SO_R1: length 24.5
  TOP w0.109: v1(164.24,77.24) 163.91,77.57 161.95,77.57 160.87,76.48 160.24,76.48 159.03,75.27 159.03,74.75 157.17,72.9 157.02,72.9 156.81,72.68 156.2,72.68 155.87,72.36 155.87,71.64 155.19,70.96 151.8,70.96 151.21,70.36 150.39,70.36 150.17,70.45 150.05,70.57 R1103.2
  BOTTOM w0.109: R5606.2 165.2,72.26 165.31,72.37 165.31,73.24 165.96,73.89 165.96,74.1 164.88,75.19 164.88,76.6 v1(164.24,77.24)
PCH_SPI1_SO_R2: length 12.4
  TOP w0.109: R1103.1 149.12,70.84 148.82,71.14 147.98,71.14 147.58,70.75 145.19,70.75 144.04,71.9 142.31,71.9 141.31,72.89 v1(140.92,72.89) 140.9,72.87 140.9,72.04 140.67,71.82 140.4,71.82 140.03,71.44 v2(140.03,71.44)
  BOTTOM w0.109: v2(140.03,71.44) 140.05,71.47 140.05,71.75 U400.DJ33
PCH_SPI_CS0#: length 35.2
  TOP w0.109: v1(168.76,95.07) 168.35,95.07 168.12,95.29 R5623.2
  BOTTOM w0.109: R5612.2 167.09,70.81 167.09,71.16 R5613.1 166.72,71.73 166.67,71.78 166.67,72.1 166.76,72.32 166.93,72.49 TP5600.1 166.93,73.38 166.7,73.61 166.7,74.41 165.61,75.49 165.61,77 165.14,77.48 165.14,77.56 164.6,78.1 164.6,80.7 162.36,82.93 162.36,85.8 164.48,87.92 167.65,87.92 169.29,89.56 169.29,92.86 168.76,93.39 v1(168.76,95.07) 168.45,94.76 U5602.1 166.85,94.76 U5604.1
PCH_SPI_CS0#_E1: length 70.5
  TOP w0.109: R4707.2 192.97,27.84 v2(192.39,28.42)
  BOTTOM w0.109: v2(192.39,28.42) 192.23,28.59 192.23,29.77 190.28,31.71 184.8,31.71 183.67,32.84 181.56,32.84 181.19,33.21 178,33.21 176.49,31.7 171.34,31.7 170.57,32.47 167.75,32.47 166.37,33.84 166.37,37.76 167.66,39.05 167.66,42.34 167.79,42.46 167.79,43.96 168.54,44.71 168.54,46.17 169.16,46.79 169.16,47.95 169.31,48.1 169.31,50.27 169.12,50.46 169.12,60.51 169.66,61.06 169.66,62.83 169.2,63.29 169.2,65.54 168.21,66.52 168.21,68.75 167.7,69.26 167.7,70.21 167.74,70.25 R5612.1
PCH_SPI_CS0#_E2: length 8.6
  TOP w0.109: U4700.G11 195.76,21.24 196.08,21.55 196.08,22.2 196.03,22.25 196.03,23.04 195.7,23.36 195.7,23.96 195.29,24.38 193.85,24.38 v1(193.77,24.46) 193.77,24.79 193.72,24.84 R4707.1
PCH_SPI_CS0#_R1: length 20.8
  TOP w0.109: R1105.2 148.55,69.08 149.87,69.08 150.21,68.74 151.51,68.74 151.82,69.05 155.19,69.05 156.52,70.39 156.71,70.39 158.76,72.45 159.95,72.45 160.05,72.34 161.61,72.34 161.75,72.2 162.55,72.2 162.61,72.26 163.36,72.26 163.4,72.22 166.07,72.22 v1(166.34,72.49)
  BOTTOM w0.109: R5613.2 166.27,72.42 v1(166.34,72.49)
PCH_SPI_CS0#_R2: length 9.4
  TOP w0.109: R1105.1 147.27,69.01 146.89,69.39 144.48,69.39 144.27,69.59 142.57,69.59 142.21,69.96 140.56,69.96 v2(139.93,70.59)
  BOTTOM w0.109: v2(139.93,70.59) 139.57,70.23 U400.DG37
PCH_SPI_IO2: length 45.5
  TOP w0.109: R5607.2 151.81,67.92 152.06,68.17 153.69,68.17 R1245.2 153.83,68.3 R1246.2 154.63,68.3 154.96,68.63 155.28,68.63 156.68,70.02 156.86,70.02 158.92,72.08 159.79,72.08 159.9,71.97 161.46,71.97 161.6,71.83 162.58,71.83 R1248.1 163.15,71.8 v1(163.19,71.83) 163.24,71.78 R5637.1 ; R5627.1 165.43,88.92 v1(165.1,89.25) 164.97,89.38 R5626.1
  BOTTOM w0.109: U5604.3 167.61,92.19 U5602.3 168.28,92.22 168.53,91.97 168.53,89.84 167.35,88.66 165.69,88.66 v1(165.1,89.25) 164.44,89.25 163.88,88.7 163.88,88.36 161.52,86 161.52,84.34 161.06,83.88 161.06,83.11 162.74,81.44 162.74,80.29 163.86,79.17 163.86,77.57 163.47,77.18 163.47,75 163.11,74.64 162.85,74.64 162.74,74.53 162.74,73.25 163.19,72.8 TP5611.1 v1(163.19,71.83)
PCH_SPI_IO2_R1: length 4.3
  TOP w0.109: R1246.1 154.44,68.69 152.65,68.69 v1(152.6,68.63) 151.93,68.63 R5607.1 151.48,68.37 151.17,68.07 R1102.2
PCH_SPI_IO2_R2: length 10.7
  TOP w0.109: R1102.1 v1(149.13,68.07) 148.86,68.07 148.44,68.48 147.1,68.48 146.56,69.02 144.32,69.02 144.12,69.22 142.19,69.22 142.13,69.16 140.89,69.16 v2(140.5,69.55)
  BOTTOM w0.109: U400.DJ39 140.22,69.27 v2(140.5,69.55)
PCH_SPI_IO3: length 7.8
  TOP w0.109: v1(156.92,94.26) 157.68,93.5 158.04,93.5 158.53,93 R5625.2 159.22,92.96 R5608.2
  BOTTOM w0.109: U5604.7 158.08,93.46 U5602.7 157.68,93.49 v1(156.92,94.26) 156.56,93.9 TP5610.1
PCH_SPI_IO3_R1: length 37.9
  TOP w0.109: R1221.1 151.31,72.44 151,72.13 151,71.47 R1101.2 151.15,71.32 155.04,71.32 155.51,71.79 155.51,72.52 155.73,72.74 R1224.1 155.91,73.05 156.66,73.05 158.62,75.01 158.62,76.12 159.51,77.01 160.75,77.01 v1(161.02,77.28) ; R5608.1 159.44,91.62 v1(159.44,88.63)
  BOTTOM w0.109: v1(161.02,77.28) 161.02,81.25 159.69,82.58 159.69,85.23 159.21,85.7 158.01,85.7 157.77,85.95 157.77,86.49 158,86.72 159.32,86.72 159.44,86.83 159.44,87.09 159.35,87.18 158.67,87.18 158.57,87.28 158.57,87.51 158.69,87.63 159.31,87.63 159.44,87.76 159.44,87.95 159.29,88.09 157.71,88.09 157.62,88.18 157.62,88.41 157.75,88.55 159.35,88.55 v1(159.44,88.63)
PCH_SPI_IO3_R2: length 15.4
  TOP w0.109: v2(139.22,70.59) 139.22,70.59 139.66,71.03 v1(139.66,71.92) 139.63,71.95 139.63,72.68 139.75,72.79 140.15,72.79 140.66,73.31 141.21,73.31 141.78,72.73 142.29,72.73 142.76,72.27 144.19,72.27 145.35,71.12 147.42,71.12 147.83,71.52 148.89,71.52 149.11,71.74 149.8,71.74 150.11,71.42 R1101.1
  BOTTOM w0.109: U400.DG35 139.22,70.66 v2(139.22,70.59)
PCH_TBT_PERST#: length 36.7
  IN1 w0.079: v1(158.52,64.72) 157.88,65.35 154.56,65.35 153.73,66.18 150.85,66.18 150.64,66.39 148.62,66.39 147.48,67.54 144.79,67.54 144.34,67.99 143.64,67.99 142.69,68.94 142.25,68.94 142.06,69.14 141.18,69.14 140.89,69.43 140.89,69.82 140.55,70.15 139.85,70.15 139.57,70.43 139.57,70.79 139.67,70.9 139.67,71.76 139.88,71.97 140.05,71.97 140.53,72.44 v2(140.54,72.44)
  BOTTOM w0.109: U1502.2 159.59,72.57 159.28,72.87 R803.1 ; U400.DJ31 140.53,72.53 140.53,72.46 v2(140.54,72.44) ; v1(158.52,64.72) 157.95,65.29 v1(157.95,66.04) 157.95,66.51 157.73,66.72 157.73,67.52 157.86,67.65 157.86,68.5 158.4,69.05 158.4,70.26 157.5,71.16 157.5,72.57 157.8,72.87 R803.1 ; R803.1 R1572.2
PCH_TCK: length 83.5
  TOP w0.109: v1(51.26,53.97) 50.57,53.29 50.01,53.29 49.71,52.98 CON7703.55
  IN2 w0.089: v1(98.02,84.15) 98.02,82.87 97.21,82.06 97.21,81.72 96.46,80.97 96.46,80.15 93.33,77.01 92.39,77.01 91.31,75.93 91.31,71.62 88.89,69.19 87.54,69.19 87.22,68.87 87.22,68.4 86.82,68 86.35,68 84.2,65.85 84.2,65.12 83.44,64.36 83.44,63.3 80.3,60.16 80.3,59.36 78.48,57.54 76.26,57.54 71.82,53.09 70.88,53.09 66.71,48.92 58.38,48.92 57.75,49.54 56.36,49.54 51.93,53.97 v1(51.26,53.97)
  BOTTOM w0.109: v1(98.02,84.15) 97.31,84.15 96.29,83.13 95.68,83.13 R620.1 96.09,83.64 TP605.1 96.6,83.89 97.32,84.61 98.16,84.61 98.69,84.08 99.42,84.08 100.21,83.3 U400.A7
PCH_TDI: length 9.4
  BOTTOM w0.109: U400.B12 101.08,81.53 99.57,81.53 98.55,80.5 98.55,80.21 97.35,79.01 97.35,78.1 97.44,78.02 97.75,77.88 97.94,77.7 97.94,77.13 R613.1 96.7,76.91 96.44,77.17 R610.1
PCH_TDO: length 14.4
  BOTTOM w0.109: R607.1 96.72,73.89 97.19,73.89 97.34,73.74 R612.1 97.34,73.22 97.46,73.09 98.33,73.09 98.57,73.33 98.57,75.79 99.43,76.65 99.43,79.26 100.15,79.98 100.29,79.98 100.55,80.25 102.85,80.25 103.04,80.43 103.04,80.89 U400.E12
PCH_TMS: length 7.4
  BOTTOM w0.109: R605.1 R611.1 95.07,82.09 95.53,81.63 98.53,81.63 99.12,82.22 100.51,82.22 U400.A9
PCH_TRST#: length 10.1
  BOTTOM w0.109: R615.1 104.05,90.82 103.71,91.16 101.82,91.16 101.65,90.99 101.65,90.58 101.48,90.41 R618.1 101.14,89.6 103.26,87.48 103.26,86.64 103.38,86.35 103.38,85.35 U400.H4
PCH_WLAN_RST#: length 59
  TOP w0.109: v1(178.87,86.42) 178.87,85.95 v1(179.04,85.77) 179.22,85.95 179.57,85.95 U4102.2 179.64,86.27 179.53,86.27 179.32,86.49 179.32,87.53 R812.1
  IN1 w0.079: v2(145.86,77.55) 145.86,77.55 146.37,78.06 148.35,78.06 148.76,77.65 150.62,77.65 151.69,76.58 152.75,76.58 153.92,75.41 154.21,75.41 154.99,74.63 158.64,74.63 160.66,76.65 161.2,76.65 161.67,77.12 163.37,77.12 164.19,76.29 169.99,76.29 170.67,75.62 172.45,75.62 172.86,76.03 176.41,76.03 176.5,76.12 177.78,76.12 178.02,76.03 179.23,76.03 179.66,76.45 183.85,76.45 v1(183.96,76.34)
  IN2 w0.089: v1(178.87,86.42) 178.87,86.1 181.41,83.56 181.41,82.47 181.73,82.14 181.73,80.24 183.96,78.01 v1(183.96,76.34)
  BOTTOM w0.109: v2(145.86,77.55) 145.85,77.55 145.85,77.55 145.85,77.57 145.44,77.98 144.68,77.98 U400.DV19
PCI_PLTRST#: length 436.9
  TOP w0.109: R4210.1 191.91,4.37 v1(191.43,4.86) 191.31,4.97 191.31,6.47 191.09,6.69 U4200.1 ; CON7602.40 10.17,5.43 9.69,4.95 8.96,4.95 8.12,5.79 8.12,10.82 7.59,11.35 7.59,13.85 v1(7.03,14.4) ; U1501.4 151.89,47.59 v1(151.2,46.9) 151.2,45.47 R1536.2 ; Q5101.2 168.48,66.44 168.2,66.17 168.02,66.17 167.82,65.97 R5120.1 167.28,65.91 v1(167.28,65.48) ; v1(168.1,86.69) 168.1,86.61 169.34,85.37 171.58,85.37 171.91,85.04 171.91,84.2 172.97,83.13 173.23,83.13 173.7,82.65 176.76,82.65 177.65,83.54 179.93,83.54 180.52,84.12 R4137.1 181.91,84.66 181.3,84.66 180.34,85.62 180.34,86.55 180.09,86.8 U4102.1 ; v1(181.96,46.96) 181.2,46.2 181.2,44.88 180.51,44.19 R7602.1 179.74,43.71 179.26,43.71 178.9,43.36 178.9,42.85 179.02,42.74 U7600.1 ; v1(78.85,58.92) 76.21,56.28 v1(76.21,50.99) 73.97,50.99 71.41,53.54 61.52,53.54 60.76,54.3 59.21,54.3 59.03,54.48 58.21,54.48 v1(57.83,54.1)
  IN1 w0.079: v1(191.43,4.86) 191.54,4.74 194.21,4.74 194.76,4.18 194.76,3.68 195.38,3.06 196.1,3.06 196.54,3.51 197.06,3.51 197.39,3.84 199.35,3.84 200.68,4.39 202.75,6.45 202.75,9.2 201.87,10.07 201.87,12.1 201.91,12.15 201.91,13.45 201.47,13.89 201.27,13.89 v2(201.14,14.02) 201.22,14.02 201.86,14.67 201.86,14.99 202.61,15.74 202.61,15.85 202.97,16.2 202.97,21.82 201.74,23.05 200.22,23.68 200,23.9 197.12,23.9 193.36,27.66 191.9,27.66 191.35,28.21 191.35,29.11 189.93,30.53 189.16,30.53 187.88,31.8 187.88,33.46 185.76,35.59 185.76,38.34 185.5,38.6 185.5,39.49 186.04,40.04 186.04,44.15 185.05,45.14 184.5,45.14 183.23,46.42 182.5,46.42 v1(181.96,46.96) 181.91,47.02 179.07,47.02 177.45,48.64 177.13,48.64 176.17,49.59 174.48,49.59 174.19,49.88 173.4,49.88 173.04,49.52 169.28,49.52 168.71,48.94 v1(167.54,48.94) 167.13,48.54 165.99,48.54 163.96,46.51 162.63,46.51 162.3,46.18 162.1,45.98 162.1,45.63 160.2,43.73 157.36,43.73 157.24,43.61 155.1,43.61 153.3,45.41 152.8,45.41 151.32,46.9 v1(151.2,46.9) ; v1(57.83,54.1) 57.12,54.81 51.53,54.81 51.28,55.06 47.72,55.06 47.34,54.68 42.67,54.68 41.81,53.82 40.48,53.82 35.37,58.93 29.68,58.93 29.37,59.24 28.4,59.24 23.04,53.88 21.06,53.88 20.48,53.3 18.25,53.3 16.91,51.96 v1(16.91,51.5) ; v1(181.61,73.1) 181.75,72.96 181.75,72.04 180.48,70.78 178.88,70.78 177.62,69.52 176.97,69.52 176.56,69.11 174.78,69.11 174.48,68.82 174.48,66.1 174.2,65.82 172.91,65.82 172.69,65.6 170.46,65.6 169.86,65.01 169.38,65.01 168.68,65.71 167.51,65.71 v1(167.28,65.48) 166.3,66.46 163.23,66.46 162.81,66.04 161.88,66.04 161.73,65.88 161.19,65.88 160.66,65.35 v1(158.51,65.35)
  IN3 w0.089: v1(181.61,73.1) 181.02,73.68 181.02,74.45 178.64,76.83 177.78,76.83 173.15,81.46 172.44,81.46 171.12,82.77 171.12,83.08 170.43,83.76 170.43,84.12 168.1,86.45 v1(168.1,86.69) ; v1(7.03,14.4) 6.33,15.11 6.33,15.66 6.98,16.31 6.98,19.28 6.1,20.16 6.1,35.37 9.6,38.88 9.6,41.28 11.66,43.33 12.72,43.33 14.2,44.81 14.2,47.02 16.14,48.96 16.14,50.73 v1(16.91,51.5)
  BOTTOM w0.109: CON4300.50 6.93,14.5 v1(7.03,14.4) ; v1(167.28,65.48) 167.25,65.46 167.25,58.62 167.75,58.12 167.75,54.32 167.03,53.59 167.03,49.45 v1(167.54,48.94) ; U6601.2 79.24,59.31 v1(78.85,58.92) ; R1550.2 R1533.1 ; R1533.1 159.72,70.78 159.72,67.44 158.51,66.23 v1(158.51,65.35) ; R1533.1 159.68,71.28 160.24,71.83 U1502.1 ; v1(76.21,50.99) 76.59,50.61 101.38,50.61 108.48,43.51 115.67,43.51 119.25,47.08 151.02,47.08 v1(151.2,46.9) ; v2(201.14,14.02) 201.44,14.02 202,13.46 202.41,13.46 202.73,13.14 Q4800.2
PCI_PLTRST#_R: length 6.8
  TOP w0.109: U4200.4 193.31,5.39 R4209.2 193.45,5.01 192.08,3.63 R4210.2 191.91,3.16 v1(191.41,2.66)
  BOTTOM w0.109: v1(191.41,2.66) 190.66,2.66 190.16,2.17 CON4202.50
PCIE4_RCOMPN: length 2.1
  TOP w0.109: v2(109.15,80.39) 109.27,80.26 R1304.1
  BOTTOM w0.109: v2(109.15,80.39) 109.15,80.4 109.01,80.4 U400.V12
PCIE4_RCOMPP: length 1.8
  TOP w0.109: v2(109.69,80.37) 109.72,80.35 R1304.2
  BOTTOM w0.109: U400.Y12 109.69,80.63 v2(109.69,80.37)
PCIE_CLKREQ_CR#: length 61.1
  TOP w0.109: R1411.1 179.35,45.13 179.34,45.14 Q7600.3 179.34,47.06 179.28,47.12 179.28,49.02 v1(179.28,49.03) 179.01,49.3 v1(178.41,49.3)
  IN1 w0.079: v2(138.73,76.03) 138.73,75.08 139.04,74.78 139.39,74.78 139.57,74.95 139.57,75.17 139.79,75.38 141.02,75.38 141.07,75.43 142.69,75.43 142.75,75.46 146.31,75.46 146.69,75.07 146.69,74.67 147.14,74.21 149.42,74.21 150.73,72.9 151.52,72.9 151.77,72.65 152.11,72.65 152.56,72.2 152.77,72.2 153.98,72.2 v2(154.43,71.75)
  IN3 w0.089: v2(154.43,71.75) 154.43,71.75 154.86,71.32 155.59,71.32 156.57,70.35 157.76,70.35 158.81,69.29 159.63,69.29 160.24,68.68 160.47,68.68 160.85,68.3 160.85,66.98 161.79,66.04 162.23,66.04 163.37,64.89 165.69,64.89 167.14,63.44 167.14,62.98 167.76,62.35 168.34,62.35 170.21,60.49 170.21,58.71 171.86,57.05 171.86,56.53 172.44,55.95 173.08,55.95 175.68,53.35 175.68,52.14 178.41,49.42 v1(178.41,49.3)
  BOTTOM w0.109: v2(138.73,76.03) 138.73,76.28 U400.DF23
PCIE_CLKREQ_CR#_R: length 6.4
  TOP w0.109: Q7600.1 178.66,48.08 v1(178.66,45.44) 178.66,42.81 178.62,42.77 U7600.2
PCIE_CLKREQ_LAN#: length 294.2
  TOP w0.109: v1(8.84,13.68) 8.85,13.68 CON7602.27
  IN1 w0.079: v1(168.74,39.88) 169.06,39.88 169.47,39.47 170.62,39.47 175.62,34.47 177.06,34.47 177.62,33.91 177.94,33.91 182.2,29.64 182.37,29.64 184.53,27.48 184.53,27.23 185.08,25.9 186.46,24.52 186.46,23.11 187.34,22.23 187.44,22.23 187.74,21.93 187.74,21.59 187.65,21.38 187.65,21.13 188.11,20.67 188.11,17.45 188.71,16.85 188.71,16.17 188.8,16.08 188.8,13.59 187.75,12.55 186.43,12.55 185.09,11.2 184.45,11.2 184.15,10.89 184.15,10.36 183.85,10.06 180.37,10.06 178.81,8.51 172.18,8.51 172.13,8.56 170.98,8.56 169.25,10.28 168.61,10.28 167.54,11.35 164.74,11.35 163.59,10.2 160.52,10.2 160.26,9.94 149.67,9.94 149.16,10.45 148.63,10.81 147.74,10.81 147.41,10.48 144.23,10.48 143.5,9.74 140.72,9.74 140.52,9.95 139.51,9.95 arc(139.47,9.94) 139.43,9.93 arc(139.24,9.82) 139.07,9.68 138.89,9.5 136.45,9.5 135.56,10.39 134.64,10.39 134.49,10.23 134.01,10.23 133.5,10.75 131.28,10.75 130.49,9.95 125.84,9.95 125.66,9.78 114.74,9.78 114.21,9.24 113.54,9.24 112.6,8.31 105.31,8.31 104.48,9.13 100.05,9.13 98.12,11.07 92.71,11.07 91.46,12.31 83.81,12.31 83.38,12.74 80.64,12.74 79.43,11.54 75.05,11.54 74.57,11.06 58.44,11.06 58.07,10.69 56.27,10.69 55.7,10.12 54.64,10.12 52.44,7.93 50.64,7.93 49.33,6.62 42.38,6.62 42.06,6.93 38.96,6.93 38.43,6.4 32.12,6.4 31.21,7.31 26.85,7.31 25.98,8.18 22.18,8.18 21.37,8.99 17.71,8.99 16.7,10.01 14.22,10.01 11.71,12.52 10.64,12.52 9.48,13.68 v1(8.84,13.68)
  IN3 w0.089: v1(170.67,56.24) 171.17,56.74 171.17,56.99 169.67,58.49 169.67,59.91 168.64,60.94 167.41,60.94 167.01,61.33 167.01,62.28 166.61,62.69 166.61,63.22 165.47,64.36 163.15,64.36 162.01,65.5 161.57,65.5 159.79,67.28 159.79,68.38 159.4,68.76 158.44,68.76 158.28,68.6 157.74,68.6 157.25,69.09 157.25,69.19 156.8,69.64 156.08,69.64 155.09,70.64 154.1,70.64 153.69,71.05 152.03,71.05 151.77,71.31 150.08,71.31 149.64,71.75 147.84,71.75 147.38,71.29 146.55,71.29 145.97,71.86 v2(145.95,71.86)
  BOTTOM w0.079: v2(145.95,71.86) 145.83,71.86 144.76,72.93 144.07,72.93 U400.DT30
  BOTTOM w0.109: v1(168.74,39.88) 168.74,41.79 168.79,41.84 168.79,43.56 169.53,44.3 169.53,45.76 170.74,46.97 170.74,51.36 171.21,51.83 171.21,54.37 170.67,54.91 v1(170.67,56.24) ; v2(145.95,71.86) 145.97,71.86 146.18,71.65 146.38,71.57 147.22,71.57 147.59,71.95 149.64,71.95 149.86,71.73 150.52,71.73 150.57,71.68 150.57,71.47 150.57,71.44 150.72,71.29 150.75,71.29 150.95,71.1 R1406.1
PCIE_CLKREQ_SSD#: length 351
  TOP w0.109: C4315.2 23.61,5.48 v1(24,5.08)
  IN1 w0.079: v2(145.62,72.82) 146.07,72.36 149.52,72.36 151.31,70.58 151.5,70.58 151.5,70.57 156.9,70.57 157.18,70.86 159.76,70.86 159.92,70.69 160.98,70.69 161.45,70.22 161.68,70.22 162.1,70.64 162.62,70.64 163.12,70.13 165.89,70.13 166.2,70.44 166.8,70.44 166.88,70.37 169.17,70.37 v1(170.1,69.44) ; v1(172.64,50.03) 172.96,50.35 174.38,50.35 174.68,50.05 176.36,50.05 177.32,49.1 177.64,49.1 178.63,48.11 181.47,48.11 182.69,46.88 183.42,46.88 184.7,45.6 185.24,45.6 186.5,44.34 186.5,39.26 186.34,39.09 186.34,37.18 187.55,35.96 187.55,34.47 188.36,33.65 188.36,31.97 189.4,30.94 189.74,30.94 191.5,29.18 191.5,28.28 191.89,27.89 193.36,27.89 196.34,24.9 199.48,24.9 199.86,24.52 201.76,24.52 202.29,24.3 204.37,22.22 204.37,17.17 204.14,16.94 204.14,15.5 203.69,15.06 203.69,13.88 203.25,13.44 203.25,11.06 204.01,10.3 204.01,6.8 204.26,6.55 204.82,6.55 205.23,6.14 205.23,5.43 204.67,4.87 201.83,4.87 200.81,3.86 199.65,3.38 197.58,3.38 196.81,2.6 195.19,2.6 194.34,3.45 193.32,3.45 193.01,3.15 187.73,3.15 187.53,2.94 187.53,2.59 187.02,2.08 183.84,2.08 182.25,2.74 179.8,2.74 179.17,2.11 174.39,2.11 arc(173.13,2.36) 172.06,3.07 168.15,6.98 165.5,6.98 165.13,6.61 163.83,6.61 162.52,5.29 161.2,5.29 161.11,5.38 133.32,5.38 132.97,5.03 104.47,5.03 103.47,6.03 102.09,6.03 101.66,6.46 99.25,6.46 98.19,7.52 96.31,7.52 95.78,8.05 76.68,8.05 75.65,7.02 75.65,2.7 74.57,1.62 65.87,1.62 64.49,2.99 52.45,2.99 51.2,4.24 26.19,4.24 25.35,5.08 v1(24,5.08) 22.41,5.08 20.57,6.92 17.27,6.92 14.31,3.97 6.42,3.97 6.07,4.32 6.07,14.12 v1(7.03,15.09)
  BOTTOM w0.109: U400.DW30 145.48,72.82 v2(145.62,72.82) 145.74,72.69 147.52,72.69 147.8,72.41 148.65,72.41 R1408.1 ; v1(172.64,50.03) 173.15,50.54 173.15,52.05 172.87,52.33 172.87,55.2 172.28,55.79 172.28,56.52 172.56,56.8 172.56,59 173,59.43 173,60.75 173.78,61.54 173.78,65.01 173.44,65.35 173.05,65.35 171.87,66.53 171.09,66.53 169.94,67.68 169.94,69.08 170.1,69.24 v1(170.1,69.44) ; v1(7.03,15.09) 6.95,15 CON4300.52
PCIE_CLKREQ_WLAN#: length 55.1
  TOP w0.109: Q4104.1 183.64,68.15 183.64,68.3 182.83,69.11 182.83,70.71 R4117.2 182.8,71.1 182.8,71.22 v1(182.03,71.99) 180.8,73.23 179.58,73.23 v1(179.37,73.02) ; R1404.1 154.55,72.27 v2(154.99,71.83)
  IN1 w0.079: v1(179.37,73.02) 179.08,72.73 177.69,72.73 176.4,71.44 173.35,71.44 171.74,73.05 168.19,73.05 167.63,72.49 167.05,72.49 166.75,72.19 166.28,71.99 163.92,71.99 163.62,72.29 162.91,72.29 162.63,72.01 160.75,72.01 160.12,72.64 158.71,72.64 158.36,72.3 156.88,72.3 156.41,71.83 v2(154.99,71.83) 154.87,71.83 154.56,72.14 154.43,72.14 154.1,72.46 152.66,72.46 152.22,72.9 151.88,72.9 151.62,73.16 150.85,73.16 149.52,74.48 147.24,74.48 146.95,74.77 146.95,75.18 146.41,75.72 142.64,75.72 142.58,75.69 140.87,75.69 140.84,75.66 139.61,75.66 139.22,75.27 v2(139.22,75.14)
  BOTTOM w0.109: v2(139.22,75.14) 139.57,75.49 U400.DG25
PCIE_CLKREQ_WWAN#: length 144.6
  TOP w0.109: v1(190.07,2.66) 190.45,3.04 190.52,3.04 C4203.1
  IN1 w0.079: v1(175.21,52.86) 175.21,52.85 177.77,52.85 178.28,53.36 180.31,53.36 180.82,52.85 180.82,52.53 181.87,51.49 184.21,51.49 185.67,50.02 185.67,47.87 187.61,45.94 189.08,45.94 190.09,44.92 190.09,41.76 189.79,41.45 189.79,35.41 190.84,34.36 190.84,32.23 192.7,30.37 193.11,30.37 193.89,29.59 196.37,29.59 196.45,29.51 197.14,29.51 198.03,29.14 200.09,29.14 201.95,27.28 202.2,27.17 202.88,27.17 203.89,26.16 204.04,26.16 205.94,24.27 205.94,24.08 206.27,23.75 207.01,23.75 207.44,24.18 207.74,24.18 208.02,23.9 208.02,23.51 209.02,22.51 209.02,21.72 210.26,20.48 210.26,7.47 207.48,4.69 207.48,4.1 207.36,3.99 207.36,3.1 206.32,2.05 197.36,2.05 197.14,2.27 195.16,2.27 194.24,3.2 193.42,3.2 192.44,2.21 191.11,2.21 190.65,2.66 v1(190.07,2.66)
  IN3 w0.089: v2(146.5,71.92) 146.85,71.56 147.27,71.56 147.74,72.03 149.74,72.03 150.19,71.58 151.9,71.58 152.15,71.33 153.79,71.33 154.21,70.9 155.22,70.9 156.2,69.92 156.9,69.92 157.57,69.25 157.57,69.15 157.85,68.87 158.17,68.87 158.33,69.03 159.52,69.03 160.13,68.41 160.36,68.41 160.58,68.18 160.58,66.87 161.68,65.77 162.12,65.77 163.26,64.63 165.58,64.63 166.88,63.33 166.88,62.8 167.28,62.39 167.28,61.45 167.53,61.21 168.75,61.21 169.94,60.02 169.94,58.6 171.6,56.94 171.6,56.42 172.33,55.68 172.88,55.68 175.21,53.35 v1(175.21,52.86)
  BOTTOM w0.079: v2(146.5,71.92) 146.23,72.18 145.75,72.18 144.84,73.09 144.55,73.09 U400.DV30
  BOTTOM w0.109: CON4202.52 189.66,2.26 v1(190.07,2.66) ; R1403.1 149.16,72.21 147.72,72.21 147.65,72.29 146.87,72.29 v2(146.5,71.92)
PCIE_RCOMPN: length 5
  BOTTOM w0.079: U400.DT9 143.9,82.52 144.3,82.11 144.88,82.11 145.02,81.97 145.24,81.97
  BOTTOM w0.305: R1300.1 147.91,82.83 147.05,81.97 145.24,81.97
PCIE_RCOMPP: length 5
  BOTTOM w0.079: 145.36,82.36 145.28,82.27 144.37,82.27 144.3,82.34 U400.DV9
  BOTTOM w0.305: 145.36,82.36 145.78,82.36 146.12,82.7 146.35,82.7 146.7,82.36 146.89,82.36 147.44,82.91 147.44,83.25 147.57,83.38 147.98,83.38 R1300.2
PCIE_REQ_GPU#: length 164.3
  TOP w0.109: v1(76.98,51.48) 76.98,52.17 83.21,58.4 83.21,60.53 v1(83.59,60.91) 83.59,62.18 83.83,62.42 v1(83.83,64.2)
  IN1 w0.079: v2(156.35,72.26) 156.2,72.41 154.53,72.41 154.23,72.72 152.78,72.72 152.34,73.16 151.98,73.16 151.74,73.4 151.74,74.34 151.59,74.5 151.08,74.5 150.26,75.31 148.94,75.31 148.59,74.95 v2(148.18,74.95) ; v1(151.92,49.25) 152.69,49.25 153.39,48.55 156.15,48.55 156.22,48.48 156.71,48.48 157.41,49.18 157.41,50.53 156.74,51.2 156.74,53.17 157.05,53.48 157.12,53.48 159.59,55.95 161.08,55.95 162.19,57.07 165.2,57.07 165.85,56.42 168.84,56.42 170.46,58.04 170.58,58.04 v1(171.16,58.62)
  IN3 w0.089: v1(171.16,58.62) 170.47,59.3 170.47,60.75 167.78,63.44 167.52,63.44 165.8,65.16 163.48,65.16 162.34,66.3 161.9,66.3 161.12,67.09 161.12,68.41 160.58,68.94 160.35,68.94 159.59,69.71 159.59,69.91 159.29,70.21 158.27,70.21 157.87,70.61 156.68,70.61 156.35,70.94 v2(156.35,72.26)
  BOTTOM w0.079: U400.DT24 144.09,75.53 144.78,75.53 145.22,75.09 145.22,75.06 145.71,74.57 146.02,74.57 146.08,74.63 146.82,74.63 147.47,75.29
  BOTTOM w0.109: 147.47,75.29 147.85,75.29 v2(148.18,74.95) 148.82,75.59 R1402.1 ; Q6600.3 83.86,64.22 v1(83.83,64.2) ; v1(76.98,51.48) 77.23,51.23 101.66,51.23 108.76,44.12 115.41,44.12 118.99,47.71 151.07,47.71 151.92,48.56 v1(151.92,49.25)
PCIE_RXN5_LAN: length 180
  TOP w0.109: v1(8.67,15.26) 8.95,14.98 9.65,14.98 9.85,15.18 CON7602.24
  IN1 w0.079: v1(8.67,15.26) 8.98,14.95 9.58,14.95 10.03,14.5 10.03,14.17 10.9,13.3 11.83,13.3 14.15,10.97 16.62,10.97 17.51,10.08 20.76,10.08 22.06,11.38 23.62,11.38 31.87,19.62 31.87,23.08 32.77,23.99 32.77,27.96 33.48,28.67 39.19,28.67 40.39,29.87 49.05,29.87 56.88,37.69 63.73,37.69 82.76,56.72 82.76,59.79 88.7,65.73 88.7,66.97 91.11,69.38 92.1,69.38 93.84,71.12 98.77,71.12 99.66,72.02 101.04,72.02 101.33,72.31 106.56,72.31 106.92,71.96 108.84,71.96 109.21,71.59 121.35,71.59 122.22,72.45 124.59,72.45 126.8,74.66 129.84,74.66 132.72,77.54 132.72,80.94 132.83,81.04 132.83,81.42 132.01,82.24 132.01,85.97 132.31,86.26 132.31,87.2 132.48,87.37 132.63,87.47 132.77,87.61 132.77,87.72 132.71,87.78 132.45,87.78 v2(132.42,87.75)
  BOTTOM w0.079: v2(132.42,87.75) 132.42,87.9 132.36,87.96 132.12,87.96 131.95,87.8 131.95,86.77 131.7,86.51 131.7,85.24 131.67,85.21 131.67,85.01 131.74,84.84 131.84,84.74 132.04,84.74 132.33,85.03 132.33,85.16 132.23,85.27 132.08,85.27 131.94,85.13 U400.CK4
PCIE_RXN6_SD: length 80.5
  TOP w0.109: C7605.2 175.33,45.27 175.33,45.43 174.78,45.98 174.78,47.74 175.6,48.56 175.6,49.39 175.91,49.7 175.91,50.99 177.6,52.67 177.98,52.67 178.37,53.06 179.1,53.06 179.36,52.81 179.36,52.69 v1(179.67,52.37)
  IN3 w0.089: v2(132.55,84.3) 132.72,84.14 133,84.14 133.16,83.97 133.16,81.87 133.03,81.74 133.03,81.09 132.86,80.69 132.86,79.53 134.02,78.37 139.72,78.37 139.82,78.47 142.95,78.47 143.03,78.39 148.89,78.39 150.24,77.05 153.33,77.05 153.61,77.33 155.16,77.33 155.32,77.48 156.01,77.48 157.52,75.98 157.52,75.6 160.25,72.86 161.66,72.86 162.39,72.13 162.39,71.89 163.99,70.29 164.27,70.29 166.02,68.55 166.77,68.55 169.26,66.06 169.26,65.22 172.61,61.87 172.61,60.19 173.55,59.25 173.93,59.25 174.27,58.91 174.27,57.55 174.83,57 175.23,57 176.64,55.59 176.64,54.93 176.45,54.75 176.45,54.36 177.1,53.72 178.52,53.72 179.47,52.78 179.47,52.58 v1(179.67,52.37)
  BOTTOM w0.079: v2(132.55,84.3) 132.78,84.54 132.78,85.11 U400.CL3
PCIE_RXN6_SD_C: length 2.8
  TOP w0.109: C7605.1 175.53,43.85 175.53,43.63 176.31,42.85 176.31,42.69 176.22,42.59 U7600.8
PCIE_RXN7_WLAN: length 68.9
  IN3 w0.089: v1(137.13,91.57) 136.96,91.4 136.96,90.72 137.25,90.43 148.56,90.43 150.2,92.08 154.04,92.08 156.56,89.56 156.56,87.87 161.85,82.59 163.76,82.59 165.53,80.82 166.41,80.82 169.39,77.84 169.39,76.93 172.66,73.66 174.81,73.66 174.9,73.74 174.9,73.83 v1(174.67,74.05)
  BOTTOM w0.079: U400.CK2 132.37,86.14 132.37,87.04 132.5,87.23 132.71,87.32 132.91,87.53 132.91,88.35 134.19,89.63 134.24,89.63 134.25,89.64
  BOTTOM w0.109: v1(174.67,74.05) 174.86,74.23 174.86,74.51 175.11,74.77 177.41,74.77 178.41,73.77 182.35,73.77 182.95,73.17 182.95,72.67 183.09,72.53 CON4100.43 ; 134.25,89.64 135.29,90.68 136.52,90.68 136.93,91.08 136.93,91.37 v1(137.13,91.57)
PCIE_RXN8_WWAN: length 148
  IN3 w0.089: v2(132.82,86.98) 133,86.8 133,86.17 133.26,85.91 135.46,85.91 135.73,85.64 136.37,85.64 136.78,85.23 137.68,85.23 138.56,84.34 139.24,84.34 139.55,84.65 140.53,84.65 140.91,84.28 141.41,84.28 141.63,84.5 142.68,84.5 143.33,83.85 144.51,83.85 145.77,82.58 148.43,82.58 149.67,81.34 152.03,81.34 152.47,80.9 156.61,80.9 156.91,81.19 157.5,81.19 160.1,78.59 161.72,78.59 162.79,77.51 163.13,77.51 164.24,76.4 164.26,76.4 166.09,74.56 166.09,74.11 167.55,72.65 167.55,71.75 169.44,69.86 170.68,69.86 171.74,68.8 171.74,66.41 172.74,65.41 172.74,64.5 173.22,64.02 173.76,64.02 175.12,62.66 175.12,62.21 176.06,61.27 176.59,61.27 177.07,61.75 181.84,61.75 182.91,60.68 182.91,55.65 186.35,52.21 186.35,47.86 186.91,47.3 186.91,42.12 188.49,40.54 188.49,38.03 188.56,37.96 188.56,34.87 189.68,33.75 189.68,31.97 192.21,29.44 192.81,29.44 194.29,27.97 198.22,27.97 199.26,26.93 200.12,26.93 200.51,26.54 200.51,26.04 201.25,25.3 201.53,25.3 203.08,23.74 203.08,23.45 206.11,20.43 206.11,19.92 207.58,18.45 207.58,17.1 208.28,16.4 208.28,13.14 207.22,12.08 203.06,12.08 201.85,10.87 198.03,10.87 197,9.84 192.59,9.84 192.47,9.97 192.47,10.23 192.52,10.29 v1(192.82,10.29)
  BOTTOM w0.079: U400.CN1 133.07,86.19 132.92,86.05 132.69,86.05 132.62,86.12 132.62,86.31 133.03,86.72 133.03,86.94 132.99,86.98 v2(132.82,86.98)
  BOTTOM w0.109: CON4202.41 192.41,9.89 v1(192.82,10.29)
PCIE_RXN9_SSD: length 185.3
  IN1 w0.079: v2(131.44,88.13) 131.44,88.1 131.67,87.87 131.76,87.87 131.99,87.64 131.99,86.59 130.38,84.99 130.38,82.5 131,81.88 131,79.22 130.23,78.46 130.23,76.49 129.41,75.66 124.84,75.66 122.01,72.84 109.71,72.84 109.35,72.48 107.12,72.48 106.55,73.05 100.96,73.05 100.72,72.81 99.36,72.81 98.57,72.02 93.83,72.02 91.59,69.77 90.91,69.77 88.51,67.36 88.27,67.36 87.65,66.75 87.65,66.09 85.82,64.26 85.82,63.52 82.37,60.06 82.37,57.71 72.73,48.08 72.73,47.63 63.19,38.09 56.73,38.09 48.9,30.26 40.01,30.26 38.8,29.05 33.32,29.05 32.39,28.12 32.39,24.21 31.48,23.3 31.48,19.8 23.49,11.81 21.84,11.81 20.91,10.88 17.31,10.88 16.83,11.36 14.67,11.36 11.92,14.11 11.82,14.11 v1(11.55,13.84)
  BOTTOM w0.079: U400.CG4 130.71,85.18 130.71,85.45 130.84,85.57 130.84,87.05 130.92,87.13 130.92,87.76 131.08,87.92 131.23,87.92 v2(131.44,88.13)
  BOTTOM w0.109: v1(11.55,13.84) 11.82,14.11 11.98,14.11 12.11,13.98 12.11,11.41 10.41,9.71 10.41,6.95 11.25,6.11 11.25,4.22 12.09,3.39 12.5,3.39 12.51,3.38 12.51,3.38 12.65,3.25 CON4300.5
PCIE_RXN10_SSD: length 171.2
  IN1 w0.079: v2(130.56,87.6) 130.73,87.78 130.86,87.78 130.92,87.72 130.92,87.34 130.77,87.19 130.77,86.53 129.37,85.13 129.37,84.58 129.26,84.47 129.26,82.38 129.66,81.97 129.88,81.97 130.28,81.58 130.28,79.62 129.45,78.79 129.45,76.95 128.93,76.43 124.47,76.43 121.65,73.61 108.83,73.61 108.74,73.71 107.04,73.71 106.59,74.15 100.83,74.15 100.38,73.7 98.5,73.7 98.28,73.48 97.69,73.48 97.04,72.83 93.55,72.83 91.22,70.5 90.62,70.5 88.41,68.29 88.17,68.29 85,65.12 85,63.83 80.88,59.72 80.88,58.6 79.16,56.87 79.16,55.65 71.28,47.78 71.28,47.28 62.81,38.81 56.43,38.81 48.66,31.04 39.34,31.04 38.24,29.94 36.8,29.94 36.43,30.31 33.56,30.31 31.67,28.42 31.67,24.53 30.74,23.61 30.74,20.19 23.24,12.69 22.72,12.69 22.6,12.8 22.6,13.03 22.76,13.18 22.96,13.18 v1(23.01,13.24)
  BOTTOM w0.079: v2(130.56,87.6) 130.56,87.73 130.47,87.81 130.31,87.81 130.23,87.73 130.23,87.15 130.35,87.03 130.35,86.08 130.44,85.99 130.62,85.99 130.68,86.06 130.68,86.28 U400.CG1
  BOTTOM w0.109: v1(23.01,13.24) 22.84,13.24 22.72,13.12 22.72,11.79 20.74,9.81 17.89,9.81 17.78,9.7 17.78,9.03 15.78,7.03 14.93,7.03 14.15,6.25 CON4300.17
PCIE_RXN11_SSD: length 179.6
  IN1 w0.079: v2(129.43,88.17) 129.6,88 129.85,88 130.02,87.83 130.02,86.51 128.08,84.56 126.93,84.56 126.69,84.32 124.24,84.32 123.96,84.04 123.96,82.29 123.02,81.35 123.02,81.11 123.04,81.04 123.04,80.31 120.33,77.6 110.99,77.6 109.44,79.14 108.87,79.14 108.34,79.67 99.73,79.67 99.39,80 96.23,80 95.41,79.18 93.86,79.18 93.6,79.44 92.83,79.44 91.18,77.8 90.28,77.8 89.45,76.97 88.74,76.97 87.02,75.25 87.02,73.81 83.79,70.58 83.79,69.59 79.93,65.73 79.93,65.34 76.65,62.06 75.34,62.06 74.95,61.67 74.95,57.76 59.22,42.02 55.21,42.02 48.17,34.98 33.48,34.98 32.77,35.7 31.44,35.7 30.81,36.34 29.56,36.34 27.84,34.62 27.84,31.29 23.9,27.35 23.9,25.98 21.22,23.3 21.22,19.8 19.91,18.49 18.62,18.49 17.77,17.64 17.77,17.3 17.08,16.6 17.08,13.07 17.93,12.22 18.46,12.22 19.2,12.96 20.08,12.96 v1(20.41,13.29)
  BOTTOM w0.079: v2(129.43,88.17) 129.62,87.98 129.77,87.98 129.91,87.84 129.91,86.98 130.03,86.86 U400.CF3
  BOTTOM w0.109: CON4300.29 14.23,9.25 14.36,9.39 14.85,9.39 15.57,10.11 15.57,10.95 16.22,11.6 20.49,11.6 21.12,12.23 21.12,12.68 20.83,12.98 20.71,12.98 v1(20.41,13.29)
PCIE_RXN12_SSD: length 175
  IN1 w0.079: v2(128.53,88.35) 128.34,88.16 128.12,88.16 127.9,87.93 127.9,86.92 128.11,86.7 128.11,85.7 127.8,85.39 125.83,85.39 125.49,85.05 123.95,85.05 123.21,84.31 123.21,83.92 122.88,83.6 122.88,82.28 121.98,81.38 121.98,80.4 120.28,78.7 110.91,78.7 109.73,79.87 109.16,79.87 108.39,80.64 108.39,82.35 108.01,82.73 106.68,82.73 106.58,82.83 106.58,84.75 106.26,85.07 104.97,85.07 103.96,84.65 103.64,84.33 103.64,83.72 103.49,83.57 102.46,83.57 100.55,81.66 96.71,81.66 95,79.95 94.18,79.95 93.98,80.16 92.44,80.16 90.91,78.63 90.07,78.63 89.21,77.76 88.5,77.76 86.2,75.46 86.2,74.02 82.99,70.81 82.99,70.04 78.74,65.8 78.55,65.8 75.86,63.11 75.01,63.11 73.34,61.43 73.34,57.18 59.71,43.56 58.49,43.56 57.68,42.74 54.59,42.74 52.49,40.65 52.03,40.65 47.12,35.74 38.07,35.74 35.82,37.99 31.84,37.99 31.64,37.79 29.94,37.79 26.46,34.31 26.46,32.77 21.95,28.26 21.95,27.76 19.72,25.54 19.72,21.61 20.02,21.31 20.02,20.03 20.11,19.94 v1(20.11,19.51)
  BOTTOM w0.079: v2(128.53,88.35) 128.71,88.16 128.92,88.16 129.05,88.03 129.05,87.45 129.51,86.99 129.51,86.74 129.72,86.54 129.72,86.15 129.64,86.08 129.51,86.08 129.47,86.12 U400.CE1
  BOTTOM w0.109: CON4300.43 14.14,12.75 14.27,12.62 14.4,12.62 14.62,12.84 14.94,12.84 16.07,13.96 16.51,13.96 17.19,14.64 19.42,14.64 20,15.23 20,18.25 20.65,18.89 20.65,19.34 20.48,19.51 v1(20.11,19.51)
PCIE_RXP5_LAN: length 180
  TOP w0.109: v1(8.67,14.48) 8.95,14.76 9.7,14.76 9.78,14.68 CON7602.25
  IN1 w0.079: v1(8.67,14.48) 8.98,14.79 9.51,14.79 9.86,14.43 9.86,14.1 10.84,13.13 11.76,13.13 14.08,10.8 16.55,10.8 17.44,9.91 20.83,9.91 22.13,11.21 23.69,11.21 32.03,19.55 32.03,23.01 32.94,23.92 32.94,27.89 33.55,28.5 39.26,28.5 40.46,29.7 49.12,29.7 56.95,37.52 63.8,37.52 82.93,56.65 82.93,59.72 88.87,65.66 88.87,66.9 91.18,69.21 92.17,69.21 93.91,70.96 98.84,70.96 99.73,71.85 101.11,71.85 101.4,72.14 106.49,72.14 106.85,71.79 108.77,71.79 109.14,71.42 121.42,71.42 122.28,72.29 124.66,72.29 126.87,74.49 129.91,74.49 132.89,77.47 132.89,80.87 132.99,80.98 132.99,81.49 132.18,82.3 132.18,85.9 132.47,86.2 132.47,87.13 132.58,87.24 132.74,87.34 132.82,87.42 132.82,87.42 132.94,87.54 132.94,87.79 132.42,88.31 v2(132.42,88.31)
  BOTTOM w0.079: v2(132.42,88.31) 132.42,88.28 132.26,88.12 132.05,88.12 131.8,87.87 131.8,86.83 131.54,86.58 131.54,85.3 131.51,85.27 131.51,84.97 131.6,84.76 U400.CK5
PCIE_RXP6_SD: length 80.5
  TOP w0.109: C7604.2 175.9,44.85 175.68,44.85 175.56,44.97 175.56,45.52 175.01,46.07 175.01,47.65 175.82,48.46 175.82,49.29 176.14,49.61 176.14,50.9 177.69,52.45 178.08,52.45 178.46,52.83 179.01,52.83 179.13,52.71 179.13,52.6 v1(178.91,52.37)
  IN3 w0.089: v2(132.54,83.76) 132.54,83.88 132.61,83.94 132.92,83.94 132.97,83.89 132.97,81.95 132.84,81.82 132.84,81.13 132.67,80.72 132.67,79.45 133.94,78.18 139.8,78.18 139.9,78.28 142.87,78.28 142.95,78.2 148.81,78.2 150.16,76.86 153.41,76.86 153.69,77.14 155.24,77.14 155.4,77.29 155.93,77.29 157.33,75.9 157.33,75.52 160.17,72.67 161.58,72.67 162.2,72.05 162.2,71.81 163.91,70.1 164.19,70.1 165.94,68.36 166.69,68.36 169.07,65.98 169.07,65.14 172.42,61.79 172.42,60.11 173.47,59.06 173.85,59.06 174.08,58.83 174.08,57.47 174.75,56.8 175.15,56.8 176.45,55.51 176.45,55.01 176.26,54.82 176.26,54.28 177.02,53.53 178.45,53.53 179.28,52.7 179.28,52.43 179.22,52.37 v1(178.91,52.37)
  BOTTOM w0.079: U400.CL4 132.31,84.74 132.22,84.65 132.22,83.98 132.42,83.78 132.52,83.78 132.54,83.76 v2(132.54,83.76)
PCIE_RXP6_SD_C: length 2.7
  TOP w0.109: C7604.1 175.76,43.93 175.76,43.72 176.53,42.94 176.53,42.7 176.62,42.62 U7600.7
PCIE_RXP7_WLAN: length 68.9
  IN3 w0.089: v1(136.42,91.57) 136.77,91.23 136.77,90.64 137.17,90.24 148.64,90.24 150.28,91.89 153.96,91.89 156.37,89.48 156.37,87.79 161.77,82.4 163.69,82.4 165.45,80.63 166.33,80.63 169.2,77.76 169.2,76.85 172.58,73.47 174.89,73.47 175.09,73.66 175.09,73.83 v1(175.31,74.05)
  BOTTOM w0.079: U400.CK1 131.94,86.11 131.99,86.06 132.07,86.06 132.21,86.21 132.21,87.09 132.39,87.36 132.62,87.46 132.75,87.59 132.75,88.41 134.08,89.74 134.08,89.79 134.09,89.8
  BOTTOM w0.109: CON4100.41 182.59,72.53 182.72,72.67 182.72,73.08 182.26,73.54 178.32,73.54 177.32,74.55 175.21,74.55 175.08,74.42 175.08,74.28 v1(175.31,74.05) ; v1(136.42,91.57) 136.64,91.57 136.7,91.52 136.7,91.18 136.43,90.9 135.2,90.9 134.52,90.23 134.52,90.23 134.09,89.8
PCIE_RXP8_WWAN: length 148
  IN3 w0.089: v2(133.37,86.98) 133.19,86.8 133.19,86.25 133.34,86.1 135.54,86.1 135.81,85.83 136.45,85.83 136.86,85.42 137.76,85.42 138.64,84.53 139.16,84.53 139.47,84.84 140.61,84.84 140.99,84.47 141.33,84.47 141.55,84.69 142.76,84.69 143.41,84.04 144.58,84.04 145.85,82.77 148.51,82.77 149.75,81.53 152.11,81.53 152.55,81.09 156.54,81.09 156.83,81.38 157.58,81.38 160.18,78.78 161.8,78.78 162.87,77.7 163.21,77.7 164.32,76.59 164.34,76.59 166.29,74.64 166.29,74.18 167.74,72.73 167.74,71.83 169.52,70.05 170.76,70.05 171.93,68.88 171.93,66.49 172.93,65.49 172.93,64.58 173.3,64.21 173.84,64.21 175.31,62.74 175.31,62.29 176.14,61.46 176.51,61.46 176.99,61.94 181.92,61.94 183.1,60.76 183.1,55.73 186.54,52.29 186.54,47.94 187.1,47.38 187.1,42.2 188.68,40.62 188.68,38.11 188.75,38.04 188.75,34.95 189.87,33.83 189.87,32.05 192.29,29.63 192.89,29.63 194.37,28.16 198.3,28.16 199.34,27.12 200.2,27.12 200.7,26.62 200.7,26.12 201.32,25.49 201.61,25.49 203.27,23.82 203.27,23.53 206.3,20.5 206.3,20 207.77,18.52 207.77,17.18 208.47,16.48 208.47,13.06 207.3,11.89 203.14,11.89 201.93,10.68 198.1,10.68 197.08,9.65 192.51,9.65 192.28,9.89 192.28,10.08 v1(192.08,10.28)
  BOTTOM w0.079: v2(133.37,86.98) 133.37,86.97 133.19,86.78 133.19,86.64 133.3,86.53 133.3,86.2 133.07,85.97 U400.CN2
  BOTTOM w0.109: v1(192.08,10.28) 192.23,10.13 192.23,10.03 191.92,9.72 CON4202.43
PCIE_RXP9_SSD: length 185.3
  IN1 w0.079: v1(11.55,14.61) 11.55,14.54 11.81,14.28 11.99,14.28 14.74,11.53 16.9,11.53 17.38,11.05 20.84,11.05 21.77,11.98 23.42,11.98 31.32,19.87 31.32,23.37 32.22,24.28 32.22,28.19 33.25,29.22 38.73,29.22 39.94,30.43 48.83,30.43 56.66,38.26 63.12,38.26 72.57,47.7 72.57,48.15 82.2,57.78 82.2,60.13 85.66,63.59 85.66,64.33 87.49,66.16 87.49,66.82 88.2,67.53 88.44,67.53 90.84,69.94 91.52,69.94 93.76,72.19 98.5,72.19 99.29,72.97 100.65,72.97 100.89,73.22 106.62,73.22 107.19,72.64 109.28,72.64 109.64,73.01 121.94,73.01 124.77,75.83 129.34,75.83 130.07,76.56 130.07,78.53 130.83,79.29 130.83,81.81 130.22,82.43 130.22,85.06 131.82,86.66 131.82,87.57 131.69,87.7 131.57,87.7 v2(131.44,87.57)
  BOTTOM w0.079: U400.CG5 130.59,84.68 130.83,84.92 130.87,85.02 130.87,85.38 131,85.51 131,86.99 131.08,87.07 131.08,87.7 131.15,87.77 131.38,87.77 131.44,87.71 v2(131.44,87.57)
  BOTTOM w0.109: v1(11.55,14.61) 11.82,14.34 12.07,14.34 12.33,14.07 12.33,11.32 10.63,9.62 10.63,7.04 11.48,6.2 11.48,4.32 12.18,3.61 12.5,3.61 12.64,3.75 CON4300.7
PCIE_RXP10_SSD: length 171.2
  IN1 w0.079: v2(130.56,88.16) 130.65,88.06 130.93,87.94 131.09,87.79 131.09,87.28 130.93,87.12 130.93,86.46 129.54,85.06 129.54,84.51 129.43,84.4 129.43,82.45 129.73,82.14 129.95,82.14 130.44,81.65 130.44,79.55 129.62,78.72 129.62,76.88 129,76.26 124.54,76.26 121.72,73.45 108.76,73.45 108.67,73.54 106.97,73.54 106.52,73.99 100.9,73.99 100.45,73.53 98.57,73.53 98.35,73.31 97.76,73.31 97.11,72.66 93.62,72.66 91.29,70.33 90.68,70.33 88.48,68.12 88.24,68.12 85.17,65.05 85.17,63.76 81.05,59.65 81.05,58.53 79.32,56.8 79.32,55.58 71.45,47.71 71.45,47.21 62.88,38.64 56.5,38.64 48.73,30.87 39.41,30.87 38.31,29.77 36.73,29.77 36.36,30.14 33.63,30.14 31.84,28.35 31.84,24.46 30.91,23.54 30.91,20.12 23.31,12.52 22.65,12.52 22.44,12.73 22.44,13.05 v1(22.25,13.24)
  BOTTOM w0.079: U400.CG2 130.48,85.83 130.37,85.83 130.19,86.02 130.19,86.97 130.07,87.09 130.07,87.79 130.25,87.97 130.4,87.97 130.56,88.13 v2(130.56,88.16)
  BOTTOM w0.109: CON4300.19 14.33,6.75 14.84,7.26 15.69,7.26 17.55,9.13 17.55,9.79 17.79,10.03 20.65,10.03 22.5,11.88 22.5,12.99 v1(22.25,13.24)
PCIE_RXP11_SSD: length 179.5
  IN1 w0.079: v1(20.41,12.52) 20.14,12.79 19.27,12.79 18.52,12.05 17.86,12.05 16.91,13 16.91,16.67 17.6,17.37 17.6,17.71 18.55,18.66 19.84,18.66 21.05,19.87 21.05,23.37 23.73,26.05 23.73,27.42 27.67,31.36 27.67,34.69 29.49,36.51 30.88,36.51 31.51,35.87 32.84,35.87 33.55,35.15 48.1,35.15 55.14,42.19 59.15,42.19 74.79,57.83 74.79,61.74 75.27,62.23 76.58,62.23 79.76,65.41 79.76,65.8 83.62,69.66 83.62,70.65 86.85,73.88 86.85,75.32 88.67,77.14 89.38,77.14 90.21,77.97 91.11,77.97 92.76,79.61 93.67,79.61 93.93,79.35 95.34,79.35 96.16,80.17 99.46,80.17 99.8,79.83 108.41,79.83 108.94,79.31 109.51,79.31 111.06,77.77 120.26,77.77 122.88,80.38 122.88,81.01 122.85,81.07 122.85,81.42 123.8,82.36 123.8,84.11 124.17,84.49 126.62,84.49 126.86,84.73 128.01,84.73 129.86,86.58 129.86,87.76 129.78,87.83 129.54,87.83 129.43,87.73 v2(129.43,87.61)
  BOTTOM w0.079: U400.CF4 130.03,84.97 129.76,85.25 129.76,85.5 129.87,85.62 129.87,86.79 129.76,86.91 129.76,87.78 129.71,87.82 129.51,87.82 129.43,87.75 v2(129.43,87.61)
  BOTTOM w0.109: v1(20.41,12.52) 20.63,12.75 20.73,12.75 20.9,12.59 20.9,12.32 20.4,11.82 16.13,11.82 15.35,11.04 15.35,10.2 14.75,9.61 14.36,9.61 14.22,9.75 CON4300.31
PCIE_RXP12_SSD: length 175
  IN1 w0.079: v1(20.65,20.05) 20.25,20.05 20.19,20.1 20.19,21.38 19.89,21.68 19.89,25.47 22.12,27.69 22.12,28.19 26.62,32.7 26.62,34.24 30.01,37.62 31.71,37.62 31.91,37.82 35.75,37.82 38,35.57 47.18,35.57 52.09,40.48 52.56,40.48 54.66,42.58 57.75,42.58 58.56,43.39 59.78,43.39 73.51,57.11 73.51,61.36 75.08,62.94 75.93,62.94 78.62,65.63 78.81,65.63 83.16,69.97 83.16,70.74 86.37,73.95 86.37,75.39 88.57,77.59 89.28,77.59 90.14,78.46 90.98,78.46 92.51,79.99 93.91,79.99 94.11,79.79 95.07,79.79 96.78,81.49 100.62,81.49 102.53,83.4 103.56,83.4 103.81,83.65 103.81,84.26 104.06,84.51 105,84.9 106.19,84.9 106.41,84.68 106.41,82.76 106.61,82.56 107.95,82.56 108.22,82.28 108.22,80.57 109.09,79.7 109.66,79.7 110.84,78.53 120.35,78.53 122.14,80.33 122.14,81.31 123.05,82.22 123.05,83.53 123.37,83.85 123.37,84.24 124.02,84.88 125.56,84.88 125.9,85.22 127.87,85.22 128.28,85.63 128.28,86.77 128.07,86.98 128.07,87.86 128.19,87.99 128.36,87.99 128.53,87.82 v2(128.53,87.79)
  BOTTOM w0.079: v2(128.53,87.79) 128.53,87.94 128.6,88.01 128.85,88.01 128.9,87.96 128.9,87.39 129.36,86.93 129.36,86.73 129.21,86.59 129.21,85.98 U400.CE2
  BOTTOM w0.109: CON4300.41 14.1,12.25 14.25,12.4 14.49,12.4 14.71,12.61 15.04,12.61 16.16,13.74 16.6,13.74 17.28,14.42 19.51,14.42 20.23,15.14 20.23,18.15 20.87,18.8 20.87,19.43 20.65,19.65 v1(20.65,20.05)
PCIE_TXN5_LAN_C: length 167.5
  TOP w0.109: v1(9.2,16.81) 9.39,16.62 9.77,16.62 9.82,16.68 CON7602.21
  IN1 w0.079: v2(127.91,83.94) 128.1,83.76 128.29,83.76 128.51,83.53 128.51,82.26 129.05,81.73 129.05,79.89 128.15,79 128.15,78.09 127.79,77.73 126.34,77.73 125.62,77 124.21,77 121.21,74.01 109.04,74.01 108.58,74.47 107.01,74.47 106.6,74.88 100.05,74.88 99.6,74.42 98.46,74.42 98.02,73.98 97.47,73.98 97.35,73.86 94.02,73.86 91.05,70.89 90.35,70.89 88.39,68.94 87.56,68.94 87.34,68.71 87.34,68.03 84.53,65.22 84.53,64.08 80.27,59.83 80.27,58.59 78.29,56.61 78.29,55.52 70.83,48.05 70.83,47.59 70.83,47.45 62.57,39.19 56.28,39.19 48.55,31.47 37.54,31.47 36.76,30.69 33.33,30.69 31.29,28.65 31.29,25.51 30.36,24.59 30.36,20.6 23.37,13.61 21.99,13.61 21.64,13.26 21.64,12.47 20.62,11.45 17.63,11.45 16.33,12.75 16.33,13.74 15.59,14.48 13.59,14.48 13.09,14.98 10.56,14.98 10.1,15.44 9.15,15.44 9.02,15.5 8.83,15.62 8.82,15.64 8.62,15.84 8.62,16.42 8.77,16.57 8.97,16.57 v1(9.2,16.81)
  BOTTOM w0.109: U400.CB7 128.43,83.72 128.14,83.72 v2(127.91,83.94)
PCIE_TXN6_SD: length 86.9
  TOP w0.109: v1(178.65,50.7) 178.92,50.43 178.92,50.32 178.79,50.19 178.11,50.19 177.69,49.77 177.69,47.57 177.81,47.45 177.81,42.06 U7600.4 ; v2(135.33,80.87) 135.89,81.43 135.89,82.38 135.53,82.74 135.53,88.3 135.68,88.45 135.68,90.12 135.18,90.62 134.01,90.62 133.68,90.3 133.68,90 C1305.2
  IN3 w0.089: v2(135.33,80.87) 135.62,80.87 135.91,80.58 135.91,79.96 136.78,79.09 137.77,79.09 137.86,79.18 139.41,79.18 139.49,79.09 142.67,79.09 143.66,80.08 146.14,80.08 146.54,79.68 146.54,79.6 147.3,78.84 149.17,78.84 150.49,77.52 153.08,77.52 153.36,77.8 154.99,77.8 155.12,77.92 157.77,77.92 158.95,76.74 158.95,76.23 159.43,75.75 161.5,75.75 161.75,75.51 161.75,74.63 162.42,73.95 162.42,73.2 164.07,71.55 164.07,71.11 166.23,68.94 166.93,68.94 170.08,65.8 170.08,65.09 173.97,61.2 174.26,61.2 175.49,59.97 175.49,57.88 178.26,55.12 178.26,54.76 180.16,52.86 180.16,51.89 179.62,51.35 179.07,51.35 178.85,51.13 178.85,50.9 v1(178.65,50.7)
PCIE_TXN6_SD_C: length 8.6
  TOP w0.109: v2(130.75,83.94) 130.87,83.82 130.94,83.82 131.07,83.94 131.07,84.2 132.79,85.93 133.7,85.93 134.12,86.34 134.12,87.7 133.88,87.93 133.88,88.85 133.71,89.02 C1305.1
  BOTTOM w0.109: v2(130.75,83.94) 130.6,84.09 130.4,84.09 130.28,83.97 U400.CG7
PCIE_TXN7_WLAN: length 14.6
  BOTTOM w0.109: CON4100.37 181.59,72.55 181.4,72.74 181.26,72.74 180.92,73.09 180.26,73.09 179.72,72.55 178.9,72.55 178.48,72.97 177.82,72.97 177.16,73.63 174.36,73.63 174.04,73.95 174.04,74.34 173.02,75.36 169.83,75.36 169.77,75.42 C1303.1
PCIE_TXN7_WLAN_C: length 62.6
  TOP w0.102: v2(129.82,83.41) 129.82,83.18 129.76,83.12 129.65,83.08 129.56,83.08 129.46,83.18 129.46,84.5 129.61,84.66 129.61,85 129.62,85.01 129.62,85.04
  TOP w0.109: v1(130.49,91.06) 130.25,91.06 130.14,90.95 130.14,86.74 129.62,86.22 129.62,85.04
  IN3 w0.089: v1(130.49,91.06) 130.3,91.06 130.2,90.96 130.2,90.7 130.29,90.61 130.67,90.61 130.93,90.87 130.93,91.92 131.4,92.39 137.2,92.39 137.63,91.96 144.14,91.96 144.32,91.78 145.47,91.78 145.73,91.53 146.66,91.53 147.16,91.74 148.17,92.75 154.43,92.75 157.26,89.92 157.26,89.1 161.6,84.77 163.08,84.77 163.54,84.31 163.54,83.8 165.82,81.52 166.78,81.52 169.9,78.39 170.41,78.39 170.71,78.09 170.71,77.75 170.46,77.49 170.36,77.49 170.15,77.28 v2(170.15,77.25)
  BOTTOM w0.109: v2(129.82,83.41) 129.45,83.04 U400.CD8 ; v2(170.15,77.25) 170.04,77.25 169.93,77.14 169.93,76.73 169.57,76.38 169.57,76.27 C1303.2
PCIE_TXN8_WWAN: length 157.1
  TOP w0.109: v1(131.67,91.05) 131.87,90.85 131.87,90.61 C1301.2
  IN3 w0.089: v1(131.67,91.05) 131.89,91.26 131.89,91.47 132.15,91.73 133.21,91.73 133.64,91.3 133.64,88.84 135.91,86.58 136.65,86.58 137.19,86.04 138.02,86.04 138.34,85.71 144.07,85.71 145.57,84.21 147.31,84.21 147.98,83.54 148.95,83.54 149.66,82.84 152.81,82.84 153.23,82.42 156.34,82.42 156.74,82.01 157.77,82.01 160.43,79.36 162.04,79.36 162.69,78.71 163.28,78.71 164.08,77.91 164.46,77.91 164.67,77.7 164.81,77.35 164.81,77.05 168.37,73.48 168.37,72.03 168.98,71.42 169.2,71.42 169.95,72.17 170.61,72.17 172.66,70.12 172.66,66.72 174.44,64.94 174.44,64.83 176.25,63.03 176.4,63.03 176.91,62.53 182.16,62.53 183.69,61 183.69,56.42 184.29,55.81 184.84,55.81 185.6,55.05 185.6,54.11 187.18,52.53 187.18,48.34 187.81,47.71 187.81,44.54 188.44,43.9 188.44,41.81 189.75,40.5 189.75,38.32 189.46,38.03 189.46,35.12 190.53,34.05 190.53,32.22 192.53,30.22 193.14,30.22 194.28,29.07 197.6,29.07 197.94,28.93 199.23,28.93 201.27,26.9 201.39,26.9 202.27,26.02 202.27,25.66 203.88,24.05 203.88,23.84 206.88,20.84 206.88,20.24 208.36,18.77 208.36,17.42 209.06,16.72 209.06,12.82 208.57,12.34 208.57,11.4 207.18,10.01 204.65,10.01 202.92,8.28 201.28,8.28 201.1,8.1 191.73,8.1 191.45,7.82 191.45,7.53 v1(191.67,7.3)
  BOTTOM w0.109: v1(191.67,7.3) 191.38,7.6 191.38,7.77 191.15,8 190.86,8 190.78,8.09 190.78,8.18 190.92,8.31 CON4202.47
PCIE_TXN8_WWAN_C: length 12.1
  TOP w0.102: v2(131.67,83.91) 131.97,83.61 132.03,83.48 132.03,82.56 132,82.5 131.74,82.23 131.21,82.01 130.52,82.01 130.19,82.35 130.19,84.24 130.45,84.5 130.45,85 130.44,85.01 130.44,85.04
  TOP w0.109: C1301.1 131.66,89.05 131.82,88.89 131.82,86.8 130.44,85.42 130.44,85.04
  BOTTOM w0.109: U400.CJ7 131.42,83.91 v2(131.67,83.91)
PCIE_TXN9_SSD: length 154.1
  IN1 w0.079: v1(22.31,15) 22.6,14.7 23.09,14.7 29.64,21.26 29.64,24.89 30.57,25.82 30.57,28.94 33.03,31.41 34.22,31.41 35.01,32.2 48.27,32.2 55.98,39.91 62.14,39.91 68.25,46.02 68.25,46.84 77.27,55.86 77.27,56.69 79.32,58.74 79.32,60.11 81.32,62.1 81.32,62.74 83.75,65.18 83.75,65.5 85.93,67.67 85.93,68.99 86.26,69.33 86.82,69.33 87.15,69.66 88.09,69.66 90.06,71.63 90.69,71.63 94.17,75.1 95.76,75.1 96.8,76.14 99.11,76.14 99.29,75.97 106.61,75.97 107,75.58 108.57,75.58 109.4,74.74 120.83,74.74 123.97,77.88 125.26,77.88 127.86,80.48 127.86,81.62 127.41,82.07 127.41,82.92 v2(127.07,83.26)
  BOTTOM w0.109: U400.BY8 127.53,83.27 127.42,83.39 127.2,83.39 v2(127.07,83.26) ; v1(22.31,15) 22.51,14.79 23.25,14.79 23.67,14.38 23.67,12.76 23.44,12.53 23.44,11.47 21.86,9.9 21.86,8.87 21.52,8.53 21.15,8.53 21.08,8.45 C4304.2

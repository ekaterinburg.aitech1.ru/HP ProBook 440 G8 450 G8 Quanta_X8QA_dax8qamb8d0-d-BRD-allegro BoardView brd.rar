# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INB1_SCL: length 645.5
  TOP w0.102: v1(143.77,7.49) 143.74,7.46 143.74,6.24 143.88,6.1 144.11,6.1 U2007.A1
  TOP w0.109: U1906.A1 161.25,6.68 162.59,6.68 v1(162.63,6.63) ; U2005.B3 176.15,53.87 175.91,54.11 175.63,54.11 175.51,54 173.34,54 172.97,53.63 172.97,52.23 173.14,52.07 173.78,52.07 v1(173.97,52.26) 173.97,52.91 174.37,53.31 175.43,53.31 175.73,53.01 U2005.A1 ; v1(25.01,60.09) 25.58,60.09 26.46,59.21 26.46,54.73 26.58,54.61 v1(26.95,54.61) 27.38,54.61 27.83,54.16 U1908.A1 ; v1(202.18,77.74) 202.13,77.69 U2004.A1 ; U1904.A1 168.73,98.48 168.73,99.97 168.12,100.58 168.12,101.14 v1(168.6,101.62) 169.21,101.01 170.2,101.01 171.65,99.57 v1(172.03,99.57) ; v1(23.7,66.88) U1909.A1 ; v1(23.51,6.57) 23.45,6.57 23.04,6.98 22.53,6.98 22.17,7.34 22.17,7.77 21.69,8.25 21.69,9.88 19.82,11.75 U2002.A1 ; v1(29.97,56.11) 29.01,56.11 28.45,55.55 U1908.B3 ; U1902.A1 44.51,14.35 44.87,14.35 v1(45.66,13.56) ; U1900.A1 145.88,10.19 145.88,9.58 145.22,8.93 145.22,7.54 v1(145.22,7.54) 145.22,7.27 145,7.05 U2007.C3 ; U2010.A1 83.57,110.67 83.14,111.1 82.43,111.1 82.03,111.5 82.03,112.23 82.28,112.49 84.4,112.49 v1(84.86,112.03) 84.63,111.8 U2010.C3
  IN1 w0.079: v1(174.14,105.71) 173.75,106.11 172.39,106.11 171.39,105.1 166.22,105.1 165.65,105.66 154.81,105.66 151.86,102.71 v1(151.81,102.71) 151.41,102.71 150.54,103.58 146.3,103.58 145.81,104.07 144.94,104.07 143.68,105.33 129.23,105.33 125.83,108.74 122.27,108.74 121.17,107.64 112.9,107.64 111.88,108.66 107.77,108.66 105.78,110.65 102.47,110.65 101.73,111.39 90.28,111.39 89.04,112.63 86.75,112.63 85.66,111.55 85.34,111.55 v1(84.86,112.03) ; v1(202.18,77.74) 201.79,77.35 201.79,75.42 202.16,75.05 202.16,71.04 201.56,70.44 201.56,69.39 201.95,68.99 201.95,64.39 203.71,62.63 203.71,61.75 204.01,61.44 204.57,61.44 205,61.01 205,59.35 203.43,57.78 203.43,54.18 202.61,53.36 202.61,51.18 v1(202.18,50.75) 202.18,50.14 201.6,49.55 201.6,46.59 201.19,46.18 200.68,46.18 200.41,46.45 195.4,46.45 192.18,43.23 192.18,41.5 192.51,41.17 192.51,39.08 192.68,38.91 192.68,33.88 193.39,33.17 193.39,33.12 193.74,32.77 193.8,32.62 193.8,32.27 194.65,31.43 197.13,31.43 197.21,31.35 197.95,31.35 198.17,31.57 198.62,31.57 199.21,30.97 200.85,30.97 202.82,29.01 203.64,29.01 204.61,28.03 204.91,28.03 206.46,26.48 206.86,26.48 v2(207.07,26.69) ; v1(184.06,49.64) 183.39,50.32 182.16,50.32 181.17,51.31 179.14,51.31 178.31,52.14 177.37,52.14 176.91,51.67 176.12,51.67 175.7,52.09 174.13,52.09 v1(173.97,52.26)
  IN2 w0.089: v1(45.66,13.56) 45.2,14.02 42.44,14.02 41.53,13.1 40.03,13.1 39.16,13.97 39.16,14.42 38.78,14.81 37.77,14.81 34.57,18.01 33.07,18.01 28.75,22.32 28.75,26.9 26.21,29.44 25.02,29.44 24.41,30.05 24.41,31.68 26.79,34.07 26.79,35.08 23.84,38.03 23.84,43.23 23.3,43.77 23.3,48.16 24.66,49.53 24.66,51.25 25.7,52.29 25.7,54.18 26.13,54.61 v1(26.95,54.61) 27.32,54.61 28.82,56.11 v1(29.97,56.11) ; v1(184.06,49.64) 184.06,50.48 182.15,52.39 182.15,53.12 180.93,54.34 180.93,57.11 181.63,57.81 181.63,59.08 181.79,59.23 181.79,59.89 180.93,60.74 180.19,60.74 179.86,61.07 179.86,62.99 178.93,63.92 178.93,64.45 179.5,65.02 180.11,65.02 181.17,66.08 181.17,67.16 181.52,67.51 182.6,67.51 182.83,67.74 182.83,69.07 182.6,69.3 182.6,71.07 181.18,72.49 181.18,76.67 176.55,81.3 176.55,83.89 174.87,85.56 174.87,86.3 172.24,88.94 172.24,93.29 171.45,94.08 171.45,96.8 172.03,97.38 v1(172.03,99.57)
  IN3 w0.089: v1(23.51,6.57) 23.51,6.4 25.25,4.66 31.75,4.66 31.88,4.79 35.17,4.79 35.81,5.43 41.86,5.43 42.48,4.81 47.94,4.81 48.36,5.23 48.36,5.66 48.82,6.12 50.62,6.12 v1(51.01,6.51) 51.59,6.51 52.26,5.84 54.28,5.84 56.21,3.91 58.81,3.91 59.34,3.38 63.07,3.38 63.6,3.91 65.17,3.91 65.4,4.14 66.93,4.14 68.26,2.81 74.22,2.81 75.28,3.87 75.28,7.15 76.74,8.61 97.78,8.61 98.71,7.69 101.28,7.69 101.8,7.17 105.2,5.75 132.46,5.75 132.74,6.03 136.56,6.03 137.33,6.81 140.14,6.81 140.91,6.04 143.4,6.04 143.77,6.4 v1(143.77,7.49) 144.09,7.49 144.43,7.82 144.93,7.82 v1(145.22,7.54) 145.34,7.54 146.84,6.03 160.83,6.03 161.31,6.51 162.51,6.51 v1(162.63,6.63) 162.97,6.3 168.74,6.3 171.3,3.74 179.7,3.74 181.8,5.84 185.12,5.84 186.8,4.16 191.75,4.16 191.76,4.16 191.91,4.16 192.82,5.07 194.37,5.07 195.17,4.26 195.17,3.75 195.55,3.38 197.08,3.38 197.38,3.68 199.06,3.68 200.36,4.98 204.93,4.98 205.32,5.36 205.84,5.36 206.09,5.6 207.09,5.6 207.75,6.26 207.75,7.2 209.36,8.8 210.02,8.8 211.42,10.2 211.42,11.15 211.76,11.49 211.76,13.34 213.77,15.35 213.77,18.9 211.86,20.81 211.86,23.79 208.75,26.9 207.27,26.9 v2(207.07,26.69) ; v1(174.14,105.71) 173.76,106.09 172.18,106.09 171.43,105.34 171.05,105.34 169.37,103.66 168.45,103.66 168.07,103.27 168.07,102.16 v1(168.6,101.62)
  BOTTOM w0.109: v1(151.81,102.71) R1903.2 ; U1805.A1 203.78,27.97 204.14,27.61 204.14,27.02 204.75,26.41 206.78,26.41 v2(207.07,26.69) ; v1(25.01,60.09) 24.82,60.28 24.82,61.66 23.7,62.79 v1(23.7,66.88) ; v1(51.01,6.51) 50.73,6.79 50.73,10.47 50.17,11.03 48.75,11.03 48.18,11.61 48.18,12.99 47.3,13.87 45.96,13.87 v1(45.66,13.56) ; v1(184.06,49.64) 183.87,49.84 183.87,50.07 184.05,50.25 186.15,50.25 186.37,50.47 187.09,50.47 187.63,51 188.44,51 189.41,51.97 190.24,51.97 190.61,51.6 192.57,51.6 192.96,51.99 195.83,51.99 196.7,51.12 200.38,51.12 200.94,50.57 202,50.57 v1(202.18,50.75) ; U2006.A1 175.32,105.52 175.02,105.23 174.68,105.23 174.49,105.31 174.14,105.66 v1(174.14,105.71)
INB1_SDA: length 653.5
  TOP w0.102: U1906.B3 U1906.A2 ; U2007.B3 U2007.A2
  TOP w0.109: v1(202.22,77.09) 202.02,77.29 U2004.A2 ; U2005.A2 175.62,53.54 174.11,53.54 173.91,53.34 173.91,53.29 173.39,52.78 v1(173.39,52.5) ; v1(172.67,99.57) 172.24,99.13 171.65,99.13 170.4,100.39 v1(169.41,100.39) 168.98,99.96 U1904.A2 ; U2010.A2 83.5,111.07 83.25,111.33 82.6,111.33 82.29,111.63 82.29,112 82.55,112.26 83.24,112.26 v1(83.53,111.98) ; U2007.B3 144.6,7.43 v1(144.61,7.44) 144.61,7.52 144.98,7.9 144.98,9.01 145.65,9.68 145.65,10 145.48,10.17 145.48,10.41 145.65,10.59 145.68,10.59 U1900.A2 145.65,10.82 144.95,10.82 144.26,11.51 144.26,11.85 144.51,12.1 146.32,12.1 146.57,11.86 146.57,11.1 U1900.C3 ; v1(22.88,6.55) 22.6,6.55 21.88,7.27 21.88,7.73 21.46,8.15 21.46,9.79 19.9,11.35 U2002.A2 ; U1909.A2 24.09,67.28 v1(23.73,67.64) 23.73,68.38 24.13,68.78 24.38,68.78 24.69,69.09 25.68,69.09 v1(25.98,68.78) 26.05,68.71 U1909.C3 ; U1902.C3 U1902.B3 44.01,13.22 44.36,12.88 44.36,12.36 44.58,12.15 45.06,12.15 45.38,12.46 45.38,13.21 v1(45.02,13.56) 45.02,13.86 44.76,14.12 44.49,14.12 U1902.A2 ; v1(24.31,60.09) 24.77,60.55 25.72,60.55 26.72,59.54 26.72,55.47 v1(26.95,55.24) 27.23,55.24 27.91,54.56 U1908.A2 ; U1906.A2 160.75,6.42 161.06,6.12 v1(161.75,6.12)
  IN1 w0.079: v1(173.51,105.69) 173.25,105.94 172.45,105.94 171.45,104.94 166.12,104.94 165.56,105.51 155.16,105.51 151.97,102.31 151.26,102.31 v1(150.85,102.71) 150.85,103.04 150.49,103.4 146.25,103.4 145.74,103.91 144.88,103.91 143.61,105.18 129.16,105.18 125.78,108.56 122.34,108.56 121.27,107.49 112.84,107.49 111.82,108.5 107.7,108.5 105.71,110.49 102.4,110.49 101.67,111.23 90.16,111.23 88.91,112.48 86.81,112.48 85.69,111.36 84.15,111.36 v1(83.53,111.98) ; v1(202.22,77.09) 202.22,75.35 202.33,75.23 202.33,67.97 202.13,67.76 202.13,64.49 203.89,62.73 203.89,61.82 204.06,61.64 204.7,61.64 205.18,61.16 205.18,59.31 203.6,57.73 203.6,54.13 202.84,53.36 v1(202.84,50.75) 202.84,50.42 201.8,49.38 201.8,46.54 201.29,46.02 200.61,46.02 200.33,46.3 195.47,46.3 192.33,43.16 192.33,41.57 192.67,41.24 192.67,39.14 192.84,38.97 192.84,33.94 193.55,33.23 193.55,33.18 193.87,32.86 193.96,32.65 193.96,32.34 194.71,31.58 197.2,31.58 197.28,31.5 197.88,31.5 198.11,31.72 198.68,31.72 199.27,31.13 200.92,31.13 202.88,29.17 203.7,29.17 204.68,28.19 205.24,28.19 v2(206.55,26.88) ; v1(173.39,52.5) 173.39,52.3 173.81,51.88 174.29,51.88 174.35,51.94 175.64,51.94 176.06,51.52 176.97,51.52 177.43,51.98 178.24,51.98 179.09,51.13 181.13,51.13 182.09,50.16 182.86,50.16 v1(183.44,49.58)
  IN2 w0.089: v1(45.02,13.56) 44.77,13.82 42.57,13.82 41.6,12.85 39.98,12.85 38.96,13.87 38.96,14.35 38.68,14.63 37.69,14.63 34.49,17.83 32.97,17.83 28.52,22.27 28.52,26.82 26.21,29.13 25.04,29.13 24.23,29.94 24.23,31.76 26.62,34.15 26.62,35 23.66,37.95 23.66,43.15 23.12,43.7 23.12,48.27 24.48,49.63 24.48,51.32 25.52,52.36 25.52,54.25 26.52,55.24 v1(26.95,55.24) ; v1(183.44,49.58) 183.76,49.26 184.22,49.26 184.45,49.48 184.45,50.35 182.33,52.47 182.33,53.2 181.11,54.42 181.11,57.04 181.81,57.74 181.81,59 181.96,59.15 181.96,59.99 181.03,60.92 180.27,60.92 180.04,61.15 180.04,63.07 179.11,63.99 179.11,64.38 179.58,64.84 180.19,64.84 181.35,66 181.35,67.09 181.59,67.33 182.68,67.33 183.01,67.67 183.01,69.14 182.78,69.38 182.78,71.14 182.21,71.71 182.21,73.07 181.35,73.92 181.35,76.75 176.73,81.37 176.73,83.96 175.05,85.63 175.05,86.38 172.44,88.99 172.44,93.37 171.63,94.18 171.63,96.72 172.29,97.38 172.29,99.18 v1(172.67,99.57)
  IN3 w0.089: v1(173.51,105.69) 173.33,105.86 172.2,105.86 171.5,105.17 171.16,105.17 169.44,103.45 168.55,103.45 168.25,103.15 168.25,102.54 169.41,101.37 v1(169.41,100.39) ; v2(206.55,26.88) 206.75,27.07 208.82,27.07 212.04,23.86 212.04,20.89 213.98,18.95 213.98,15.31 211.94,13.27 211.94,11.42 211.6,11.07 211.6,10.13 210.1,8.62 209.43,8.62 207.95,7.15 207.95,6.21 207.17,5.43 206.17,5.43 205.9,5.15 205.36,5.15 205.01,4.8 200.43,4.8 199.13,3.5 197.76,3.5 197.46,3.2 195.48,3.2 195,3.68 195,4.18 194.29,4.89 192.89,4.89 191.98,3.98 191.68,3.98 191.68,3.99 186.73,3.99 185.08,5.63 181.85,5.63 179.78,3.57 171.22,3.57 168.67,6.12 v1(161.75,6.12) 161.48,5.86 145.57,5.86 145.04,6.39 145.04,7.01 144.61,7.44 v1(144.61,7.44) 144.17,7 144.17,6.47 143.55,5.86 138.81,5.86 138.14,6.53 137.3,6.53 136.63,5.86 132.84,5.86 132.56,5.58 105.17,5.58 101.7,7.02 101.21,7.51 98.61,7.51 97.69,8.44 76.81,8.44 75.46,7.08 75.46,3.79 74.29,2.63 68.19,2.63 66.88,3.93 65.5,3.93 64.56,2.99 54.96,2.99 53.11,4.85 52.7,4.85 v1(51.48,6.07) 51.08,6.07 50.95,5.94 48.97,5.94 48.64,5.61 48.64,5.05 48.19,4.61 42.43,4.61 41.79,5.25 35.88,5.25 35.25,4.61 31.95,4.61 31.83,4.49 25.18,4.49 23.65,6.01 23.42,6.01 v1(22.88,6.55)
  BOTTOM w0.109: U1805.A2 203.71,28.37 204.37,27.71 204.37,27.12 204.74,26.74 206.44,26.74 206.55,26.85 v2(206.55,26.88) 206.55,26.9 205.29,28.17 204.67,28.17 203.77,29.06 203.27,29.06 203.02,28.81 U1805.B3 ; v1(51.48,6.07) 51.48,6.68 50.96,7.2 50.96,10.56 50.26,11.26 48.85,11.26 48.41,11.71 48.41,13.08 47.39,14.09 45.56,14.09 v1(45.02,13.56) ; v1(173.51,105.69) 173.86,105.33 174.66,105 175.26,105 175.38,105.12 U2006.A2 ; v1(24.31,60.09) 24.47,60.25 24.47,61.53 23.26,62.74 23.26,67.18 v1(23.73,67.64) ; v1(150.85,102.71) 150.79,102.71 R1904.2 ; v1(183.44,49.58) 183.64,49.79 183.64,50.17 183.94,50.47 186.05,50.47 186.28,50.7 186.99,50.7 187.55,51.25 188.36,51.25 189.3,52.19 190.35,52.19 190.6,51.94 192.48,51.94 192.76,52.22 196.01,52.22 196.88,51.35 200.48,51.35 201.01,50.82 201.65,50.82 202,51.18 202.41,51.18 v1(202.84,50.75)
INPUT3VSEL: length 8.4
  BOTTOM w0.109: R1247.2 149.64,64.65 149.27,64.29 149.27,63.46 149.1,63.28 148.78,63.28 148.49,63.58 R1249.1 148.49,63.7 148.34,63.85 145.41,63.85 145.14,64.11 144.66,64.11 144.51,64.27 144.13,64.27 143.71,64.68 U400.DT49
INT_BT_OFF#: length 9.6
  TOP w0.109: Q4106.3 185.52,85.89 185.52,83.94 184.77,83.2 184.77,82.61 184.94,82.45 R4118.2 184.94,82.29 185.19,82.04 185.77,82.04 185.9,81.91 186.28,81.91 v1(186.65,81.54) v1(187.09,81.1)
  BOTTOM w0.109: CON4100.54 185.84,80.1 186.1,80.36 186.36,80.36 v1(187.09,81.1)
INT_EDP_AUXN: length 124.8
  TOP w0.109: v1(34.39,29.77) 34.63,29.77 34.74,29.88 34.74,30.83 33.67,31.9 33.67,33.88 33.53,34.02 33.2,34.02 33.18,34.01 33.11,33.94 C3418.2
  IN3 w0.089: v2(114.26,88.62) 114.26,88.36 114.31,88.31 114.6,88.31 114.69,88.41 114.69,88.87 113.97,89.59 112.39,89.59 111.5,88.7 111.5,88.39 110.93,87.82 109.42,87.82 107.93,89.3 106.17,89.3 105.31,90.16 103.27,90.16 102.86,90.57 101.42,90.57 94.61,83.77 93.61,83.77 92.45,82.61 92.45,81.51 90.54,79.6 90.54,78.69 87.22,75.38 87.22,75.12 86.67,74.57 86.67,72.02 80.82,66.17 80.82,65.39 78.22,62.78 70.74,62.78 68.85,60.9 68.85,55.95 59.51,46.61 56.63,46.61 49.51,39.49 47.18,39.49 36.74,29.06 34.97,29.06 34.73,29.3 34.73,29.71 34.68,29.77 v1(34.39,29.77)
  BOTTOM w0.109: v2(114.26,88.62) 114.26,88.45 114.15,88.34 113.86,88.34 113.65,88.13 113.65,86.82 113.28,86.44 U400.AJ1
INT_EDP_AUXP: length 124.8
  TOP w0.109: v1(35.16,29.77) 34.96,29.96 34.96,30.92 33.89,31.99 33.89,33.97 33.62,34.24 33.41,34.24 C3419.2
  IN3 w0.089: v2(114.26,87.95) 114.43,88.12 114.67,88.12 114.88,88.33 114.88,88.95 114.05,89.78 112.31,89.78 111.31,88.78 111.31,88.47 110.85,88.01 109.5,88.01 108.01,89.49 106.25,89.49 105.39,90.35 103.35,90.35 102.93,90.76 101.34,90.76 94.53,83.96 93.53,83.96 92.26,82.69 92.26,81.59 90.35,79.68 90.35,78.77 87.03,75.46 87.03,75.2 86.48,74.65 86.48,72.1 80.63,66.25 80.63,65.47 78.14,62.97 70.66,62.97 68.66,60.98 68.66,56.03 59.43,46.8 56.55,46.8 49.43,39.69 47.1,39.69 36.67,29.25 35.05,29.25 34.92,29.38 34.92,29.54 v1(35.16,29.77)
  BOTTOM w0.109: U400.AJ2 113.56,86 113.56,86.46 113.84,86.74 113.84,88.05 113.94,88.15 114.05,88.15 v2(114.26,87.95)
INT_EDP_TXN0: length 115.2
  TOP w0.109: v1(33.97,26.87) 34.18,26.66 34.18,26.49 34.12,26.42 33.04,26.42 32.98,26.48 C3417.2
  IN3 w0.089: v2(112.98,86.71) 112.8,86.54 109.28,86.54 107.51,88.31 105.68,88.31 104.81,89.18 101.84,89.18 100.95,88.29 100.63,88.29 99.22,86.88 99.22,86.31 91.81,78.89 91.81,78.58 90.94,77.71 90.94,76.94 88.69,74.69 88.69,72.5 87.03,70.84 87.03,70.21 82.78,65.95 82.78,65.4 79.18,61.8 71.14,61.8 69.83,60.49 69.83,55.34 66.71,52.22 66.71,51.38 60.95,45.63 57.03,45.63 49.87,38.47 47.7,38.47 36.8,27.57 34.52,27.57 34.17,27.23 34.17,27.08 v1(33.97,26.87)
  BOTTOM w0.109: v2(112.98,86.71) U400.AG1
INT_EDP_TXN1: length 119.2
  TOP w0.109: C3411.1 33.13,30.13 33.13,27.82 33.4,27.56 34.38,27.56 34.47,27.65 34.47,27.79 v1(34.22,28.04)
  IN3 w0.089: v2(112.09,88.16) 112.09,88.15 111.93,87.98 111.66,87.98 111.1,87.42 109.24,87.42 107.76,88.91 105.92,88.91 105.06,89.77 103.1,89.77 102.71,90.16 101.68,90.16 98.59,87.08 98.59,86.51 91.02,78.94 91.02,78.62 89.72,77.31 89.72,76.75 87.06,74.09 87.06,71.81 81.89,66.64 81.89,65.39 81.2,64.7 80.7,64.7 78.38,62.39 70.9,62.39 69.24,60.73 69.24,55.63 65.49,51.88 65.49,51.46 60.24,46.21 56.79,46.21 49.65,39.08 47.48,39.08 37.03,28.62 34.72,28.62 34.54,28.44 34.54,28.36 v1(34.22,28.04)
  BOTTOM w0.079: v2(112.09,88.16) 112.09,88.15 111.89,87.95 111.72,87.95 111.55,87.78 111.55,86.1 111.72,85.93 111.91,85.93 111.98,85.86 U400.AF2
INT_EDP_TXP0: length 115.2
  TOP w0.109: v1(34.73,26.87) 34.41,26.56 34.41,26.53 34.41,26.52 34.41,26.39 34.21,26.2 33.19,26.2 C3415.2
  IN3 w0.089: v1(34.73,26.87) 34.44,26.87 34.36,26.95 34.36,27.15 34.6,27.38 36.88,27.38 47.78,38.28 49.95,38.28 57.11,45.44 61.03,45.44 66.9,51.31 66.9,52.14 70.02,55.26 70.02,60.41 71.22,61.61 79.26,61.61 82.97,65.32 82.97,65.87 87.22,70.13 87.22,70.76 88.89,72.43 88.89,74.61 91.13,76.86 91.13,77.63 92,78.5 92,78.81 99.41,86.23 99.41,86.81 100.7,88.1 101.02,88.1 101.92,88.99 104.73,88.99 105.6,88.12 107.43,88.12 109.2,86.35 112.67,86.35 v2(112.96,86.05)
  BOTTOM w0.109: v2(112.96,86.05) U400.AG2
INT_EDP_TXP1: length 119.1
  TOP w0.109: v1(34.98,28.04) 34.7,27.76 34.7,27.56 34.48,27.34 33.3,27.34 32.91,27.73 32.91,30.13 C3409.1
  IN3 w0.089: v2(112.09,87.62) 111.91,87.79 111.74,87.79 111.18,87.23 109.16,87.23 107.68,88.72 105.84,88.72 104.98,89.58 103.02,89.58 102.63,89.97 101.76,89.97 98.78,87 98.78,86.43 91.21,78.86 91.21,78.54 89.91,77.24 89.91,76.67 87.25,74.01 87.25,71.73 82.08,66.56 82.08,65.31 81.28,64.51 80.78,64.51 78.46,62.2 70.98,62.2 69.44,60.66 69.44,55.55 65.68,51.8 65.68,51.38 60.32,46.02 56.87,46.02 49.73,38.89 47.56,38.89 37.11,28.43 34.8,28.43 34.73,28.36 34.73,28.29 v1(34.98,28.04)
  BOTTOM w0.079: U400.AF1 111.98,86.17 111.9,86.09 111.79,86.09 111.71,86.17 111.71,87.71 111.78,87.79 111.92,87.79 v2(112.09,87.62)
INT_RF_OFF#: length 14.6
  TOP w0.109: Q4108.3 191.56,71.31 v1(191.08,71.31) 190.98,71.41 R4132.2 190.38,71.08 190.82,70.63 v1(191.1,70.63)
  IN2 w0.089: v1(191.1,70.63) 190.65,70.63 187.72,73.56 187.72,75.25 188.26,75.79 188.26,76.17 187.54,76.89 v1(187.54,77.58)
  BOTTOM w0.109: v1(187.54,77.58) 187.52,77.58 186.72,78.38 186.59,78.38 186.34,78.63 CON4100.56
INTRUDER#: length 23.8
  TOP w0.109: v2(157.39,68.39) 157.51,68.39 157.81,68.09 C1500.1 157.51,67.96 157.48,68 156.84,68 156.72,67.88 156.72,67.44 156.9,67.26 R1240.1 157.17,67.16 R1237.2
  IN1 w0.079: v2(141.75,70.59) 141.38,70.96 141.06,70.96 140.92,71.11 140.92,71.64 141.05,71.78 141.34,71.78 141.6,72.03 143.6,72.03 145.14,70.5 148.84,70.5 150.22,69.11 150.83,69.11 151.37,68.58 154.2,68.58 154.44,68.81 155.31,68.81 155.47,68.65 156.19,68.65 156.45,68.39 157.39,68.39 v2(157.39,68.39)
  BOTTOM w0.109: U400.DM37 141.52,70.36 v2(141.75,70.59)
INV_PWM_R: length 2.1
  TOP w0.109: R3433.1 32.64,40.05 32.64,40.38 v1(32.43,40.59) 32.31,40.59 32.03,40.31 U3405.3
ISH_AE_INT_K: length 5.6
  BOTTOM w0.079: 146.43,74.3 146.29,74.3 146.14,74.16 146.14,73.78 145.98,73.62 145.66,73.62 144.87,74.41 144.55,74.41 144.41,74.55 U400.DV27
  BOTTOM w0.109: TP800.1 148.77,74.3 146.43,74.3
ISL95860_ALERT#: length 3.7
  TOP w0.109: PR8833.2 80.71,108.19 81.08,108.19 81.19,108.09 81.19,107.7 81.45,107.44 82.45,107.44 82.75,107.13 PU8800.28
ISL95860_CLK: length 3
  TOP w0.109: PU8800.29 82.67,106.73 82.19,107.21 81.33,107.21 80.92,107.62 PR8835.2
ISL95860_COMP: length 4.4
  TOP w0.203: PR8818.1 82.47,102.98 PC8805.2 84.13,103.68 84.37,103.68 84.48,103.78 v1(84.61,103.78) 85.21,103.78 85.47,104.03 PU8800.5
ISL95860_EN: length 3.8
  TOP w0.178: v1(82.56,105.46) 82.63,105.53 PU8800.32
  TOP w0.203: PR8827.2 81.34,104.73 81.35,104.72 v1(81.76,104.72) 82.22,105.19 82.29,105.19 v1(82.56,105.46)
  BOTTOM w0.203: v1(82.56,105.46) 82.86,105.76 82.86,106.52 PC8811.2
ISL95860_FB: length 4.3
  TOP w0.203: PU8800.6 85.87,104.02 v1(86.09,103.79) 86.3,103.58 PR8830.2 85.82,102.98 85.66,102.81 PR8834.2 85.08,102.81 84.91,102.98 PR8828.1
ISL95860_HOT#: length 2.5
  TOP w0.109: PR8829.2 81.21,106.78 v1(81.84,106.78) 82.24,106.78 82.69,106.33 PU8800.30
ISL95860_IMON: length 3.5
  TOP w0.203: v1(83.26,104.09) 83.51,104.33 83.91,104.33 84.27,104.69 PU8800.2
  BOTTOM w0.203: v1(83.26,104.09) 83.26,103.89 PR8840.1 84.13,103.41 84.19,103.47 PC8818.2
ISL95860_ISEN1: length 8.8
  TOP w0.203: v1(88.74,105.63) 88.82,105.63 PR8806.2 89.22,106.25 89.48,106.51 89.48,106.86 PC8809.1 89.32,106.9 88.29,105.86 v1(88.14,105.86) 88.07,105.93 PU8800.10 ; v1(90.32,104.05) 91.26,104.05 PR8807.1
  BOTTOM w0.203: v1(88.74,105.63) 88.87,105.49 PR8846.1 89.23,105.07 89.63,104.67 90.12,104.67 90.32,104.47 v1(90.32,104.05)
ISL95860_ISEN2: length 17.1
  TOP w0.203: PU8800.11 88.31,106.33 88.89,106.92 88.89,107.33 PC8810.1 89.45,108.42 v1(89.36,108.51) ; PR8815.1 91.82,100.78 91.69,100.66 v1(91.56,100.66) 91.18,100.66 v1(90.98,100.86) 90.9,100.78 PR8812.2
  BOTTOM w0.203: v1(89.36,108.51) 89.02,108.17 89.02,106.59 88.14,105.71 PR8845.1 87.98,105.07 87.3,104.39 87.3,102.66 88.39,101.57 90.27,101.57 v1(90.98,100.86)
ISL95860_ISEN3: length 4
  TOP w0.203: PU8800.12 87.66,106.73 87.74,106.65 88.18,106.65 88.56,107.03 88.56,108.13 v1(88.59,108.15) 88.77,108.34 88.77,108.78 PR8826.1
ISL95860_ISUMN: length 12.3
  TOP w0.203: v1(89.68,104.11) 90.15,104.58 PC8804.2 PC8808.1 91.1,104.91 91.05,104.96 91.05,105.25 91.16,105.36 PR8821.2 91.16,106.24 90.51,106.9 PC8809.2 PC8810.2 ; PR8819.2 89.04,100.92 PR8823.2 87.98,101.97 PR8820.2 87.98,103.22 v1(88.15,103.39)
  BOTTOM w0.203: v1(88.15,103.39) 88.27,103.26 PC8803.2 89.32,103.26 89.81,102.77 PR8814.2 90.02,103 89.95,103.07 PR8817.1 89.68,103.67 v1(89.68,104.11)
ISL95860_ISUMN_R: length 3.8
  TOP w0.178: PU8800.8 86.67,104.57 86.73,104.51
  TOP w0.203: 86.73,104.51 87.53,103.7 v1(87.53,103.45) PR8820.1 87.53,102.34 87.27,102.08 PC8807.1
ISL95860_ISUMP: length 12.9
  TOP w0.178: PU8800.9 87.61,105.53
  TOP w0.203: 87.61,105.53 87.68,105.53 88.21,105 89.07,105 PC8804.1 89.14,104.47 88.82,104.47 88.57,104.21 v1(88.57,104.19) 88.57,103.78 89.04,103.31 PR8808.2 PR8816.2 88.91,101.87 v1(88.47,102.31)
  BOTTOM w0.203: PR8810.1 92,100.22 91.64,100.58 91.64,100.97 90.29,102.32 PR8814.1 89.63,102.32 89.47,102.48 PC8803.1 88.85,102.48 88.84,102.48 88.64,102.48 v1(88.47,102.31)
ISL95860_NTC: length 5
  TOP w0.203: PR8839.1 PC8817.2 81.6,103.25 82.14,103.78 v1(82.7,103.78) 82.9,103.58 83.56,103.58 84.01,104.02 84.05,104.02 84.67,104.64 PU8800.3
ISL95860_PROG1: length 1.6
  TOP w0.178: v1(83.66,109.64) 83.87,109.44 PU8800.24
  BOTTOM w0.203: PR8809.1 83.53,109.51 v1(83.66,109.64)
ISL95860_PROG2: length 1.6
  TOP w0.203: v1(84.34,109.7) 84.27,109.62 PU8800.23
  BOTTOM w0.203: v1(84.34,109.7) 84.38,109.66 PR8811.1
ISL95860_PROG3: length 1.7
  TOP w0.203: PU8800.22 84.67,109.22 85.02,109.57 v1(85.02,109.66)
  BOTTOM w0.203: PR8813.1 85.23,109.45 v1(85.02,109.66)
ISL95860_PSYS: length 5.2
  TOP w0.178: PU8800.1 83.87,104.74 83.79,104.66
  TOP w0.203: PR8836.1 81.8,103.94 82.61,104.76 v1(82.61,104.81) 82.76,104.66 83.79,104.66
  BOTTOM w0.203: v1(82.61,104.81) 82.69,104.89 PC8819.2 83.72,104.89 83.75,104.85 PR8838.1
ISL95860_RTN: length 49.1
  TOP w0.203: PU8800.7 86.27,104.45 86.26,104.45
  TOP w0.254: 86.26,104.45 86.26,104.36 86.79,103.83 86.79,100.61 PC8815.1 86.78,99.59 87.85,99.59 PC8816.2 88.52,98.92 88.52,97.86 88.17,97.52 88.17,96.35 89.1,95.42 89.1,91.57 88.49,90.96 88.49,90.56 88.17,90.23 88.17,88.83 87.78,88.44 87.78,86.08 93.17,80.69 93.37,80.69 95.72,78.34 95.72,77.64 96.59,76.76 98.01,76.76 98.81,75.97 98.81,74.77 99.72,73.86 99.72,72.19 99.75,72.13 100.63,71.24 102.33,71.24 102.97,70.61 104.01,70.61 v1(104.52,71.12) 104.64,71.23 PR8837.2 105.36,70.96 105.37,70.95 PR8844.2
ISL95860_SDA: length 4.5
  TOP w0.109: PU8800.27 82.96,107.53 82.84,107.66 81.55,107.66 81.42,107.79 81.42,109.38 81.32,109.48 81.32,109.84 81.43,109.96 PR8831.2
ISL95860_SLOPE: length 1.9
  TOP w0.203: v1(84.98,104.28) 85.07,104.36 PU8800.4
  BOTTOM w0.203: PR8822.1 85.02,104.31 v1(84.98,104.28)
ISL95860_VDD: length 2.4
  TOP w0.203: PU8800.26 82.02,107.93 PC8802.1
  TOP w0.254: v1(82.51,108.47) 82.24,108.47 PC8802.1
  vias: v1(82.75,107.87)
ISL95860_VIN: length 1.2
  TOP w0.178: 83.01,108.46 83.13,108.33 PU8800.25
  TOP w0.203: 83.01,108.46 83.01,109.1 v1(82.92,109.18)
  vias: v1(82.29,109.19)
ISL95860_VRRDY: length 3.2
  TOP w0.203: PR8824.1 81.08,106.18 PR8825.2 81.37,106.19 81.49,106.3 82.31,106.3 82.68,105.93 PU8800.31
IST_TP_0: length 6.1
  BOTTOM w0.109: U400.A4 96.55,88.9 TP1012.1
IST_TP_1: length 5.5
  BOTTOM w0.109: TP1011.1 97.34,86.95 100.23,84.07 100.72,84.07 U400.A6
ITP_PMODE: length 3.6
  TOP w0.109: CON7703.46 40.37,50.48 39.73,51.12 39.28,51.12 ; 39.28,51.12 R7724.2 ; 39.28,51.12 R7706.2
JTAG_TCK: length 8.9
  BOTTOM w0.109: TP6905.1 83.66,67.56 80.8,67.56 80.62,67.39 79.24,67.39 78.84,67.79 75.94,67.79 75.53,68.2 U6600.AE5
JTAG_TDI: length 10
  BOTTOM w0.109: TP6907.1 80.37,66.63 79.61,65.87 77.43,65.87 77.32,65.99 77.32,66.75 77.06,67 76.02,67 75.72,67.31 75.72,67.56 75.48,67.79 75.11,67.79 74.7,68.2 U6600.AE6
JTAG_TDO: length 12.3
  BOTTOM w0.109: TP6908.1 85.19,65.07 84.32,65.94 80.42,65.94 79.89,65.41 76.83,65.41 75.7,66.54 75.3,66.54 U6600.AF6
JTAG_TMS: length 8.4
  BOTTOM w0.109: U6600.AD6 74.85,68.59 78.73,68.59 79.29,68.02 TP6906.1
JTAG_TRST#: length 9.3
  BOTTOM w0.109: v1(84.4,66.49) 84.22,66.67 R6963.1 83.74,66.46 83.45,66.17 80.24,66.17 79.71,65.64 77.1,65.64 U6600.AG4
KBC_PWR_ON: length 179.6
  TOP w0.076: U4700.G7 195.44,18.29 v2(194.79,18.29)
  TOP w0.109: v2(187.25,26.92) 186.97,26.92 186.46,26.41 184.3,26.41 184.07,26.19 v2(183.72,26.19) ; PR9513.2 PR9522.1 173.08,61.92 173.06,61.9 v1(173.06,61.49) 173.25,61.49 173.91,60.83 173.91,59.66 173.61,59.35 R4806.1 173.1,59.48 170.2,62.38 170.2,65.45 169.11,66.55 169.11,67.03 167.38,68.76 167.38,70.03 166.67,70.74 166.47,70.74 166.16,71.04 166.16,71.7 166.77,72.31 166.77,73.05 165.28,74.55 163.42,74.55 163.24,74.72 162.84,74.72 162.33,75.23 v1(160.78,75.23)
  IN1 w0.079: v1(119.07,13.76) 119.2,13.76 119.71,13.26 120.55,13.26 120.95,13.66 120.95,13.76 121.49,14.3 124.99,14.3 125.93,15.24 130.86,15.24 131.76,14.34 136.13,14.34 136.45,14.66 145.68,14.66 146.35,13.99 153.01,13.99 153.57,13.43 155.52,13.43 156.63,14.55 156.63,14.96 157.27,15.59 162.26,15.59 162.89,16.23 164.46,16.23 164.74,15.95 164.74,15.57 164.94,15.37 172.24,15.37 172.54,15.67 178.46,15.67 179.14,14.99 182.05,14.99 184.82,17.77 184.82,19.88 184.27,20.43 184.27,22.81 182.67,24.41 182.67,25.4 183.35,26.07 183.6,26.07 v2(183.72,26.19)
  IN2 w0.089: v1(173.06,61.49) 172.69,61.13 172.69,59.64 173.25,59.08 173.25,57.2 173.76,56.69 173.76,54.88 174.24,54.4 174.24,52.53 176.03,50.74 176.03,48.74 177.65,47.12 177.65,42.8 180.34,40.1 180.34,38.21 181.82,36.73 181.82,35.96 182.91,34.87 182.91,33.87 185.43,31.35 185.43,29.88 185.9,28.74 187.13,27.51 187.13,27.04 v2(187.25,26.92) 188.08,26.08 188.08,25.91 188.3,25.69 188.59,25.57 189.56,24.6 189.56,24.17 190.95,22.78 191.92,22.78 192.73,21.97 193.33,21.97 193.5,21.81 194.02,21.81 194.84,20.99 194.84,19.45 195.27,19.02 195.27,18.78 v2(194.79,18.29)
  BOTTOM w0.109: PR10625.1 119.28,13.56 v1(119.07,13.76) ; v1(160.78,75.23) 160.75,75.23 160.65,75.33 158.68,75.33 157.58,74.23 157.58,73.73 156.77,72.92 154.05,72.92 153.6,72.47 U1600.3
KBC_PWR_ON_3: length 89.1
  TOP w0.109: PR9505.2 151.44,16.18 v1(151.44,16.17) 151.18,16.43 151.02,16.43 v1(150.32,17.13) ; PR9522.2 174.53,61.32 v1(174.53,60.38)
  IN3 w0.089: v1(150.32,17.13) 150.61,17.13 150.8,16.94 151.38,16.94 152.02,17.57 155.22,17.57 157.5,15.29 159.65,15.29 160.02,15.66 162.39,15.66 163.45,16.72 163.95,16.72 165.95,18.72 175.93,18.72 176.81,19.6 177.8,19.6 178.64,20.45 179.02,20.45 179.96,21.39 180.37,21.39 180.62,21.64 180.62,23.11 180.22,23.51 180.22,27.03 178.5,28.75 178.5,29.33 176.78,31.05 176.78,32.8 175.9,33.68 175.9,34.32 172.98,37.24 172.98,38.77 170.98,40.77 170.76,40.77 v1(170.13,41.4)
  BOTTOM w0.109: v1(174.53,60.38) 174.85,60.38 175.43,59.8 175.43,58.55 175.54,58.44 175.54,57.43 175.98,56.99 175.98,56.08 174.46,54.56 174.46,53.02 174.85,52.62 174.85,51.73 174.23,51.11 174.23,50.7 174.83,50.11 174.83,48.95 174.06,48.19 174.06,47.53 173.29,46.75 173.29,45.87 171.82,44.41 171.82,43.18 170.33,41.69 170.33,41.6 v1(170.13,41.4)
KBL_DET#: length 242.2
  IN1 w0.079: v1(45.44,7.85) 48.25,7.85 49.38,8.97 52.83,8.97 54.44,10.58 55.51,10.58 56.08,11.15 57.88,11.15 58.25,11.52 73.71,11.52 74.2,12 79.24,12 80.45,13.2 83.57,13.2 84,12.77 91.65,12.77 92.9,11.53 98.31,11.53 100.24,9.59 104.67,9.59 105.5,8.77 109.37,8.77 109.67,9.07 112.71,9.07 113.45,9.81 114.12,9.81 114.58,10.26 123.99,10.26 124.14,10.41 125.08,10.41 130.3,10.41 131.09,11.21 134.89,11.21 135.32,11.38 136.11,11.38 137.48,10.01 138.38,10.01 arc(138.75,10.08) 139.07,10.29 139.37,10.59 142.72,10.59 143.55,10.94 147.22,10.94 147.55,11.27 148.77,11.27 149.67,10.66 149.93,10.4 159.09,10.4 159.68,11 163.67,11 164.6,11.93 167.9,11.93 169.06,10.77 169.42,10.77 171.17,9.02 172.33,9.02 172.39,8.97 178.62,8.97 180.52,10.86 183.09,10.86 183.91,11.68 184.88,11.68 186.26,13.05 187.61,13.05 188.29,13.73 188.29,15.85 188.06,16.08 188.06,16.84 187.63,17.27 187.27,17.27 187.09,17.45 187.09,21.05 187.52,21.48 187.59,21.64 187.59,21.85 187.37,22.06 187.13,22.06 185.95,23.24 185.95,24.38 184.69,25.63 184.07,27.13 184.07,27.26 182.16,29.18 182.01,29.18 177.77,33.42 176.01,33.42 172.67,36.77 170.94,36.77 168.81,38.9 167.83,38.9 166.73,37.8 164.71,37.8 163.73,38.77 162.99,38.77 161.72,40.03 161.36,40.03 161.14,40.26 160.22,40.26 159.97,40.5 156.75,40.5 150.67,46.58 150.67,46.73 150.3,47.1 149.61,47.1 142.08,54.63 142.08,55.74 141.27,56.56 140.69,56.56 140.07,57.18 140.07,57.8 139.85,58.01 139.85,62.86 138.85,63.86 138.85,64.35 138.59,64.61 137.95,64.61 137.6,64.96 137.6,65.57 137.26,65.91 137.26,66.79 136.89,67.17 v2(136.89,68.15)
  BOTTOM w0.109: v1(45.44,7.85) 45.76,7.52 R626.1 46.09,7.43 CON5002.6 ; v2(136.89,68.15) 137.25,68.15 U400.DB41
KBSWON: length 1.5
  BOTTOM w0.109: R5027.1 31.19,25.35 SW5000.1
KSI0: length 83
  TOP w0.076: 190.22,14.81 190.96,15.54 191.69,15.54 U4700.A2
  TOP w0.109: v2(185.81,14.41) 185.97,14.25 v1(186.51,14.25) 188.19,14.25 188.55,13.88 189.75,13.88 190.22,14.35 190.22,14.81 ; v1(120.45,7.85) 120.45,8.15 119.88,8.73 R5015.1
  IN2 w0.089: v2(138.83,10.55) 138.87,10.59 142.5,10.59 142.86,10.95 145.18,10.95 145.47,10.66 147.32,10.66 147.78,11.11 154.08,11.11 154.36,10.84 157.23,10.84 157.47,11.08 159.56,11.08 159.67,11.19 160.28,11.19 160.77,10.7 162.8,10.7 163.34,10.16 165.47,10.16 165.84,10.52 166.14,10.52 166.74,9.92 170.65,9.92 171.52,9.05 174.66,9.05 176.05,10.45 177.98,10.45 180.8,13.26 180.8,14.43 181.33,14.96 182.5,14.96 183.04,14.42 184.79,14.42 185.12,14.09 185.49,14.09 v2(185.81,14.41)
  IN3 w0.089: v1(120.45,7.85) 120.81,8.2 124.56,8.2 125.68,9.32 131.54,9.32 132.2,9.97 133.3,9.97 133.45,9.83 134.54,9.83 135.28,10.56 135.75,10.56 136.1,10.92 138.36,10.92 138.73,10.55 v2(138.83,10.55)
  BOTTOM w0.109: v2(138.83,10.55) 139.79,11.5 D5000.6
KSI1: length 90.8
  TOP w0.076: 190.22,15.32 190.8,15.9 191.74,15.9 U4700.A3
  TOP w0.109: R5015.2 119.24,9.72 119.48,9.96 120.55,9.96 v1(121.03,9.47) 121.37,9.47 122.08,8.76 123.53,8.76 124.02,8.26 124.02,7.75 124.36,7.41 124.36,6.17 125.65,4.87 134.12,4.87 134.6,5.36 140.9,5.36 142.57,7.03 142.57,8 143.22,8.65 143.22,10.06 143.01,11.11 v1(142.03,12.09) ; 190.22,15.32 189.71,14.81 189.71,14.58 189.44,14.31 188.73,14.31 188.21,14.83 186.91,14.83 v2(186.39,15.35)
  IN2 w0.089: v2(186.39,15.35) 186.08,15.67 181.03,15.67 179.22,13.86 177.54,13.86 176.43,12.75 172.51,12.75 170.41,10.64 168.96,10.64 168.05,11.56 164.12,11.56 163.97,11.41 162.25,11.41 161.75,11.9 159.38,11.9 159.27,11.79 157.75,11.79 157.36,12.18 153.49,12.18 153.06,12.61 146.03,12.61 145.44,12.02 144.45,12.02 144.33,12.14 142.09,12.14 v1(142.03,12.09)
  BOTTOM w0.109: v1(142.03,12.09) 142.31,11.81 142.31,10.54 141.98,10.2 D5000.3
KSI2: length 92.2
  TOP w0.076: U4700.A4 191.78,16.67 191.36,16.25 190.52,16.25
  TOP w0.109: v2(185.6,14.93) 185.6,15.16 186.16,15.73 187.77,15.73 188.21,15.29 189.56,15.29 190.52,16.25 ; v2(136.96,10.04) 137.18,10.04 137.39,9.83 139.49,9.83 139.73,9.59 139.73,9.2 139.41,8.88 139.41,8.57 138.71,7.88 D5001.6 138.71,7.01 138.33,6.63 137.97,6.63 137.8,6.47 137.67,6.41 134.33,6.41 133.37,5.46 126.8,5.46 124.46,7.8 v1(124.46,8.2) 124.46,8.33 123.8,8.99 122.18,8.99 120.98,10.18 118.92,10.18 118.61,9.87 R5015.3
  IN2 w0.089: v2(185.6,14.93) 185.21,15.31 184.32,15.31 183.6,14.59 183.16,14.59 182.62,15.14 181.25,15.14 180.62,14.5 180.62,13.34 177.9,10.62 175.98,10.62 174.59,9.23 171.59,9.23 170.73,10.1 166.81,10.1 166.21,10.7 165.76,10.7 165.4,10.33 163.41,10.33 162.87,10.87 162.03,10.87 161.53,11.37 159.6,11.37 159.49,11.26 157.4,11.26 157.16,11.02 154.43,11.02 154.16,11.29 147.7,11.29 147.25,10.84 145.59,10.84 145.28,11.15 142.81,11.15 142.45,10.79 139.1,10.79 138.97,10.92 137.44,10.92 136.96,10.44 v2(136.96,10.04)
KSI3: length 88.5
  TOP w0.076: 189.88,14.36 190.05,14.53 190.05,14.89 190.88,15.72 191.98,15.72 192.28,16.02 U4700.B3
  TOP w0.109: D5001.3 137.41,9.3 137.06,9.65 136.7,9.65 136.42,9.94 v2(136.42,10.04) ; R5015.4 117.97,9.89 118.49,10.41 121.08,10.41 122.07,9.42 v1(123.24,9.42) 123.86,9.42 v1(125.63,7.66) ; v2(186.21,14.83) 186.57,14.83 186.91,14.48 188.26,14.48 188.64,14.09 189.61,14.09 189.88,14.36
  IN2 w0.089: v2(186.21,14.83) 186.21,14.88 185.6,15.49 184.24,15.49 183.55,14.8 183.21,14.8 182.7,15.31 181.18,15.31 180.34,14.47 180.34,13.31 177.84,10.82 175.92,10.82 174.51,9.41 171.66,9.41 170.79,10.28 168.81,10.28 167.9,11.2 165.98,11.2 165.29,10.51 163.49,10.51 162.95,11.05 162.1,11.05 161.61,11.55 159.53,11.55 159.42,11.44 157.57,11.44 157.2,11.81 153.28,11.81 152.83,12.26 148.42,12.26 147.18,11.02 145.66,11.02 145.35,11.33 142.73,11.33 142.38,10.97 139.8,10.97 139.06,11.71 138.7,11.71 138.08,11.1 137.34,11.1 136.42,10.17 v2(136.42,10.04)
  IN3 w0.089: v2(136.42,10.04) 135.16,8.78 126.46,8.78 125.63,7.95 v1(125.63,7.66)
KSI4: length 92
  TOP w0.076: U4700.B4 192.37,16.67 192.06,16.36 191.75,16.36 191.44,16.05 190.62,16.05 189.95,15.38
  TOP w0.109: v1(121.91,7.81) 121.91,7.76 v1(120.62,6.47) 120.59,6.44 119.26,6.44 118.61,7.09 R5015.8 ; v2(187.21,15.25) 187.4,15.06 189.63,15.06 189.95,15.38 ; D5002.6 140.05,8.86 140.51,9.32 142.11,9.32 142.53,8.9 v1(142.56,8.9) 142.56,9.71 142.21,10.06 142.21,11.29 v1(141.42,12.09)
  IN2 w0.089: v1(141.42,12.09) 141.82,12.49 144.23,12.49 144.52,12.2 145.36,12.2 145.95,12.79 153.13,12.79 153.56,12.36 157.43,12.36 157.82,11.97 159.2,11.97 159.3,12.08 161.83,12.08 162.32,11.58 163.9,11.58 164.05,11.73 168.12,11.73 169.04,10.82 170.33,10.82 172.45,12.94 176.34,12.94 177.46,14.06 179.17,14.06 180.96,15.85 186.46,15.85 187.06,15.25 v2(187.21,15.25)
  BOTTOM w0.109: v1(121.91,7.81) 122.38,7.34 125.04,7.34 126.58,5.8 128.6,5.8 129.06,6.25 129.06,6.61 129.56,7.12 130.31,7.12 130.55,7.35 136.25,7.35 136.65,6.95 137.07,6.53 137.94,6.53 138.54,5.94 139.67,5.94 140.8,7.07 142.08,7.07 142.41,7.4 142.41,8.76 v1(142.56,8.9)
KSI5: length 95.7
  TOP w0.076: 190.31,14.13 190.42,14.25 190.42,14.7 191.08,15.36 191.46,15.36 191.74,15.08 191.99,15.08 192.21,15.3 192.21,15.55 192.34,15.68 192.74,15.68 193.08,16.02 U4700.C3
  TOP w0.109: v1(142.76,10.18) 143,9.94 143,8.74 142.35,8.09 142.35,7.12 141.81,6.58 141.5,6.58 141.35,6.72 D5002.3 ; R5015.7 117.97,8.08 117.85,8.2 117.68,8.2 117.61,8.2 117.44,8.38 116.94,8.38 115.59,9.73 v2(115.59,10.69) ; 190.31,14.13 189.84,13.66 188.47,13.66 188.13,14 187,14 186.76,13.76 v2(186.76,13.59)
  IN2 w0.089: v2(186.76,13.59) 185.36,13.59 184.71,14.24 182.76,14.24 182.22,14.78 181.48,14.78 181.02,14.32 181.02,13.24 178.05,10.27 176.12,10.27 174.72,8.86 171.46,8.86 170.58,9.74 165.53,9.74 165.3,9.98 163.27,9.98 162.73,10.52 160.7,10.52 160.2,11.01 159.75,11.01 159.64,10.9 157.55,10.9 157.3,10.66 154.28,10.66 154.01,10.94 147.85,10.94 147.4,10.48 144.18,10.48 143.81,10.11 142.83,10.11 v1(142.76,10.18) 142.53,10.41 139.22,10.41 138.99,10.19 137.65,10.19 137.08,9.62 136.31,9.62 135.72,10.22 132.22,10.22 131.64,9.64 121.19,9.64 120.42,10.41 115.87,10.41 v2(115.59,10.69)
KSI6: length 87.2
  TOP w0.109: R5015.6 117.34,6.89 117.85,6.37 v1(118.27,6.37) 118.69,5.95 120.92,5.95 v1(122.74,7.78)
  TOP w0.14: U4700.C4 v2(192.84,16.34)
  IN3 w0.089: v1(122.74,7.78) 122.91,7.95 124.58,7.95 125.78,9.14 134.13,9.14 135.35,10.36 135.79,10.36 136.01,10.58 137.58,10.58 v2(137.6,10.55) 138.15,10.01 139.06,10.01 139.39,10.34 141.59,10.34 143.44,11.1 143.88,11.1 144.03,10.95 146.54,10.95 146.61,11.02 148.71,11.02 148.8,10.92 149.12,10.79 149.68,10.24 159.97,10.24 160.12,10.27 160.72,10.87 163.9,10.87 164.36,10.41 165.3,10.41 165.45,10.56 166.19,10.56 166.96,9.79 171.41,9.79 171.8,9.4 172.27,9.4 172.3,9.44 177.92,9.44 180.49,12.01 180.49,14.15 181.68,15.34 182.19,15.34 183.52,16.66 187.15,16.66 187.45,16.36 188.44,16.36 188.87,16.79 189.19,16.79 189.39,16.58 190.09,16.58 190.9,17.4 191.79,17.4 v2(192.84,16.34)
  BOTTOM w0.109: v2(137.6,10.55) 137.6,11.06 137.83,11.29 D5003.6
KSI7: length 85.2
  TOP w0.076: 190.29,16.46 191.24,16.46 191.78,17 192.84,17 U4700.C5
  TOP w0.109: v1(121.29,7.8) 120.15,6.67 119.57,6.67 119.24,6.99 R5015.9 ; v2(189.14,15.81) 189.65,15.81 190.29,16.46
  IN3 w0.089: v2(189.14,15.81) 188.98,15.81 188.65,16.15 187.19,16.15 186.86,16.48 183.59,16.48 182.27,15.16 181.75,15.16 180.69,14.1 180.69,11.97 177.99,9.26 172.38,9.26 172.34,9.22 171.72,9.22 171.33,9.61 165.96,9.61 165.34,10.23 164.29,10.23 163.83,10.69 160.79,10.69 160.16,10.06 149.6,10.06 149.02,10.64 148.67,10.79 148.61,10.84 146.78,10.84 146.71,10.77 143.96,10.77 143.8,10.93 143.48,10.93 141.63,10.16 139.47,10.16 139.14,9.83 137.69,9.83 137.12,10.4 136.08,10.4 135.79,10.11 135.35,10.11 134.21,8.96 125.88,8.96 124.53,7.62 123.21,7.62 122.98,7.39 121.7,7.39 v1(121.29,7.8)
  BOTTOM w0.109: CON5000.20 122.14,8.47 121.97,8.3 121.79,8.3 v1(121.29,7.8)
KSI_D_0: length 38.4
  BOTTOM w0.109: D5000.1 141.45,11.5 140.71,10.77 140.71,9.7 141.09,9.32 142.75,9.32 142.98,9.09 142.98,8.58 142.64,8.25 142.64,7.32 142.17,6.85 140.91,6.85 139.77,5.71 138.44,5.71 137.84,6.32 136.98,6.32 136.16,7.13 131.64,7.13 129.66,5.15 123.44,5.15 122.46,6.12 119.88,6.12 118.59,7.41 116.18,7.41 115.14,8.45 CON5000.34
KSI_D_1: length 29
  IN2 w0.089: v1(140.44,12.09) 138.57,12.09 137.94,11.45 135.45,11.45 135.32,11.4 131.33,11.4 130.1,10.18 124.03,10.18 122.99,11.22 121.59,11.22 121.48,11.33 117.02,11.33 v1(116.52,10.82)
  BOTTOM w0.109: v1(116.52,10.82) 116.64,10.7 CON5000.31 ; D5000.5 140.39,10.85 140.76,11.22 140.76,11.77 v1(140.44,12.09)
KSI_D_2: length 27.5
  TOP w0.109: v1(130.36,6.44) 130.65,6.14 133.02,6.14 134.21,7.34 136.14,7.34 136.82,8.01 138.14,8.01 138.71,8.59 D5001.1
  BOTTOM w0.109: CON5000.32 116.14,8.32 116.56,7.9 118.84,7.9 120.17,6.57 122.64,6.57 123.52,5.7 124.05,5.7 124.42,6.07 124.42,6.51 124.66,6.75 125.01,6.75 126.4,5.36 129.28,5.36 v1(130.36,6.44)
KSI_D_3: length 25.7
  TOP w0.109: v1(129.48,6.44) 129.48,6.39 130.18,5.69 133.27,5.69 134.44,6.86 v1(136.7,6.86) 136.93,6.86 137.15,6.63 137.62,6.63 137.68,6.66 138.06,7.04 D5001.5
  BOTTOM w0.109: v1(129.48,6.44) 129.48,6.24 128.82,5.58 126.49,5.58 125.1,6.97 124.57,6.97 124.2,6.6 124.2,6.16 123.96,5.92 123.61,5.92 122.74,6.79 120.41,6.79 119.05,8.15 117.43,8.15 117.14,8.44 CON5000.30
KSI_D_4: length 28.8
  TOP w0.109: D5002.1 140.05,6.14 139.75,5.84 138.58,5.84 138.22,6.2 134.43,6.2 133.4,5.17 126,5.17 v1(125.29,5.88) v1(124.84,6.34)
  BOTTOM w0.109: CON5000.33 115.64,8.43 116.43,7.64 118.77,7.64 120.06,6.35 122.55,6.35 123.43,5.48 124.14,5.48 124.84,6.18 v1(124.84,6.34)
KSI_D_5: length 24.3
  TOP w0.109: v1(139.29,7.2) 139.29,7.49 139.8,8 140.46,8 140.7,8.24 D5002.5
  IN3 w0.089: v1(139.29,7.2) 136.89,7.2 136.19,6.5 133.12,6.5 132.33,7.29 130.78,7.29 130.32,6.82 126.84,6.82 125.95,5.93 124.18,5.93 v1(123.78,6.34)
  BOTTOM w0.109: CON5000.22 121.14,8.56 120.87,8.28 120.87,7.63 121.44,7.06 123.06,7.06 v1(123.78,6.34)
KSI_D_6: length 17.2
  IN2 w0.089: v1(135.39,11.01) 135.18,11.22 131.4,11.22 130.18,10 122.94,10 v1(122.14,10.8)
  BOTTOM w0.109: v1(122.14,10.8) 122.14,10.46 121.64,9.96 CON5000.21 ; v1(135.39,11.01) 135.88,11.01 136.15,11.29 D5003.1
KSI_D_8: length 41.1
  BOTTOM w0.109: CON5000.37 113.64,8.23 113.61,8.2 113.61,6.94 114.88,5.67 122.27,5.67 123.24,4.7 131.65,4.7 133.17,6.22 133.17,6.48 133.36,6.67 136.01,6.67 137.32,5.36 139.8,5.36 141.08,6.63 142.28,6.63 142.87,7.22 142.87,8.15 143.2,8.48 143.2,9.47 v1(143.15,9.52) 143.13,9.55 141.2,9.55 140.94,9.8 140.94,10.64 141.16,10.85 D5000.2
KSI_D_9: length 19.1
  BOTTOM w0.109: CON5000.17 123.64,8.55 123.88,8.31 125.9,8.31 126.28,7.93 126.28,7.54 126.52,7.31 128.35,7.31 128.61,7.57 130.11,7.57 130.6,8.06 133.1,8.06 134.9,9.85 135.76,9.85 135.95,9.66 137.61,9.66 138.12,10.18 139.16,10.18 139.19,10.2 D5000.4
KSI_D_10: length 26.8
  TOP w0.109: v1(134.34,7.99) 134.76,7.57 136.05,7.57 136.71,8.23 137.7,8.23 138.06,8.6 D5001.2
  IN1 w0.079: v1(134.34,7.99) 133.79,8.54 126.41,8.54 126.25,8.38 116.02,8.38 v1(114.88,7.24)
  BOTTOM w0.109: v1(114.88,7.24) 114.64,7.48 CON5000.35
KSI_D_11: length 17.3
  TOP w0.109: D5001.4 137.08,7.24 136.98,7.34 136.57,7.34 136.32,7.08 134.34,7.08 133.17,5.92 130.28,5.92 129.92,6.27 129.92,6.6 129.64,6.88 128.78,6.88 v1(128.34,6.44)
  BOTTOM w0.109: CON5000.18 123.14,8.55 123.61,8.08 125.8,8.08 126.05,7.83 126.05,7.45 127.06,6.44 v1(128.34,6.44)
KSI_D_12: length 32.5
  TOP w0.109: D5002.2 140.7,6.19 140.15,5.63 137.92,5.63 v1(137.77,5.78)
  BOTTOM w0.109: CON5000.36 114.14,7.97 113.83,7.66 113.83,7.05 114.98,5.9 122.37,5.9 123.34,4.93 131.53,4.93 132.9,6.3 132.9,6.53 133.25,6.89 136.1,6.89 137.21,5.78 v1(137.77,5.78)
KSI_D_13: length 23.2
  TOP w0.109: D5002.4 141.35,8.18 140.94,7.77 139.9,7.77 139.71,7.58 139.71,7 139.5,6.79 139.46,6.79 139.36,6.77 139.17,6.69 v1(138.85,6.37)
  BOTTOM w0.109: CON5000.19 122.64,8.5 123.44,7.7 124.99,7.7 126.67,6.02 128.51,6.02 128.83,6.33 128.83,6.71 129.46,7.34 130.22,7.34 130.46,7.57 136.34,7.57 137.15,6.77 138.03,6.77 138.43,6.37 v1(138.85,6.37)
KSI_D_14: length 26.1
  IN2 w0.089: v2(113.91,10.33) 114,10.23 120.34,10.23 121.11,9.47 131.72,9.47 132.2,9.95 132.7,9.95 v1(133.1,9.56)
  BOTTOM w0.109: v2(113.91,10.33) 113.81,10.33 113.14,9.65 CON5000.38 ; D5003.2 136.19,11.94 135.71,11.45 135.15,11.45 134.75,11.06 134.75,10.74 134.57,10.29 133.84,9.56 v1(133.1,9.56)
KSO0: length 122.4
  TOP w0.076: 191.42,17.39 191.49,17.39 191.71,17.61 192.22,17.61 U4700.B5
  TOP w0.109: v2(189.84,17.19) 189.89,17.14 v1(190.57,17.14) 190.82,17.39 191.42,17.39
  IN3 w0.089: v2(112.85,10.51) 114.05,9.31 124.91,9.31 125.44,9.84 130.3,9.84 131.02,10.56 133.51,10.56 134.51,11.57 134.64,11.57 135.23,11.81 135.63,11.81 135.96,11.48 138.45,11.48 138.71,11.73 139,11.73 139.7,11.03 141.45,11.03 143.3,11.8 144.17,11.8 144.32,11.65 145.46,11.65 146.21,12.4 147.29,12.4 147.71,11.99 148.73,11.99 149.2,11.52 149.34,11.46 151.74,11.46 152.18,11.02 157.41,11.02 157.55,11.16 158.84,11.16 159.93,11.61 164.19,11.61 164.36,11.44 166.74,11.44 167.28,10.89 167.28,10.39 167.52,10.15 171.41,10.15 171.62,10.35 178.33,10.35 180.13,12.16 180.13,14.3 181.53,15.69 182.05,15.69 183.57,17.22 186.92,17.22 186.99,17.29 189.74,17.29 v2(189.84,17.19)
  BOTTOM w0.109: CON5000.41 111.64,9.81 112.34,10.51 v2(112.85,10.51) ; v2(189.84,17.19) 189.84,17.52 190.21,17.9 190.21,18.55 190.02,18.74 189.52,18.94 189.49,18.94 189.36,19.07 189.36,19.79 188,21.15 188,21.88 189.28,23.16 191.75,23.16 191.97,23.06 192.16,22.87 195.31,22.87 195.34,22.84 197.99,22.84 198.05,22.91 203.48,22.91 206.64,19.75 208.38,19.75 208.7,19.42 209.58,19.42 209.8,19.2 209.8,18.62 210.19,18.22 CON7702.17
KSO1: length 114.7
  TOP w0.076: 191.43,18.33 191.74,18.33 191.78,18.29 192.19,18.29 U4700.B6
  TOP w0.109: v2(189.84,18.1) 190.33,18.1 190.57,18.33 191.43,18.33
  IN3 w0.089: v2(189.84,18.1) 189.75,18.18 189.58,18.18 189.25,18.51 189.05,18.51 188.65,18.91 187.55,18.91 187.15,18.51 187.15,18.35 186.62,17.83 183.43,17.83 181.83,16.22 181.31,16.22 179.6,14.52 179.6,12.38 178.11,10.89 171.29,10.89 171.08,10.68 168.69,10.68 167.4,11.97 164.65,11.97 163.87,12.75 162.36,12.75 161.75,12.14 159.82,12.14 158.73,11.69 157.76,11.69 157.3,12.15 153.18,12.15 152.73,12.6 147.87,12.6 147.54,12.94 145.95,12.94 145.22,12.2 144.52,12.2 144.29,12.44 142.71,12.44 142.59,12.56 141.31,12.56 140.99,12.24 140.99,11.91 140.74,11.66 139.93,11.66 139.26,12.32 138.52,12.32 138.24,12.04 136.15,12.04 135.31,12.88 134.7,12.88 134.37,12.54 134.37,12.18 133.39,11.2 130.9,11.2 130.68,10.97 129.23,10.97 128.84,11.36 125.95,11.36 125,10.41 121.33,10.41 v1(120.89,10.84)
  BOTTOM w0.109: v2(189.84,18.1) 189.84,18.4 189.54,18.7 189.48,18.73 189.4,18.73 189.14,18.99 189.14,19.69 187.77,21.06 187.77,21.97 189.17,23.37 191.79,23.37 192.1,23.25 192.25,23.09 195.71,23.09 195.73,23.07 197.89,23.07 197.95,23.14 203.58,23.14 206.74,19.98 208.47,19.98 208.8,19.65 209.66,19.65 210.03,19.28 210.03,19.07 210.37,18.72 CON7702.18 ; CON5000.23 120.64,10.18 120.89,10.43 v1(120.89,10.84)
KSO2: length 144.5
  TOP w0.076: U4700.B7 192.16,18.98 191.23,18.98 191.07,19.13 191.07,19.55 191.23,19.71 191.23,20.04 191.06,20.22 189.61,20.22 189.33,20.5 189.33,20.67 189.25,20.75 188.95,20.75
  TOP w0.109: 188.95,20.75 188.06,20.75 187.63,21.18 186.87,21.18 v2(186.71,21.02) ; v2(177.62,9.8) 177.62,9.54 179.41,7.76 181.44,7.76 182.44,6.76 184.57,6.76 184.76,6.57 187.35,6.57 187.85,7.07 189.1,7.07 190.06,8.03 193.53,8.03 v1(193.96,7.59)
  IN1 w0.079: v2(177.62,9.8) 178.57,9.8 180.25,11.49 182.79,11.49 183.21,11.91 183.21,12.69 184.19,13.67 186.06,13.67 186.71,14.32 187.09,14.32 187.75,14.98 187.75,15.49 185.82,17.42 185.82,20.12 v2(186.71,21.02)
  IN2 w0.089: v2(177.62,9.8) 176.3,9.8 175.16,8.66 171.41,8.66 170.51,9.56 165.46,9.56 165.22,9.8 163.19,9.8 162.65,10.34 160.25,10.34 160.09,10.18 159.69,10.18 159.39,10.48 149.12,10.48 148.68,10.05 147.53,10.05 147.27,10.3 144.26,10.3 143.75,9.8 142.6,9.8 142.18,10.21 139.29,10.21 139.09,10.01 137.72,10.01 137.16,9.45 136.24,9.45 135.65,10.04 134.13,10.04 133.2,9.11 130.96,9.11 130.78,9.29 120.93,9.29 120.27,9.95 112.6,9.95 v2(112.47,10.08) ; v1(207.31,20.65) 207.31,19.3 208.02,18.6 208.02,14.06 206.86,12.9 206.86,11.96 202.64,7.74 199.11,7.74 198.85,8.01 196.44,8.01 196.35,8.1 194.88,8.1 194.58,7.8 194.17,7.8 v1(193.96,7.59)
  BOTTOM w0.109: v2(112.47,10.08) 112.14,9.75 CON5000.40 ; CON7702.20 210.37,19.72 209.96,20.13 209.1,20.13 208.58,20.65 v1(207.31,20.65)
KSO3: length 120.9
  TOP w0.076: U4700.B8 192.17,19.61 191.76,19.61 191.56,19.8 191.56,20.02 191.22,20.37 190.5,20.37 189.92,20.95 188.9,20.95 188.85,21 188.5,21
  TOP w0.109: v2(187.23,21.71) 187.42,21.71 188.13,21 188.5,21
  IN1 w0.079: v1(117.14,10.82) 117.55,11.24 123.95,11.24 124.11,11.3 124.37,11.3 124.71,11.64 128.95,11.64 129.21,11.37 130.36,11.37 130.84,11.85 134.8,11.85 135.19,12.01 139.14,12.01 139.93,11.22 142.59,11.22 143.53,11.61 145.33,11.61 145.95,12.23 152.09,12.23 152.32,12 152.32,11.53 152.82,11.03 158.83,11.03 159.42,11.63 161.51,11.63 162.45,12.57 163.17,12.57 164.26,13.66 169.75,13.66 170.89,12.52 170.89,11.04 171.43,10.51 178.83,10.51 180.12,11.8 182.59,11.8 182.89,12.1 182.89,12.81 184.06,13.99 185.92,13.99 186.76,14.83 186.76,15.57 185.5,16.83 185.5,21.01 186.43,21.94 187,21.94 v2(187.23,21.71)
  BOTTOM w0.109: CON5000.29 117.64,10.32 v1(117.14,10.82) ; CON7702.19 210.34,19.22 210.25,19.31 210.25,19.37 209.74,19.88 208.89,19.88 208.57,20.21 206.87,20.21 203.72,23.36 197.85,23.36 197.8,23.3 195.82,23.3 195.81,23.31 192.35,23.31 192.22,23.43 191.84,23.59 189.07,23.59 187.23,21.76 v2(187.23,21.71)
KSO4: length 86.9
  TOP w0.076: U4700.C7 v2(192.84,18.94)
  IN3 w0.089: v2(192.84,18.94) 192.43,18.53 190.62,18.53 190.21,18.12 190.21,17.79 190.15,17.73 189.69,17.73 189.23,18.19 187.24,18.19 186.67,17.63 183.48,17.63 181.9,16.05 181.38,16.05 179.78,14.44 179.78,12.31 178.18,10.71 171.37,10.71 171.16,10.5 168.61,10.5 167.33,11.79 164.56,11.79 163.77,12.58 162.44,12.58 161.83,11.97 159.86,11.97 158.76,11.51 157.69,11.51 157.23,11.97 153.11,11.97 152.65,12.42 147.78,12.42 147.45,12.76 146.06,12.76 145.33,12.02 144.45,12.02 144.21,12.26 143.46,12.26 141.36,11.39 139.85,11.39 139.12,12.11 138.57,12.11 138.31,11.86 136.08,11.86 135.24,12.7 134.77,12.7 134.54,12.47 134.54,12.1 133.44,11 130.95,11 130.75,10.79 129.16,10.79 128.77,11.18 126.03,11.18 125.07,10.23 118.99,10.23 v1(118.38,10.83)
  BOTTOM w0.109: CON5000.27 118.64,10.57 v1(118.38,10.83)
KSO5: length 91.6
  TOP w0.076: v2(192.84,17.64) U4700.C6
  IN3 w0.089: v2(113.39,10.51) 113.39,10.3 114.2,9.49 124.84,9.49 125.37,10.02 130.22,10.02 130.95,10.74 133.43,10.74 134.43,11.74 134.59,11.74 135.18,11.99 135.7,11.99 136,11.68 138.39,11.68 138.64,11.94 139.05,11.94 139.77,11.21 141.41,11.21 142.04,11.47 142.04,11.47 143.27,11.98 144.24,11.98 144.39,11.83 145.39,11.83 146.14,12.58 147.37,12.58 147.71,12.25 152.19,12.25 152.33,12.11 152.33,11.53 152.57,11.29 153.4,11.29 153.91,11.79 157.15,11.79 157.61,11.33 158.8,11.33 159.9,11.79 164.26,11.79 164.44,11.61 167.25,11.61 168.54,10.33 171.29,10.33 171.49,10.53 178.25,10.53 179.96,12.24 179.96,14.37 181.46,15.87 181.97,15.87 183.53,17.42 186.74,17.42 187.33,18.01 189.16,18.01 189.61,17.56 190.23,17.56 190.4,17.73 190.4,18.06 190.69,18.35 192.13,18.35 v2(192.84,17.64)
  BOTTOM w0.109: v2(113.39,10.51) 113.39,10.41 112.64,9.66 CON5000.39
KSO6: length 85.8
  TOP w0.076: v2(192.84,19.59) U4700.C8
  IN3 w0.089: v2(192.84,19.59) 191.95,18.71 189.11,18.71 188.73,19.09 187.48,19.09 186.92,18.53 186.92,18.37 186.55,18.01 183.36,18.01 182.36,17.01 181.22,17.01 180.88,16.67 180.88,16.04 179.42,14.59 179.42,12.46 178.03,11.07 171.21,11.07 171.01,10.86 168.76,10.86 167.47,12.15 164.73,12.15 163.94,12.93 162.29,12.93 161.68,12.32 159.79,12.32 158.69,11.87 157.83,11.87 157.37,12.33 153.25,12.33 152.8,12.78 147.94,12.78 147.61,13.11 145.84,13.11 145.11,12.38 144.59,12.38 144.36,12.62 142.79,12.62 142.67,12.74 141.12,12.74 140.88,12.5 138.45,12.5 138.16,12.22 136.23,12.22 135.39,13.05 134.62,13.05 134.19,12.62 134.19,12.25 133.31,11.38 130.83,11.38 130.6,11.15 129.33,11.15 128.94,11.54 125.88,11.54 125.53,11.19 121.7,11.19 121.03,11.85 120.64,11.85 v1(119.65,10.86)
  BOTTOM w0.109: CON5000.25 119.64,10.85 v1(119.65,10.86)
KSO7: length 119.7
  TOP w0.076: U4700.B9 192.16,20.27 191.74,20.27 191.34,20.67 190.67,20.67 190.09,21.25 189.03,21.25 188.65,21.64
  TOP w0.109: v2(186.71,21.56) 186.75,21.61 186.75,21.79 187.06,22.1 187.42,22.1 187.78,21.74 R4815.2 188.54,21.74 188.65,21.64
  IN1 w0.076: v2(186.71,21.56) 186.61,21.56
  IN1 w0.079: v1(119.01,10.84) 119.42,10.42 123.34,10.42 124.01,11.09 124.14,11.14 124.44,11.14 124.78,11.48 128.88,11.48 129.15,11.21 130.43,11.21 130.91,11.69 134.83,11.69 135.22,11.86 139.08,11.86 139.87,11.07 142.62,11.07 143.56,11.46 145.39,11.46 146,12.06 147.13,12.06 147.44,11.74 148.91,11.74 149.98,11.02 150.13,10.87 158.89,10.87 159.49,11.47 163.01,11.47 164.27,12.73 170.18,12.73 170.74,12.16 170.74,10.95 171.33,10.35 178.89,10.35 180.19,11.65 182.69,11.65 183.05,12.01 183.05,12.75 184.13,13.83 185.99,13.83 186.73,14.57 187.11,14.57 187.58,15.03 187.58,15.39 185.66,17.31 185.66,20.81 186.41,21.56 186.61,21.56
  BOTTOM w0.109: CON5000.26 119.14,10.7 v1(119.01,10.84) ; CON7702.21 210.3,20.22 210.16,20.36 209.27,20.36 208.32,21.31 206.09,21.31 203.83,23.57 197.74,23.57 197.7,23.53 192.44,23.53 192.34,23.63 191.88,23.82 188.67,23.82 188.33,23.48 187.71,23.48 187.64,23.51 187.31,23.51 187.12,23.32 187.12,22.26 186.75,21.89 186.75,21.61 v2(186.71,21.56)
KSO8: length 88.3
  TOP w0.076: U4700.C9 v2(192.84,20.24)
  IN3 w0.089: v1(117.76,10.82) 118.26,11.33 119.4,11.33 120.1,12.03 121.1,12.03 121.77,11.37 125.46,11.37 125.81,11.72 129.05,11.72 129.44,11.33 130.53,11.33 130.76,11.55 133.24,11.55 134.01,12.32 134.01,12.69 134.55,13.23 135.46,13.23 136.3,12.39 138.09,12.39 138.37,12.68 140.81,12.68 141.05,12.91 142.74,12.91 142.86,12.79 144.43,12.79 144.67,12.56 145.04,12.56 145.77,13.29 147.69,13.29 148.02,12.96 152.88,12.96 153.33,12.51 157.45,12.51 157.91,12.05 158.66,12.05 159.35,12.33 159.51,12.5 159.51,12.93 159.79,13.21 163.92,13.21 164.8,12.32 167.56,12.32 168.84,11.04 170.93,11.04 172.36,12.47 177.75,12.47 177.83,12.39 178.68,12.39 179.25,12.95 179.25,14.66 180.63,16.05 180.63,16.78 181.04,17.19 182.28,17.19 183.28,18.18 186.48,18.18 186.71,18.42 186.71,18.58 187.4,19.27 188.83,19.27 189.18,18.92 191.51,18.92 v2(192.84,20.24)
  BOTTOM w0.109: v1(117.76,10.82) 118.14,10.44 CON5000.28

# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): 53.32,13.68 53.46,13.68 53.49,13.62 53.48,13.55 53.46,13.48 53.45,13.41 53.45,13.33 48.34,13.33 47.28,12.27 47.11,12.27 46.95,12.43 46.95,12.79 47.97,13.8 53.2,13.8
GND on IN3 (solid shape): 89.87,15.14 91.87,15.14 92.11,15.38 92.5,15.38 92.6,15.32 92.57,15.21 92.14,14.77 89.49,14.77 88.97,15.3 89.05,15.38 89.62,15.38
GND on IN3 (solid shape): 110.93,18.36 111.02,18.3 111,18.19 110.51,17.71 107.34,17.71 107.24,17.77 107.27,17.88 107.75,18.36
GND on IN3 (solid shape): 144.94,66.01 144.96,65.9 144.87,65.84 143.37,65.84 142.98,66.24 142.97,66.29 143.02,66.32 143.27,66.58 144.38,66.58
GND on IN3 (solid shape): 147.24,55.68 147.28,55.73 147.33,55.72 147.39,55.66 147.39,55.3 149.25,53.44 149.27,53.33 149.18,53.27 148.23,53.27 147.24,54.25
GND on IN3 (solid shape): 47.54,70.04 47.64,69.98 47.62,69.87 46.99,69.24 44.78,69.24 44.71,69.27 44.68,69.34 44.68,69.41 45.99,69.41 46.62,70.04
GND on IN3 (solid shape): 162.98,63.93 165.29,63.93 166.18,63.04 166.18,62.51 166.59,62.11 166.59,61.7 166.51,61.66 166.44,61.69 166.32,61.8 162.9,61.8 162.65,62.06 162.65,63.68 161.92,64.41 161.92,64.53 162.07,64.69 162.22,64.69
GND on IN3 (solid shape): 157.21,62.93 157.28,63.03 157.39,63 157.57,62.82 157.57,62.44 156.21,61.08 156.1,61.06 156.04,61.16 156.04,61.74 157.21,62.91
GND on IN3 (solid shape): 162.98,57.86 163.15,57.86 163.45,57.56 163.12,57.23 163.12,57.21 163.05,57.12 162.94,57.14 162.52,57.57 162.52,58.13 161.79,58.86 161.78,58.91 161.83,58.94 161.9,58.94
GND on IN3 (solid shape): 149.05,77.37 149.07,77.26 148.98,77.19 147.47,77.19 147.21,77.46 147.23,77.49 147.27,77.57 147.28,77.65 147.28,77.7 147.27,77.74 147.3,77.77 147.34,77.78 148.64,77.78
GND on IN3 (solid shape): 163.83,68.67 163.9,68.77 164.01,68.75 164.56,68.2 164.56,67.33 164.68,67.2 165.13,66.76 165.15,66.65 165.05,66.59 163.9,66.59 163.53,66.96 163.53,67.61 163.83,67.92
GND on IN3 (solid shape): 174.27,65.93 174.3,65.95 174.34,65.93 177.23,63.04 177.24,62.98 177.19,62.95 177.08,62.95 176.58,63.45 176.42,63.45 174.87,65.01 174.87,65.11 174.23,65.76 174.2,65.84 174.24,65.91
GND on IN3 (solid shape): 58.13,87.65 58.14,87.6 58.1,87.57 57.64,87.57 50.97,80.9 50.78,80.9 50.68,80.97 50.7,81.08 57.1,87.47 57.17,87.57 57.2,87.69 57.2,87.74 58.05,87.74
GND on IN3 (solid shape): 127.24,17.9 127.24,17.79 126.61,17.16 125.83,17.16 125.73,17.22 125.76,17.33 125.85,17.45 125.88,17.59 125.86,17.71 125.8,17.81 125.8,17.89 125.88,17.97 127.18,17.97
GND on IN3 (solid shape): 176.65,60.18 176.75,60.12 176.72,60.01 176.67,59.95 176.67,58.27 176.68,58.23 176.68,58.18 176.67,58.12 176.67,58.11 176.67,57.82 176.6,57.73 176.49,57.75 176.11,58.14 176.11,60.18
GND on IN3 (solid shape): 179.44,38.79 179.51,38.88 179.62,38.86 183.58,34.89 183.58,34.85 183.55,34.8 183.49,34.81 183.22,35.08 181.02,35.08 180.85,34.92 180.74,34.89 180.68,34.99 180.68,37.29 179.44,38.53
GND on IN3 (solid shape): 206.1,19.06 206.17,19.15 206.27,19.13 206.95,18.45 206.94,18.42 206.91,18.35 206.9,18.27 206.96,18.1 207.1,17.98 207.13,17.97 207.13,17.65 207.13,17.61 207.07,17.54 206.1,18.51
GND on IN3 (solid shape): 48.76,69.33 48.85,69.26 48.83,69.15 48.67,69 48.2,69 46.76,67.56 45.99,67.56 45.9,67.65 45.9,68.13 45.91,68.17 45.95,68.18 46.16,68.27 46.26,68.47 46.26,68.52 47.29,68.52 48.1,69.33
GND on IN3 (solid shape): 179.9,68.21 179.98,68.18 180.1,68.09 180.24,68.06 180.28,68.05 180.29,68.01 180.29,67.18 180.67,66.8 180.67,66.53 180.19,66.53 179.25,67.46 179.25,67.69 179.58,68.02 179.58,68.06 179.63,68.07 179.74,68.1 179.83,68.18
GND on IN3 (solid shape): 116.22,12.85 116.22,12.54 115.5,11.82 114.29,11.82 114.25,11.83 113.63,11.96 112.06,11.96 111.92,11.83 111.85,11.8 111.78,11.83 111.66,11.91 111.52,11.94 111.48,11.94 111.44,11.95 111.38,12.03 111.4,12.12 111.7,12.42 114.98,12.42 115.81,13.25
GND on IN3 (solid shape): 123.16,17.29 123.16,17.07 121.54,17.07 121.37,17.25 121.37,17.45 121.35,17.54 121.42,17.61 121.59,17.73 121.65,17.93 121.63,18.04 121.58,18.14 121.57,18.25 121.66,18.3 122.14,18.3
GND on IN3 (solid shape): 180,60 180.03,59.9 179.94,59.83 179.88,59.82 179.82,59.8 179.79,59.79 179.32,60.26 178.59,60.26 178.56,60.25 178.52,60.24 178.47,60.23 178.42,60.24 178.36,60.26 178.29,60.31 178.24,60.37 178.23,60.39 178.16,60.47 178.13,60.58 178.23,60.65 179.36,60.65
GND on IN3 (solid shape): 13.94,17.1 14.02,17.14 14.1,17.11 14.49,16.72 14.49,15.01 15.16,14.34 15.19,14.26 15.15,14.19 15.06,14.07 15.02,13.92 15.05,13.79 15.12,13.67 15.22,13.57 15.22,10.26 15.28,10.2 15.29,10.14 15.25,10.11 14.56,10.11 13.94,10.73
GND on IN3 (solid shape): 20.39,7.79 21.3,7.79 21.93,7.16 22.13,7.16 22.22,7.1 22.21,7 20.21,7 19.7,7.15 19.17,7.24 19.15,7.24 19.11,7.29 19.14,7.32 19.14,7.52 19.31,7.68 19.4,7.82 19.44,7.98 19.42,8.11 19.36,8.23 19.34,8.26 19.92,8.26
GND on IN3 (solid shape): 147.59,58.87 147.59,58.27 147.55,58.18 147.45,58.17 147.38,58.2 147.31,58.2 147.18,58.18 147.08,58.11 146.97,58.1 146.91,58.19 146.91,58.31 145.55,59.66 145.55,59.74 145.57,59.82 145.65,59.85 146.61,59.85
GND on IN3 (solid shape): 204.13,11.45 204.18,11.43 204.21,11.4 204.19,11.34 204.19,11.28 204.21,11.16 204.27,11.06 204.24,11.01 204.17,10.98 204.15,10.98 202.45,9.28 201.74,9.28 200.94,10.08 200.92,10.19 201.01,10.25 201.93,10.25 202.01,10.26 202.1,10.29 202.14,10.29 203.3,11.45
GND on IN3 (solid shape): 149.76,73.68 149.78,73.65 150.12,73.31 150.14,73.2 150.04,73.14 147.71,73.14 147.66,73.19 147.42,73.19 147.36,73.21 147.32,73.27 147.34,73.33 147.34,73.39 147.27,73.6 147.07,73.7 147.05,73.77 147.08,73.84 147.25,74.01 149.43,74.01
GND on IN3 (solid shape): 122.81,25.45 122.87,25.54 122.98,25.52 123.03,25.46 123.21,25.34 123.42,25.3 123.45,25.29 123.47,25.25 123.47,24.13 124.01,23.59 124.01,22.8 123.93,22.77 123.88,22.75 123.78,22.75 123.73,22.83 123.73,22.84 123.59,23.2 123.24,23.39 123.22,23.39 122.81,23.81
GND on IN3 (solid shape): 176.76,42.26 176.83,42.35 176.94,42.33 178.25,41.02 178.21,40.65 178.54,40.46 178.58,40.45 178.59,40.41 178.59,38.18 179.5,37.27 179.53,37.19 179.49,37.12 179.45,37.08 179.37,37.05 179.3,37.08 178.66,37.72 177.46,37.72 176.76,38.42
GND on IN3 (solid shape): 111.21,22.91 111.26,22.88 111.25,22.83 109.57,21.15 109.49,21.12 109.41,21.17 109.29,21.3 109.12,21.35 108.88,21.25 108.74,20.95 108.67,20.92 108.53,20.92 108.44,20.98 108.46,21.09 109.5,22.13 110.39,22.13 111.17,22.91
GND on IN3 (solid shape): 130.97,77.62 131.04,77.58 131.16,77.49 131.31,77.46 131.42,77.48 131.53,77.54 131.56,77.57 132.95,76.18 135.23,76.18 135.31,76.14 135.33,76.06 134.61,75.34 134.61,75.2 134.52,75.21 134.48,75.24 132.76,75.24 130.68,77.33 130.65,77.43 130.72,77.5 130.81,77.53 130.89,77.59
GND on IN3 (solid shape): 44.87,92.1 44.96,91.88 45.19,91.79 45.2,91.79 45.27,91.76 45.3,91.68 45.3,91.62 45.2,91.63 45.17,91.63 44.95,91.55 44.85,91.33 44.85,91.29 43.86,91.29 43.83,91.47 43.75,91.57 43.72,91.65 43.75,91.72 44.18,92.15 44.87,92.15
GND on IN3 (solid shape): 106.59,10.56 109.32,10.56 109.45,10.44 109.45,10.06 108.34,8.95 106.09,8.95 105.98,9.05 104.73,9.05 103.66,10.13 103.08,10.13 103.06,10.15 105.46,10.15 105.47,10.1 105.48,10.05 105.5,10 105.53,9.95 105.56,9.91 105.6,9.88 105.64,9.85 105.69,9.83 105.74,9.81 105.79,9.81 105.85,9.81 105.9,9.82 105.95,9.84 105.99,9.86 106.04,9.89 106.07,9.93 106.1,9.97 106.13,10.02 106.14,10.07 106.15,10.12 106.15,10.18 106.14,10.23 106.13,10.28 106.1,10.33 106.07,10.37 106.04,10.41 105.99,10.44 105.95,10.46 105.9,10.48 105.85,10.49 105.79,10.49 105.74,10.49 105.69,10.47 105.64,10.45 105.6,10.42 105.56,10.39 105.53,10.35 105.5,10.3 105.48,10.25 105.47,10.2 105.46,10.15 103.06,10.15 102.49,10.73 102.49,11.03 103.6,12.14 105.01,12.14
GND on IN3 (solid shape): 169.39,43.83 169.4,43.85 169.4,43.88 169.42,43.9 169.44,43.92 169.47,43.93 169.5,43.94 169.53,43.93 169.56,43.92 169.67,43.8 171.3,43.8 171.71,43.39 171.71,42.81 169.93,42.81 169.39,43.34 169.39,43.35 170.43,43.35 170.44,43.3 170.45,43.25 170.47,43.2 170.49,43.16 170.53,43.12 170.57,43.08 170.61,43.05 170.66,43.03 170.71,43.02 170.76,43.01 170.82,43.01 170.87,43.02 170.92,43.04 170.96,43.07 171,43.1 171.04,43.14 171.07,43.18 171.09,43.23 171.11,43.28 171.12,43.33 171.12,43.38 171.11,43.43 171.09,43.48 171.07,43.53 171.04,43.57 171,43.61 170.96,43.64 170.92,43.67 170.87,43.69 170.82,43.7 170.76,43.7 170.71,43.69 170.66,43.68 170.61,43.66 170.57,43.63 170.53,43.59 170.49,43.55 170.47,43.51 170.45,43.46 170.44,43.41 170.43,43.35 169.39,43.35
GND on IN3 (solid shape): 21.65,54.09 21.71,54.18 21.82,54.16 21.89,54.11 21.96,54.08 21.97,54.08 22.99,53.06 22.99,50.63 22.95,50.55 22.87,50.53 22.83,50.53 22.59,50.44 22.48,50.2 22.45,50.13 22.37,50.11 22.32,50.11 22.21,50.09 22.11,50.04 22.01,50.03 21.95,50.12 21.95,50.96 21.65,51.26
GND on IN3 (solid shape): 61.86,89.99 61.97,90.02 62.04,89.92 62.04,89.87 62.77,89.14 62.77,88.92 62.73,88.85 62.66,88.82 62.47,88.82 62.38,88.86 62.37,88.96 62.39,89.02 62.4,89.08 62.3,89.3 62.08,89.39 61.97,89.38 61.88,89.32 61.84,89.29 61.43,89.7 61.41,89.82 61.5,89.88 61.75,89.88
GND on IN3 (solid shape): 94.57,83.34 94.66,83.28 94.64,83.17 93.05,81.57 92.94,81.55 92.87,81.65 92.87,81.72 92.91,81.73 93.1,81.85 93.18,82.07 93.13,82.24 93,82.37 92.94,82.44 92.97,82.53 93.51,83.06 93.54,83.04 93.63,83 93.72,82.99 93.95,83.08 94.07,83.3 94.07,83.34
GND on IN3 (solid shape): 129.48,89.16 129.48,88.49 129.43,88.49 129.21,88.39 129.12,88.17 129.13,88.08 129.17,87.99 129.17,87.89 129.08,87.84 128.85,87.84 128.84,87.87 128.81,87.94 128.77,88 128.74,88.07 128.76,88.13 128.83,88.23 128.75,88.57 128.53,88.67 128.44,88.65 128.35,88.61 128.19,88.77 128.19,89.08 128.39,89.28 129.36,89.28
GND on IN3 (solid shape): 121.64,11.05 121.73,11.05 121.81,11.01 121.82,10.92 121.8,10.86 121.8,10.8 121.8,10.74 121.82,10.68 121.81,10.58 121.73,10.54 121.38,10.54 121.21,10.71 121.22,10.74 121.23,10.79 121.24,10.84 121.14,11.08 120.89,11.18 120.76,11.16 120.65,11.08 120.58,11.05 120.51,11.08 120.44,11.14 120.36,11.17 120.29,11.24 120.31,11.34 120.7,11.72 120.97,11.72
GND on IN3 (solid shape): 190.14,97.73 190.15,97.72 190.16,97.7 190.17,97.67 190.16,97.64 190.15,97.61 190.13,97.59 190.11,97.57 190.08,97.56 190.06,97.56 188.86,97.56 188.82,97.52 188.06,97.52 188.04,97.49 187.87,97.49 187.8,97.44 187.78,97.44 187.76,97.45 187.75,97.46 187.74,97.49 187.74,98.03 188.52,98.03 188.52,97.98 188.52,97.93 188.54,97.88 188.56,97.83 188.59,97.79 188.63,97.76 188.67,97.73 188.71,97.71 188.76,97.69 188.81,97.68 188.86,97.68 188.91,97.69 188.96,97.71 189,97.73 189.04,97.76 189.08,97.79 189.11,97.83 189.13,97.88 189.14,97.93 189.15,97.98 189.15,98.03 189.14,98.07 189.13,98.12 189.11,98.17 189.08,98.21 189.04,98.24 189,98.27 188.96,98.3 188.91,98.31 188.86,98.32 188.81,98.32 188.76,98.31 188.71,98.3 188.67,98.27 188.63,98.24 188.59,98.21 188.56,98.17 188.54,98.12 188.52,98.07 188.52,98.03 187.74,98.03 187.74,99.03 188.84,99.03
GND on IN3 (solid shape): 9.35,37.28 9.35,35.9 7.69,34.24 7.58,34.22 7.52,34.32 7.52,34.32 6.93,34.56 7.17,33.98 7.18,33.98 7.27,33.92 7.25,33.8 7.01,33.56 7.01,29.07 7.39,28.68 7.39,24.12 6.7,23.43 6.59,23.41 6.53,23.5 6.53,35.2 8.84,37.51 9.12,37.51
GND on IN3 (solid shape): 175.15,105.66 175.15,105.35 176.54,103.96 176.56,103.85 176.47,103.79 175.36,103.79 173.92,105.24 173.34,105.24 173.34,105.31 173.36,105.34 173.4,105.35 173.45,105.35 173.51,105.34 173.67,105.39 173.79,105.5 173.85,105.5 173.89,105.47 174.38,105.47 174.38,105.96 174.35,106.07 174.45,106.14 174.67,106.14
GND on IN3 (solid shape): 176.37,72.87 176.37,72 177.43,70.94 177.43,70.78 177.39,70.69 177.3,70.68 176.93,70.57 176.89,70.19 176.9,70.18 176.9,67.63 177.71,66.82 177.73,66.72 177.65,66.65 177.55,66.62 177.47,66.56 177.4,66.53 177.32,66.56 177.09,66.68 176.84,66.61 176.81,66.6 176.78,66.61 174.82,68.57 174.82,70.96 173.73,72.04 173.73,72.77 174.01,73.04 175.07,73.04 175.1,73.07 175.24,73.07 175.48,73.31 175.93,73.31
GND on IN3 (solid shape): 60.41,69.49 60.44,69.44 60.44,68.19 60.52,68.03 60.7,68.01 60.74,68.02 60.79,68.03 60.95,67.96 61.02,67.8 60.95,67.64 60.79,67.57 60.74,67.58 60.7,67.59 60.52,67.57 60.44,67.41 60.44,66.3 60.23,66.1 60.22,66.09 60.05,66 59.96,65.84 59.96,65.82 59.86,65.72 59.86,64.2 57.58,61.92 57.47,61.9 57.41,61.99 57.41,66.15 57.58,66.32 58.53,66.32 59.98,67.78 59.98,69.47 60.35,69.47
GND on IN3 (solid shape): 11.78,41.34 11.91,41.2 12.09,41.15 12.18,41.17 12.26,41.2 12.37,41.2 12.42,41.12 12.42,39.39 11.91,38.88 11.2,39.6 11.17,39.69 11.24,39.76 11.43,39.89 11.5,40.1 11.49,40.19 11.45,40.27 11.44,40.35 11.49,40.41 11.62,40.54 11.67,40.71 11.57,40.95 11.33,41.05 11.23,41.12 11.25,41.23 11.39,41.36 11.77,41.36
GND on IN3 (solid shape): 25.25,6.29 25.36,6.23 25.53,6.21 25.58,6.22 25.61,6.23 26.2,5.64 27.08,5.64 27.13,5.69 29.27,5.69 29.36,5.65 29.37,5.55 29.35,5.49 29.34,5.43 29.35,5.36 29.38,5.29 29.36,5.2 29.28,5.15 25.92,5.15 25.64,5.43 25.65,5.46 25.66,5.51 25.67,5.56 25.56,5.8 25.32,5.9 25.1,5.82 24.98,5.6 24.91,5.52 24.81,5.55 24.52,5.83 24.5,5.94 24.6,6 24.9,6 25.22,6.32
GND on IN3 (solid shape): 187.52,5.3 191.14,5.3 191.24,5.23 191.21,5.12 191.11,5 191.08,4.86 191.1,4.74 191.16,4.64 191.17,4.53 191.08,4.47 187.89,4.47 187.04,5.33 187.05,5.36 187.06,5.41 187.06,5.46 186.48,5.7 186.72,5.12 186.77,5.12 186.82,5.13 186.85,5.14 187.52,4.47 187.54,4.36 187.45,4.3 186.85,4.3 185.78,5.37 185.78,5.83 186,6.05 186.77,6.05
GND on IN3 (solid shape): 147.79,62 147.88,61.97 148.09,61.76 148.09,59.25 148.02,59.16 147.91,59.18 146.79,60.3 144.87,60.3 144.6,60.03 144.58,60.03 144.33,59.93 144.23,59.69 144.23,59.67 144.17,59.57 144.06,59.59 143.93,59.73 142.93,59.73 142.84,59.79 142.86,59.9 143.51,60.55 143.94,60.98 147.15,60.98 147.29,61.12 147.32,61.11 147.37,61.1 147.42,61.09 147.66,61.19 147.76,61.44 147.73,61.58 147.65,61.69 147.62,61.76 147.65,61.84 147.69,61.89 147.72,61.94
GND on IN3 (solid shape): 148.4,18.14 148.49,18.08 148.47,17.97 147.72,17.23 146.11,17.23 146.02,17.28 146.02,17.38 146.05,17.46 146.06,17.54 145.96,17.78 145.72,17.88 145.58,17.85 145.46,17.77 145.39,17.74 145.31,17.77 145.19,17.87 145.05,17.9 144.8,17.8 144.7,17.55 144.71,17.46 144.75,17.38 144.75,17.28 144.66,17.23 144.63,17.23 144.3,17.56 143,17.56 142.91,17.65 141.91,17.65 141.81,17.71 141.83,17.82 142.16,18.14
GND on IN3 (solid shape): 155.64,73.54 155.63,73.48 155.62,73.43 155.72,73.21 155.94,73.12 156.05,73.14 156.15,73.19 156.21,73.22 156.28,73.19 156.38,73.14 156.49,73.12 156.68,73.18 156.8,73.35 156.84,73.35 156.88,73.32 157.53,72.68 157.53,71.19 157.6,71.13 157.61,71.07 157.56,71.04 156.86,71.04 156.77,71.12 156.77,72.44 156.53,72.69 156.17,72.69 155.92,72.44 155.92,72.22 155.86,72.12 155.75,72.15 155.16,72.74 155.16,73.26 155.15,73.3 155.16,73.34 155.17,73.4 155.18,73.45 155.18,73.49 155.17,73.53 155.19,73.62 155.27,73.66 155.53,73.66
GND on IN3 (solid shape): 145.13,79.61 145.24,79.43 145.44,79.35 145.56,79.38 145.66,79.44 145.73,79.47 145.8,79.44 145.9,79.38 146.02,79.35 146.1,79.36 146.17,79.39 146.2,79.34 146.24,79.3 146.52,79.02 146.5,78.99 146.48,78.93 146.47,78.87 146.46,78.82 146.33,78.82 146.33,78.88 146.23,79.1 146.01,79.2 145.89,79.17 145.79,79.11 145.72,79.08 145.65,79.1 145.55,79.16 145.44,79.18 145.22,79.09 145.12,78.87 145.12,78.82 143.24,78.82 143.15,78.89 143.17,78.99 143.83,79.65 145.12,79.65
GND on IN3 (solid shape): 161.32,74.45 161.45,74.32 161.48,74.25 161.44,74.17 161.35,74.06 161.32,73.91 161.42,73.67 161.67,73.57 161.76,73.58 161.84,73.62 161.94,73.62 161.99,73.53 161.99,73.26 161.96,73.21 161.91,73.22 161.84,73.29 160.43,73.29 159.47,74.25 159.45,74.36 159.54,74.42 160.5,74.42 160.7,74.62 160.7,74.79 160.73,74.86 161.03,74.99 161.12,75.23 161.15,75.3 161.23,75.33 161.32,75.33
GND on IN3 (solid shape): outline of 100 points within 78.15,85.97 80.45,90.96
GND on IN3 (solid shape): 182.24,60.74 182.27,60.65 182.21,60.58 182.07,60.45 182.01,60.27 182.11,60.02 182.36,59.92 182.38,59.92 182.45,59.9 182.49,59.82 182.49,59.35 182.46,59.27 182.2,59.19 182.07,59.05 182,58.99 181.91,59.02 181.65,59.28 181.62,59.35 181.65,59.42 181.72,59.53 181.74,59.66 181.65,59.89 181.4,60.02 181.39,60.05 181.39,60.1 180.61,60.87 180.58,60.95 180.62,61.03 180.72,61.14 180.77,61.28 180.77,61.33 181.66,61.33
GND on IN3 (solid shape): 96.96,95.56 97.06,95.5 97.03,95.39 95.71,94.06 92.75,94.06 92.63,94.18 92.63,94.41 93.38,95.16 93.45,95.19 93.52,95.17 93.64,95.1 93.78,95.07 93.93,95.1 94.06,95.19 94.14,95.22 94.21,95.18 94.35,95.08 94.51,95.04 94.67,95.08 94.81,95.17 94.88,95.21 94.96,95.17 95.09,95.08 95.25,95.04 95.41,95.08 95.54,95.17 95.62,95.2 95.69,95.16 95.83,95.05 96.01,95.01 96.29,95.12 96.4,95.4 96.4,95.45 96.42,95.53 96.5,95.56
GND on IN3 (solid shape): 52.95,5.71 53.03,5.67 53.04,5.57 53.03,5.52 53.02,5.45 53.37,5.11 53.71,5.45 53.71,5.51 53.79,5.55 53.91,5.43 54.27,5.43 55,4.7 54.98,4.62 54.9,4.58 54.67,4.48 54.57,4.24 54.67,4 54.91,3.9 55.15,3.99 55.26,4.23 55.3,4.3 55.38,4.32 55.87,3.83 55.87,3.69 55.88,3.68 55.88,3.63 55.7,3.45 54.7,3.45 53.16,4.98 52.76,4.98 52.21,5.53 52.18,5.65 52.28,5.71
GND on IN3 (solid shape): 185.8,11.01 185.9,10.95 185.88,10.84 185.82,10.74 185.8,10.62 185.9,10.38 186.14,10.27 186.3,10.31 186.42,10.42 186.49,10.45 186.56,10.44 186.65,10.35 186.93,10.35 187.11,10.53 187.15,10.48 187.28,10.36 187.45,10.32 187.68,10.41 187.79,10.63 187.82,10.68 187.88,10.71 188,10.71 188.04,10.71 188.07,10.71 188.11,10.7 188.29,10.75 188.42,10.89 188.43,10.91 188.85,10.91 188.94,10.85 188.92,10.74 188.76,10.58 188.76,10.22 188.75,10.21 188.75,9.78 188.4,9.43 185.16,9.43 184.99,9.61 184.99,10.88 185.11,11.01
GND on IN3 (solid shape): 37.41,77.52 37.5,77.46 37.48,77.35 37.15,77.03 37.15,76.33 37.35,76.14 37.47,76.06 37.61,76.03 38.15,76.03 38.52,76.4 38.64,76.4 39.32,75.72 39.34,75.61 39.25,75.54 39.17,75.54 39.11,75.48 39.05,75.54 39.06,75.57 39.07,75.62 39.08,75.66 38.98,75.89 38.76,75.98 38.55,75.9 38.44,75.71 38.38,75.62 38.27,75.65 38.27,75.65 36.87,75.65 36.73,75.63 36.62,75.55 36.46,75.4 36.39,75.47 36.33,75.47 36.18,75.54 36.11,75.7 36.2,75.88 36.39,75.93 36.39,75.92 36.72,75.92 37,76.21 37,76.74 36.82,76.92 36.77,76.92 36.68,76.98 36.69,77.09 36.74,77.19 36.76,77.3 36.76,77.52
GND on IN3 (solid shape): 141.43,95.58 143.71,95.58 143.83,95.69 144.64,95.69 145.09,95.24 145.11,95.15 145.04,95.07 144.86,94.95 144.79,94.74 145.13,94.4 145.47,94.79 145.46,94.84 145.48,94.93 145.56,94.97 146.26,94.97 146.31,94.94 146.29,94.88 146.2,94.79 146.17,94.77 146.17,94.03 145.84,93.69 139.32,93.69 139.23,93.75 139.25,93.86 139.32,93.97 139.34,94.1 139.24,94.34 139,94.44 138.96,94.44 138.93,94.43 138.84,94.46 138.81,94.55 138.82,94.61 138.8,94.72 138.74,94.82 138.72,94.86 139.82,95.96 141.04,95.96
GND on IN3 (solid shape): 196.14,79.75 196.14,78.29 196.67,77.75 196.7,77.64 196.6,77.58 195.84,77.58 195.32,78.1 194.25,78.1 193.37,78.98 193.35,79.09 193.44,79.16 193.95,79.16 194.38,79.58 194.48,79.6 194.55,79.52 194.58,79.4 194.66,79.31 194.69,79.23 194.64,79.15 194.53,79.02 194.49,78.86 194.83,78.52 195.17,78.86 195.14,79 195.06,79.11 195.03,79.2 195.08,79.27 195.19,79.4 195.23,79.56 195.21,79.7 195.13,79.81 195.1,79.89 195.13,79.96 195.18,80.01 195.22,80.07 195.24,80.1 195.79,80.1
GND on IN3 (solid shape): 100.72,25.3 100.77,25.22 100.77,24.9 101.45,24.21 101.39,24.04 101.44,23.86 101.19,23.46 101.33,23.01 101.35,22.23 102.13,22.24 102.19,22.31 102.55,22.31 102.55,21.62 102.38,21.46 100.77,21.46 100.74,21.7 100.61,21.9 100.52,21.99 100.56,22.16 100.51,22.32 100.76,22.72 100.61,23.17 100.52,23.26 100.53,23.56 100.31,23.75 100.31,25.19 100.34,25.27 100.42,25.29 100.53,25.3 100.63,25.32
GND on IN3 (solid shape): 135.9,67.91 135.96,68.01 136.07,67.99 136.97,67.09 137,67.01 136.95,66.93 136.92,66.94 136.88,66.94 136.65,66.4 137.2,66.62 137.19,66.66 137.19,66.7 137.26,66.74 137.34,66.71 137.38,66.67 137.38,65.58 137.36,65.52 137.3,65.48 137.21,65.53 137.11,65.54 136.79,65.22 137.11,64.91 137.21,64.92 137.3,64.97 137.36,64.93 137.38,64.87 137.38,64.53 138.42,63.49 139.59,63.49 140.37,62.71 140.39,62.6 140.3,62.54 140.09,62.54 139.61,62.06 139.55,62.07 139.52,62.08 139.38,62.04 139.28,61.95 139.26,61.92 139.19,61.92 139.19,61.99 135.9,65.28
GND on IN3 (solid shape): 204.27,16.26 204.34,16.35 204.44,16.33 204.45,16.32 204.52,16.27 204.61,16.25 204.76,16.25 204.76,16.1 204.78,16.01 204.83,15.94 204.95,15.82 204.99,15.79 204.97,15.73 204.96,15.67 205.06,15.44 205.28,15.35 205.35,15.36 205.42,15.38 205.47,15.38 205.58,15.4 205.68,15.46 205.71,15.48 205.76,15.48 205.87,15.39 206.02,15.35 206.07,15.36 206.12,15.37 206.16,15.33 206.18,15.28 206.18,14.69 205.78,14.3 205.72,14.24 205.72,13.86 205.45,13.86 205.4,13.87 205.37,13.91 205.37,13.94 205.34,14.07 205.26,14.17 205.26,14.22 205.28,14.27 205.35,14.37 205.37,14.48 205.05,14.8 204.73,14.48 204.75,14.38 204.81,14.28 204.83,14.22 204.8,14.15 204.75,14.09 204.73,14.01 204.66,13.99 204.59,14.02 204.27,14.34
GND on IN3 (solid shape): outline of 132 points within 208.21,6.02 212.72,11.79
GND on IN3 (solid shape): 51.14,88.16 51.24,88.09 51.21,87.98 50.49,87.26 45.39,87.26 44.88,86.76 44.81,86.64 44.78,86.51 44.78,86.46 44.66,86.46 44.66,86.51 44.34,86.82 44.02,86.51 44.02,86.46 43.86,86.46 43.86,86.51 43.76,86.73 43.54,86.82 43.32,86.72 43.22,86.5 43.26,86.34 43.38,86.23 43.43,86.15 43.4,86.07 43.28,85.96 43.25,85.91 43.22,85.87 43.14,85.81 43.06,85.84 42.99,85.91 42.87,85.99 42.73,86.02 42.65,86.01 42.58,85.98 42.48,85.99 42.44,86.08 42.44,86.4 42.54,86.66 42.97,87.09 43.2,87.09 43.25,87.14 43.4,87.01 43.54,86.98 43.77,87.07 43.86,87.3 43.85,87.38 43.82,87.45 43.82,87.55 43.91,87.6 49.03,87.6 49.58,88.16
GND on IN3 (solid shape): 97.91,77.49 98.01,77.47 98.15,77.32 98.15,75.18 98.08,75.08 97.97,75.11 97.85,75.2 97.71,75.23 97.37,74.89 97.71,74.54 97.85,74.57 97.97,74.66 98.08,74.69 98.15,74.6 98.15,74.41 97.2,73.46 97.12,73.43 97.05,73.47 96.93,73.55 96.79,73.58 96.65,73.56 96.54,73.47 96.46,73.44 96.39,73.47 96.27,73.56 96.13,73.58 96,73.56 95.89,73.48 95.81,73.45 95.74,73.48 95.63,73.56 95.5,73.58 95.41,73.57 95.35,73.63 95.44,73.72 95.73,73.72 96.66,74.65 96.68,74.68 96.68,76.59 97.11,77.02 97.28,77.09 97.35,77.15 97.45,77.15 97.5,77.15 97.71,77.22 97.83,77.42
GND on IN3 (solid shape): 143.87,68.11 144.23,68.11 145.08,67.27 147.18,67.27 147.21,67.24 147.22,67.2 147.15,67.1 147.13,66.98 147.22,66.75 147.44,66.66 147.48,66.66 147.52,66.67 147.6,66.65 147.64,66.57 147.64,66.24 147.59,66.15 147.49,66.15 147.41,66.18 147.33,66.19 147.32,66.19 147.25,66.22 147.22,66.28 147.11,66.47 146.9,66.54 146.7,66.47 146.59,66.29 146.53,66.28 146.48,66.31 146.43,66.33 146.39,66.34 146.26,66.34 146.16,66.4 146.19,66.51 146.26,66.61 146.28,66.74 146.19,66.96 145.96,67.05 145.84,67.03 145.74,66.97 145.68,66.94 145.61,66.96 145.52,67.01 145.42,67.02 145.2,66.94 145.1,66.73 145.03,66.64 144.93,66.66 143.55,68.04 143.53,68.15 143.62,68.21 143.77,68.21
GND on IN3 (solid shape): outline of 145 points within 76.76,75.67 80.19,87.36
GND on IN3 (solid shape): outline of 148 points within 73.05,69.5 77.91,72.95
GND on IN3 (solid shape): outline of 147 points within 140.47,54.01 143.52,59.3
GND on IN3 (solid shape): 148.26,70.19 148.34,70.15 148.35,70.06 148.34,70.01 148.34,69.96 148.43,69.74 148.65,69.65 148.67,69.6 148.66,69.56 148.65,69.51 148.65,69.47 148.66,69.38 148.7,69.3 148.71,69.26 148.69,69.23 148.66,69.21 148.6,69.22 148.55,69.22 148.37,69.22 148.27,69.21 148.18,69.16 148.18,69.16 148.13,69.14 148.05,69.22 147.95,69.29 147.84,69.31 147.75,69.31 147.7,69.33 147.66,69.38 147.68,69.44 147.69,69.5 147.59,69.73 147.37,69.82 147.32,69.82 147.26,69.8 145.02,69.8 144.83,69.61 144.76,69.51 144.74,69.4 144.74,69 145,68.74 145.22,68.74 145.31,68.69 145.31,68.58 145.28,68.51 145.27,68.43 145.59,68.11 145.91,68.43 145.9,68.51 145.86,68.58 145.87,68.69 145.95,68.74 146.2,68.74 146.2,68.16 146.37,67.99 146.42,67.95 146.4,67.85 145.32,67.85 144.63,68.55 144.63,69.36 144.28,69.71 142.86,69.71 142.84,69.8 142.96,69.92 147.83,69.92 147.94,69.92 148.21,70.19
GND on IN3 (solid shape): 117.66,23.32 117.74,23.29 117.76,23.22 117.77,23.18 117.77,23.14 117.75,23.05 117.67,23.01 117.46,22.4 118.01,22.75 118.03,22.83 118.11,22.87 118.35,22.97 118.48,23.29 118.55,23.32 119.03,23.32 119.04,23.28 119.16,23.05 119.41,22.97 119.49,22.95 119.52,22.87 119.52,21.84 119.56,21.81 119.58,21.7 119.49,21.63 119.02,21.63 118.97,21.77 118.88,21.87 118.86,21.91 118.88,21.95 118.98,22.08 119.02,22.23 118.68,22.57 118.33,22.23 118.37,22.08 118.47,21.95 118.49,21.91 118.47,21.87 118.38,21.77 118.33,21.63 117.48,21.63 116.58,22.53 117.37,23.32
GND on IN3 (solid shape): outline of 168 points within 173.96,91.04 179.58,93.37
GND on IN3 (solid shape): outline of 182 points within 187.91,91.02 197.66,97.05
GND on IN3 (solid shape): outline of 190 points within 55.77,4.42 65.85,9.17
GND on IN3 (solid shape): 94.39,19.14 94.46,19.1 94.48,19.02 94.47,18.94 94.46,18.87 94.61,18.51 94.97,18.36 95.31,18.49 95.48,18.82 95.47,18.97 95.46,19.02 95.47,19.1 95.55,19.14 96.71,19.14 96.95,18.9 101.42,18.9 101.52,18.8 101.52,18.08 101.3,17.86 101.23,17.86 101.22,17.89 101.01,18.09 100.73,18.16 100.34,18 100.18,17.6 100.34,17.21 100.73,17.04 100.81,17.05 100.86,16.99 100.23,16.37 96.75,16.37 96.66,16.42 96.67,16.53 96.72,16.63 96.73,16.74 96.66,16.94 96.48,17.07 96.42,17.12 96.41,17.19 96.43,17.24 96.33,17.54 96.09,17.64 95.84,17.54 95.74,17.3 95.75,17.25 95.76,17.2 95.75,17.12 95.68,17.07 95.49,16.95 95.41,16.74 95.43,16.63 95.48,16.53 95.49,16.42 95.4,16.37 93.79,16.37 93.65,16.37 93.29,16.01 92.98,16.01 92.89,16.07 92.91,16.18 93.57,16.84 93.57,18.64 94.07,19.14
GND on IN3 (solid shape): outline of 190 points within 96.92,62.97 100.13,66.78
GND on IN3 (solid shape): 146.99,62.34 147.07,62.29 147.08,62.2 147.07,62.14 147.06,62.08 147.07,62.03 147.08,61.98 147.09,61.95 146.56,61.43 143.72,61.43 141.37,59.08 140.66,59.08 140.02,58.45 140.02,55.87 139.96,55.77 139.85,55.8 139.19,56.46 139.19,57.74 139.22,57.81 139.3,57.84 139.36,57.83 139.6,57.93 139.7,58.18 139.6,58.42 139.36,58.52 139.3,58.52 139.22,58.54 139.19,58.62 139.19,61.34 139.24,61.43 139.34,61.43 139.42,61.4 139.5,61.39 139.72,61.48 139.82,61.7 139.81,61.76 139.81,61.83 140.26,62.27 140.9,62.27 140.96,62.25 141,62.19 140.94,62.09 140.93,61.99 140.98,61.82 141.11,61.7 141.16,61.64 141.15,61.55 141.12,61.48 141.1,61.39 141.2,61.16 141.42,61.07 141.49,61.08 141.56,61.1 141.6,61.07 141.62,61.03 141.74,60.82 141.96,60.74 142.3,61.08 141.96,61.43 141.89,61.42 141.83,61.4 141.78,61.4 141.74,61.42 141.68,61.57 141.56,61.68 141.51,61.74 141.52,61.82 141.55,61.9 141.56,61.99 141.54,62.09 141.49,62.19 141.53,62.25 141.59,62.27 141.88,62.27 142.49,61.66 142.93,61.66 143.6,62.34
GND on IN3 (solid shape): 88.35,16.66 88.37,16.58 88.32,16.5 88.2,16.38 88.15,16.2 88.15,16.16 88.16,16.11 88.14,16.02 88.06,15.98 86.75,15.98 86.67,16.03 86.66,16.12 86.68,16.19 86.68,16.25 86.58,16.5 86.34,16.6 86.22,16.57 86.11,16.51 86.04,16.48 85.97,16.52 85.85,16.6 85.71,16.63 85.58,16.6 85.46,16.52 85.38,16.49 85.31,16.52 85.19,16.61 85.05,16.64 84.71,16.29 85.05,15.95 85.19,15.98 85.31,16.06 85.38,16.09 85.46,16.06 85.54,15.99 85.65,15.95 85.67,15.95 85.71,15.9 85.62,15.8 81.59,15.8 81.49,15.87 81.51,15.98 82.5,16.96 83.31,16.96 83.47,17.11 83.54,17.14 83.62,17.1 83.74,17.01 83.89,16.97 84.05,17.02 84.18,17.13 84.25,17.18 84.33,17.14 84.45,17.06 84.58,17.04 84.93,17.38 84.58,17.72 84.42,17.68 84.29,17.57 84.22,17.52 84.14,17.55 84.1,17.59 84.06,17.66 84.09,17.74 84.6,18.25 86.76,18.25
GND on IN3 (solid shape): outline of 171 points within 22.09,28.43 27.35,48.03
GND on IN3 (solid shape): outline of 96 points within 133.29,78.81 135.02,84.65
GND on IN3 (solid shape): outline of 238 points within 69.99,74.54 74.62,78.66
GND on IN3 (solid shape): outline of 91 points within 196.76,78.49 200.36,86.92
GND on IN3 (solid shape): outline of 271 points within 6.88,19.09 9.56,34.73
GND on IN3 (solid shape): outline of 85 points within 158.61,21.47 164.82,27.36
GND on IN3 (solid shape): outline of 271 points within 188.97,90.98 194.77,94.07
GND on IN3 (solid shape): outline of 123 points within 98.82,74.93 105.96,84.49
GND on IN3 (solid shape): outline of 314 points within 42.67,64.63 47.09,66.97
GND on IN3 (solid shape): outline of 308 points within 17.97,21.98 22.99,49.87
GND on IN3 (solid shape): outline of 325 points within 191.47,35.51 202.38,42.04
GND on IN3 (solid shape): outline of 129 points within 70.73,79.93 75.85,95.85
GND on IN3 (solid shape): outline of 354 points within 111.68,77.83 126.2,89.33
GND on IN3 (solid shape): outline of 396 points within 206.52,13.63 213.61,26.76
GND on IN3 (solid shape): outline of 416 points within 53.16,74.31 60.13,79.37
GND on IN3 (solid shape): outline of 430 points within 192.79,70.18 201.14,78.26
GND on IN3 (solid shape): outline of 411 points within 33.43,24.26 50.42,37.85
GND on IN3 (solid shape): outline of 461 points within 126.83,21.69 132.6,44.48
GND on IN3 (solid shape): outline of 173 points within 134.66,67.1 138.71,72.41
GND on IN3 (solid shape): outline of 458 points within 134.07,86.12 155.45,91.54
GND on IN3 (solid shape): outline of 562 points within 144.03,99.87 205.39,113.74
GND on IN3 (solid shape): outline of 594 points within 8.3,8.07 15.85,20.18
GND on IN3 (solid shape): outline of 716 points within 168.18,0.51 217.53,31.09
GND on IN3 (solid shape): outline of 686 points within 137.65,56.14 157.83,67.43
GND on IN3 (solid shape): outline of 770 points within 32.06,15.63 78.52,24.12
GND on IN3 (solid shape): outline of 884 points within 97.15,71.7 131.91,80.58
GND on IN3 (solid shape): outline of 967 points within 142.61,43.95 157.11,59.46
GND on IN3 (solid shape): outline of 978 points within 169.19,91.01 183.35,104.66
GND on IN3 (solid shape): outline of 973 points within 122.88,77.73 129.57,86.17
GND on IN3 (solid shape): outline of 1124 points within 82.83,21.4 98.54,32.38
GND on IN3 (solid shape): outline of 1106 points within 17.88,10.35 46.89,27.09
GND on IN3 (solid shape): outline of 1233 points within 103.65,21.43 122.13,45.78
GND on IN3 (solid shape): outline of 1495 points within 41.19,36.88 67.28,57.42
GND on IN3 (solid shape): outline of 1843 points within 137.8,21.66 160.14,37.64
GND on IN3 (solid shape): outline of 1892 points within 38.39,19.99 66.96,27.45
GND on IN3 (solid shape): outline of 2328 points within 195.74,42.37 216.83,79.31
GND on IN3 (solid shape): outline of 3034 points within 80.26,90.61 132.46,109.97
GND on IN3 (solid shape): outline of 3158 points within 186.75,68.94 218.33,119.74
GND on IN3 (solid shape): outline of 4443 points within 97.89,59.01 138.59,76.24
GND on IN3 (solid shape): outline of 8159 points within 0.51,0.51 165.6,113.89
GND on SGND1 (solid shape): outline of 4260 points within 0.51,0.51 218.33,119.74
VBUS_P on TOP (solid shape): 192.22,90.82 192.48,90.82 192.5,90.83 192.53,90.83 192.61,90.75 192.61,90.7 192.73,90.57 193.39,90.57 193.5,90.47 193.5,90.41 193.41,90.34 193.36,90.25 193.36,89.99 193.41,89.9 193.5,89.83 193.5,89.71 193.35,89.57 191.98,89.57 191.64,89.23 191.64,89.13 191.51,89 190.14,89 190.02,89.13 190.02,90.11 190.17,90.26 190.2,90.25 190.25,90.24 190.3,90.24 190.36,90.24 190.43,90.26 190.8,90.26 190.87,90.24 190.93,90.24 191,90.25 191.06,90.26 191.25,90.45 191.27,90.51 191.27,90.58 191.27,90.64 191.25,90.71 191.25,90.79 191.29,90.83 192.2,90.83
VBUS_P on BOTTOM (solid shape): 191.54,89.35 191.54,88.89 191.51,88.89 191.51,87.93 191.49,87.91 191.31,87.91 191.31,88.89 191.11,88.89 191.11,87.91 190.91,87.91 190.91,88.89 190.71,88.89 190.71,87.91 190.51,87.91 190.51,88.89 190.31,88.89 190.31,87.91 190.11,87.91 190.11,88.89 190.07,88.89 190.07,89.08 190.02,89.13 190.02,89.38 190.09,89.46 191.44,89.46
VCC3V3_FLASH on BOTTOM (solid shape): outline of 594 points within 176.13,57.3 189.41,64.31
VCCDSW_3P3 on BOTTOM (solid shape): 157.12,66.42 157.12,65.99 156.46,65.33 156.46,64.41 157.12,63.75 157.12,63.29 156.72,62.89 156.51,62.89 156.35,63.05 156.35,63.26 155.5,64.11 155.5,64.59 154.99,65.1 154.99,65.56 155.06,65.63 155.98,65.63 156.56,66.22 156.56,66.39 156.64,66.47 157.07,66.47
VCCDSW_3P3 on IN3 (solid shape): outline of 327 points within 137.64,68.2 144.54,70.71
VCCSTG_OVRD on TOP (solid shape): 138.74,99.59 138.74,99.41 138.67,99.3 138.65,99.18 138.75,98.92 139.01,98.81 139.16,98.84 139.28,98.93 139.29,98.95 139.37,98.95 139.37,98.87 139.38,98.86 139.38,97.53 139.45,97.49 139.48,97.42 139.48,96.95 138.76,96.23 138.76,95.68 138.72,95.65 138.72,95.49 138.27,95.04 137.59,95.04 137.46,95.17 137.46,95.59 137.46,95.63 138.21,96.37 138.21,98.68 138.02,98.86 138.02,99.46 138.22,99.67 138.66,99.67
2260_LX_1.35V on BOTTOM (solid shape): outline of 88 points within 24.46,81.25 32.69,88.14
8097_EN_2.5V on TOP (solid shape): 174.8,50.26 174.8,48.94 173.7,47.84 173.39,47.84 173.15,48.08 173.15,48.74 173.23,48.82 174.22,48.82 174.42,49.02 174.42,49.48 173.89,50.01 173.45,50.01 173.33,50.14 173.33,50.87 173.4,50.95 174.11,50.95
8097_LX_2.5V on BOTTOM (solid shape): 186,16.23 186,15.29 185.98,15.26 183.97,15.26 183.94,15.29 183.67,15.29 183.6,15.4 183.49,15.47 183.23,15.47 183.13,15.41 183.05,15.3 182.44,15.3 182.44,15.31 181.79,15.31 181.63,15.47 181.63,16.13 181.75,16.25 182.92,16.25 182.97,16.26 183.01,16.29 183.02,16.3 185.93,16.3
8097_VIN_2.5V on BOTTOM (solid shape): 179.96,16.05 180.03,15.94 180.14,15.86 180.4,15.86 180.51,15.94 180.59,16.05 180.59,16.1 180.87,16.1 181.52,15.45 181.52,15.42 181.75,15.2 181.78,15.2 181.79,15.19 182.89,15.19 183.05,15.03 183.05,15.02 183.12,14.92 183.23,14.85 183.49,14.85 183.58,14.9 183.65,14.98 184.48,14.98 184.63,14.83 184.63,14.55 185.01,14.17 185.01,13.64 184.91,13.54 184.25,13.54 183.98,13.8 183.82,13.8 183.78,13.83 183.74,13.83 182.79,13.83 182.79,13.84 182.61,13.84 182.52,13.89 182.52,13.99 182.55,14.06 182.56,14.15 182.45,14.4 182.19,14.51 182.04,14.48 181.92,14.39 181.91,14.37 181.84,14.37 181.83,14.39 181.7,14.48 181.56,14.51 181.45,14.49 181.35,14.44 181.33,14.43 181.28,14.44 181.26,14.48 181.26,14.54 181.23,14.62 181.15,14.65 180.92,14.65 180.32,14.65 180.31,14.65 179.14,14.65 178.74,15.06 178.74,15.97 178.86,16.1 179.96,16.1
8231_LG on TOP (solid shape): 103.68,15.9 103.68,13.65 103.65,13.62 103.63,13.62 103.63,13.42 103.63,12.65 103.58,12.6 103.45,12.6 103.36,12.68 103.36,12.75 103.35,12.76 103.35,12.88 102.41,13.82 102.41,15.92 102.13,16.2 101.67,16.2 100.35,17.52 100.35,17.78 100.51,17.93 101.65,17.93
8231_LG on BOTTOM (solid shape): 101.34,17.73 101.34,16.33 101.27,16.25 100.56,16.25 100.43,16.38 100.43,17.8 100.56,17.93 101.14,17.93
8231_PH on TOP (solid shape): 102.11,15.69 102.11,13.84 103.25,12.7 103.25,12.27 103.2,12.22 102.44,12.22 102.44,12.22 102.21,12.22 101.87,12.56 101.24,12.56 101.22,12.57 101.19,12.62 101.15,12.65 101.14,12.66 101.12,12.68 100.9,12.68 100.53,13.05 100.53,14.76 101.62,15.85 101.95,15.85
8231_PH on BOTTOM (solid shape): 104.6,16.63 104.6,13.33 104.29,13.03 97.03,13.03 96.82,13.23 96.82,15.87 96.97,16.01 101.52,16.01 102.24,16.74 104.49,16.74
8231_UG on BOTTOM (solid shape): 102.03,12.29 102.03,11.53 101.47,10.97 100.81,10.97 100.73,11.05 100.73,11.43 100.84,11.53 100.99,11.53 101.29,11.83 101.29,12.14 101.57,12.42 101.9,12.42
+BAT_DIS on BOTTOM (solid shape): outline of 132 points within 66.27,3.2 75.44,15.06
+BATCHG on TOP (solid shape): 78.03,16.68 82.27,16.68 82.47,16.47 82.47,13.44 82.23,13.19 80.71,13.19 80.54,13.03 78.69,13.03 78.55,13.16 78.55,14.2 78.17,14.58 78.16,14.58 78.14,14.6 77.58,14.6 77.3,14.31 77.28,14.31 77.21,14.3 77.13,14.28 76.8,14.28 76.72,14.3 76.65,14.31 76.58,14.3 76.5,14.28 76.06,14.28 75.93,14.28 75.78,14.28 75.61,14.11 75.61,14.1 75.25,13.74 71.91,13.74 69.24,11.07 69.24,10.72 68.93,10.41 67.3,10.41 67.12,10.59 67.12,12.99 67.69,13.56 69.49,13.56 70.23,14.3 70.23,17.02 70.61,17.4 77.32,17.4
+BATCHG on BOTTOM (solid shape): outline of 189 points within 72.24,12.16 78.53,17.96
+FB_PLLAVDD on BOTTOM (solid shape): 66.98,64.06 66.98,62.96 66.85,62.84 62.86,62.84 62.85,62.83 62.82,62.83 62.54,62.55 61.79,62.55 61.73,62.61 61.73,63.84 61.74,63.86 61.86,64 61.91,64.16 61.94,64.23 62.01,64.26 66.77,64.26
+FB_PLLAVDD on IN2 (solid shape): 62.72,82.23 63.04,82.23 63.11,82.16 63.11,81.51 62.94,81.34 62.94,77.84 62.37,77.27 61.71,77.27 61.34,77.64 61.33,77.68 61.33,77.72 61.33,77.75 61.34,77.82 61.34,78.02 61.5,78.18 61.72,78.18 61.92,78.38 61.92,79.19 62.42,79.69 62.42,79.97 61.94,80.45 61.94,81.23 61.75,81.42 61.55,81.42 61.39,81.58 61.39,82.18 61.59,82.39 62.56,82.39
+OLEDVDD on TOP (solid shape): 12.65,36.7 12.65,33.78 12.52,33.65 12.04,33.65 11.86,33.47 11.86,32.28 11.73,32.15 10.84,32.15 10.62,31.93 10.62,29.64 9.32,28.34 8.71,28.34 8.45,28.61 8.45,33 9.71,34.27 9.73,34.27 10.3,34.84 10.31,34.84 10.31,36.75 10.41,36.85 12.49,36.85
+OLEDVDD on BOTTOM (solid shape): 10.41,29.59 10.41,28.57 10.26,28.42 9.17,28.42 9.04,28.55 9.04,29.41 9.29,29.66 10.34,29.66
+OLEDVSS on TOP (solid shape): 13.16,31.7 13.16,27.73 13.03,27.61 12.62,27.61 12.55,27.68 11.25,27.68 10.67,27.1 9.68,27.1 9.5,26.92 9.5,26.01 9.32,25.83 8.68,25.83 8.48,26.03 8.48,27.23 9.23,27.98 9.24,27.98 10.87,29.6 10.87,31.82 11,31.95 12.9,31.95
+OLEDVSS on BOTTOM (solid shape): 9.42,27.05 10.23,27.05 10.31,26.97 10.31,26.13 10.23,26.06 9.65,26.06 9.52,25.93 9.01,25.93 8.81,26.13 8.81,26.87 9.07,27.12 9.35,27.12
+SMDDR_VREF_DIMM on TOP (solid shape): 158.57,21.03 158.57,20.39 158.37,20.19 157.81,20.19 157.66,20.34 154.38,20.34 154.33,20.39 154.33,20.76 154.33,20.77 154.33,21.11 154.38,21.16 156.12,21.16 156.23,21.16 156.39,21.16 156.56,21.33 156.56,21.74 156.61,21.79 157.81,21.79
+SMDDR_VREF_DQ0 on TOP (solid shape): 159.81,21.69 159.81,21.46 159.81,20.33 159.73,20.24 159.03,20.24 158.94,20.33 158.94,21.05 158.92,21.11 158.88,21.14 158.87,21.15 158.87,21.52 158.87,21.6 158.85,21.71 159.03,21.89 159.61,21.89
+SMDDR_VREF_DQ1 on TOP (solid shape): 110.49,21.41 110.49,20.7 110.39,20.6 109.19,20.6 108.86,20.93 108.86,21.18 109.17,21.49 110.41,21.49
+SPI_VCC on TOP (solid shape): 161.11,94.69 161.11,93.52 160.91,93.32 158.9,93.32 157.86,94.36 157.86,94.77 158.04,94.94 160.85,94.94
+SPI_VCC on TOP (solid shape): 162.49,60.37 162.49,59.61 162.5,59.61 162.53,59.58 162.53,59.56 162.69,59.4 162.69,59.39 162.79,59.29 162.79,58.65 162.71,58.57 162.23,58.57 161.95,58.29 161.16,58.29 161.08,58.37 161.08,59.89 161.57,60.38 162.09,60.38 162.13,60.38 162.16,60.4 162.46,60.4
+SPI_VCC on TOP (solid shape): 169.11,97.15 169.11,96.54 169.29,96.37 169.29,95.91 169.38,95.81 169.41,95.77 169.46,95.74 170.23,94.97 170.23,94.94 170.38,94.79 170.38,93.55 170.13,93.29 169.75,93.29 169.7,93.34 169.59,93.34 169.48,93.45 169.48,94.1 169.59,94.22 169.63,94.38 169.56,94.6 169.37,94.73 169.36,94.74 169.11,94.99 169.12,95.07 169.01,95.33 168.76,95.43 168.68,95.43 168.6,95.4 168.57,95.38 168.45,95.5 168.45,97.15 168.53,97.23 169.03,97.23
+SPI_VCC on TOP (solid shape): 164.44,69.06 164.44,68.56 164.42,68.53 164.39,68.51 164.08,68.31 164.11,67.94 164.12,67.86 164.07,67.79 163.92,67.66 163.87,67.47 163.87,67.45 163.76,67.35 163.74,67.34 163.49,67.24 163.38,66.99 163.38,66.97 163.27,66.85 163.27,66.32 163.32,66.27 163.49,66.27 163.54,66.26 163.58,66.25 163.61,66.26 163.66,66.27 164.36,66.27 164.49,66.14 164.49,65.96 164.44,65.92 163.86,65.92 163.83,65.9 163.81,65.9 163.54,65.88 163.37,65.68 163.36,65.62 163.35,65.56 163.39,65.41 163.49,65.27 163.5,65.25 163.5,65.12 163.49,65.12 163.49,64.43 163.48,64.42 163.29,64.42 163.27,64.44 163.27,65.14 163.25,65.16 163.15,65.16 162.84,65.48 162.84,66.59 162.88,66.63 162.88,67.17 162.88,67.18 162.91,67.25 162.92,67.33 162.92,67.4 162.93,67.42 162.94,67.44 163.53,68.03 163.53,68.4 163.66,68.53 163.66,68.94 163.84,69.11 163.86,69.13 163.88,69.13 164.37,69.13
+SPI_VCC on BOTTOM (solid shape): 169.64,95.45 169.64,94.97 169.49,94.81 169.29,94.81 169.11,94.99 169.12,95.07 169.01,95.33 168.76,95.43 168.6,95.4 168.47,95.3 166.9,95.3 166.7,95.1 161.24,95.1 161.24,95.09 161.18,95.09 161.01,94.92 161.01,94.56 160.74,94.29 157.33,94.29 157.28,94.34 157.27,94.37 157.24,94.43 157.24,95.27 157.39,95.41 160.59,95.41 160.78,95.6 166.47,95.6 166.7,95.83 169.26,95.83
+SPI_VCC on IN2 (solid shape): outline of 153 points within 163.85,66.27 167,69.67
+UIM_PWR on TOP (solid shape): 213.43,9.62 213.43,9.29 213.64,9.09 214.3,9.09 214.37,9.17 214.37,9.55 214.42,9.6 214.63,9.6 214.67,9.56 214.67,9.27 214.68,9.26 214.68,8.91 214.5,8.74 211.94,8.74 211.86,8.66 211.86,8.13 211.73,8 210.77,8 210.67,8.1 210.67,9.07 210.79,9.19 211.02,9.19 211.3,9.06 211.58,9.19 212.06,9.19 212.14,9.12 212.24,9.09 212.52,9.09 212.63,9.12 212.71,9.19 212.75,9.19 212.88,9.32 212.88,9.62 212.98,9.73 213.33,9.73
+UIM_PWR on BOTTOM (solid shape): 211.33,9.07 211.33,8.13 211.2,8 210.92,8 210.08,7.16 210.08,3.93 208.68,2.54 208.1,2.54 207.92,2.72 207.92,3.05 208.25,3.37 208.46,3.47 208.56,3.69 208.96,4.09 208.96,7.8 209.73,8.56 210.08,8.56 210.28,8.76 210.28,8.91 210.67,9.29 211.1,9.29
+UIM_PWR on IN1 (solid shape): outline of 308 points within 206.42,7.95 213.59,25.5
+VAC on BOTTOM (solid shape): outline of 96 points within 149.68,99.69 163.14,104.59
+VAC_IN on TOP (solid shape): 151.95,99.69 151.95,99.24 152.18,99.01 152.35,99.01 152.47,98.88 152.47,98.58 152.27,98.37 151.99,98.37 151.78,98.16 151.78,97.76 151.69,97.68 148.1,97.68 147.95,97.53 147.37,97.53 147.31,97.6 147.31,97.75 147.22,97.84 147.22,98.65 147.35,98.78 147.35,99.57 147.42,99.64 150.14,99.64 150.21,99.72 150.21,99.84 150.32,99.94 151.7,99.94
+VAC_IN on BOTTOM (solid shape): 149.43,101.04 149.43,100.78 149.73,100.48 153.19,100.48 153.24,100.43 153.24,99.31 153.11,99.18 152.83,99.18 152.45,98.8 152.45,98.47 152.4,98.42 151.11,98.42 151.03,98.34 151.03,97.75 150.92,97.64 150.5,97.64 150.44,97.58 147.37,97.58 147.14,97.81 147.14,98.73 147.28,98.86 147.28,99.39 147.44,99.55 147.44,100.06 147.53,100.13 147.59,100.22 147.59,100.48 147.51,100.59 147.4,100.67 147.14,100.67 147.1,100.64 147.03,100.64 147.03,100.98 147.05,101 147.05,101.2 147.14,101.29 149.17,101.29
+VLVSS on TOP (solid shape): 17.93,31.78 17.93,28.01 17.69,27.78 16.03,27.78 15.77,28.04 15.77,31.8 15.92,31.95 17.75,31.95
AOZ5507_PHASE1 on BOTTOM (solid shape): 96.52,110.88 96.52,108.94 95.71,108.13 95.15,108.13 95.14,108.14 95.14,109.1 95.41,109.38 95.41,110.83 95.59,111.01 96.39,111.01
AOZ5507_PHASE2 on BOTTOM (solid shape): 107.74,111.3 107.74,110.18 108.26,109.66 108.26,108.56 108.16,108.46 107.45,108.46 107.41,108.5 107.41,109.05 107.41,109.05 107.41,109.45 107.03,109.83 107.03,110.27 106.79,110.51 106.79,111.29 106.9,111.41 107.63,111.41
AOZ5507_SW1 on TOP (solid shape): 96.09,103.2 96.09,101.97 95.73,101.61 95.01,101.61 94.8,101.82 94.8,103.23 94.82,103.26 96.03,103.26
AOZ5507_SW1 on BOTTOM (solid shape): 95.48,104.15 95.48,103.81 96.08,103.21 96.08,100.09 96.04,100.05 96.04,99.81 96.02,99.78 95.93,99.72 95.9,99.65 95.9,97.73 95.79,97.62 93.64,97.62 93.6,97.66 93.6,102.72 93.04,103.27 93.04,104.12 93.26,104.34 95.29,104.34
AOZ5507_SW2 on TOP (solid shape): 107.57,103.42 107.57,102.4 107.23,102.05 106.58,102.05 106.17,101.65 105.28,101.65 105.05,101.88 105.05,103.45 105.2,103.6 107.39,103.6
AOZ5507_SW2 on BOTTOM (solid shape): 110.63,101.56 111.1,101.56 111.35,101.31 111.35,97.78 111.25,97.67 109.36,97.67 109.05,97.99 109.05,99.23 109.07,99.26 109.07,99.3 109.07,99.68 109.07,99.72 109.05,99.75 109.05,100.69 108.75,100.99 108.28,100.99 105.35,103.92 105.35,104.47 105.53,104.66 107.53,104.66
BATT+ on TOP (solid shape): 84.26,12.55 84.26,9.58 83.26,8.58 77.98,8.58 77.67,8.89 77.67,12.13 78.19,12.66 80.83,12.66 81.15,12.98 83.84,12.98
BATT+ on BOTTOM (solid shape): 80.68,15.57 80.68,15.05 81.23,14.49 83.91,14.49 84.17,14.23 84.17,12.42 84.3,12.29 84.3,10.82 83.84,10.36 80.74,10.36 80.28,10.82 80.28,10.84 79.89,11.24 79.89,15.59 80.05,15.75 80.5,15.75
BQHIDRV on BOTTOM (solid shape): 62.48,10.39 62.48,9.9 62.43,9.85 61.77,9.85 60.58,8.66 60.58,6.65 60.42,6.5 60.2,6.5 60.04,6.65 60.04,8.99 61.52,10.46 62.41,10.46
BQLODRV on BOTTOM (solid shape): 63.62,8.89 63.62,8.48 63.54,8.39 62.24,8.39 62.08,8.56 62.08,8.86 62.28,9.07 63.45,9.07
BQPHASE on TOP (solid shape): 66.83,6.86 66.83,5.61 66.7,5.48 66.34,5.48 66.22,5.61 66.22,6.27 65.86,6.63 64.13,6.63 64.01,6.75 64.01,7.24 64.18,7.41 66.27,7.41
BQPHASE on BOTTOM (solid shape): 65.35,9.57 66.85,9.57 67.29,9.13 67.29,8.58 67.4,8.32 67.66,8.21 68.85,8.21 69.54,7.52 69.54,3.96 69.26,3.68 66.57,3.68 63.85,6.4 63.85,9.04 63.68,9.22 62.2,9.22 61.26,8.28 61.26,6.6 61.16,6.5 60.75,6.5 60.7,6.55 60.7,8.62 61.78,9.7 62.48,9.7 62.61,9.83 62.61,10.44 62.69,10.51 64.41,10.51
DDR_VTT on TOP (solid shape): 118.84,17.12 118.84,14.98 118.77,14.91 117.83,14.91 117.7,15.03 117.7,16.02 117.14,16.58 117.14,17.04 117.42,17.32 118.64,17.32
DDR_VTT on TOP (solid shape): 184.02,22.43 184.02,18.18 183.87,18.03 182.41,18.03 182.23,18.22 181.88,18.22 181.55,18.54 181.55,18.89 182.89,20.23 182.89,22.24 183.21,22.55 183.89,22.55
DDR_VTT on TOP (solid shape): 106.32,24.33 106.59,23.66 107.26,23.39 107.64,23.39 108.51,24.25 109.17,24.25 109.32,24.1 109.32,23.47 108.71,22.86 108.71,22.58 108.18,22.04 108.18,21.71 108.05,21.59 107.64,21.59 107.16,22.07 106.5,22.07 105.89,21.46 105.18,21.46 104.87,21.77 104.87,24.46 105,24.58 105.18,24.58 105.18,24.58 106.06,24.58
DDR_VTT on TOP (solid shape): 96.38,17.4 96.38,17.39 96.48,17.26 96.63,17.18 96.64,17.18 96.7,17.12 97.08,17.12 98.45,15.75 98.45,15.62 98.83,15.24 98.83,13.6 98.6,13.37 98.6,12.84 98.83,12.61 98.83,11.55 99.05,11.33 99.05,10.94 99.38,10.61 100.1,10.61 100.11,10.58 100.14,10.54 100.17,10.51 100.17,10.41 100.16,10.39 100.1,10.28 100.07,10.16 100.18,9.91 100.43,9.8 100.6,9.85 100.73,9.97 100.82,10.02 100.9,9.97 101.03,9.85 101.21,9.8 101.46,9.91 101.56,10.16 101.55,10.25 101.52,10.34 101.52,10.39 101.56,10.41 101.6,10.41 102.01,10.82 102.43,10.82 103.23,10.82 103.29,10.76 103.29,9.42 103.43,9.29 103.66,9.29 103.74,9.36 103.74,9.43 103.83,9.43 103.83,10.47 103.89,10.53 103.98,10.53 104.03,10.48 104.03,9.43 104.06,9.4 104.06,9.3 103.64,8.88 103.26,8.88 103.15,8.9 103.05,8.91 102.94,8.9 102.83,8.88 100.9,8.88 100.28,8.25 98.72,8.25 97.38,9.59 97.38,15.03 96.64,15.77 96.24,15.77 95.5,16.51 95.5,17.12 95.86,17.47 96.31,17.47
DDR_VTT on BOTTOM (solid shape): 183.16,19.03 183.16,18.62 182.8,18.26 181.4,18.26 181.25,18.41 181.25,19 181.43,19.17 183.01,19.17
DDR_VTT on BOTTOM (solid shape): 106.45,22.76 106.45,22.17 106.17,21.89 106.16,21.89 106.07,21.82 106,21.72 105.99,21.71 105.84,21.56 105.84,19.33 105.83,19.29 105.79,19.28 105.64,19.28 105.58,19.34 105.59,19.34 105.59,21.52 105.48,21.63 105.46,21.69 105.43,21.75 105.43,22.96 105.64,23.16 106.04,23.16
DDR_VTT on IN1 (solid shape): outline of 2203 points within 95.48,15.62 182.9,20.25
DDR_VTT on IN2 (solid shape): outline of 284 points within 105.65,15.61 118.6,23.19
DP_RCOMP on BOTTOM (solid shape): 111.45,89.56 111.45,88.44 110.54,87.53 110.54,86.54 110.11,86.1 109.9,86.1 109.81,86.2 109.81,86.57 110.01,86.76 110.01,87.74 110.7,88.44 110.7,88.45 110.82,88.57 110.82,88.97 110.86,89.05 110.88,89.15 110.88,89.34 110.82,89.4 110.82,89.51 110.92,89.61 111.4,89.61
FBVDDQ_GPU on TOP (solid shape): 34.62,80.72 34.62,80.46 33.31,79.16 32.57,79.16 31.87,79.86 31.87,82.09 31.95,82.17 33.17,82.17
FBVDDQ_GPU on TOP (solid shape): 62.85,81.51 62.85,81.07 62.52,80.74 62.52,78.98 62.41,78.86 62.02,78.86 61.92,78.97 61.92,79.58 61.8,79.7 61.6,79.7 61.56,79.7 61.29,79.7 61.19,79.8 61.19,81.1 61.35,81.26 61.87,81.26 62.03,81.1 62.07,81.05 62.13,81.03 62.33,81.03 62.41,81.06 62.44,81.13 62.45,81.16 62.45,81.52 62.46,81.55 62.5,81.57 62.79,81.57
FBVDDQ_GPU on TOP (solid shape): outline of 181 points within 60.32,72.51 62.86,76.02
FBVDDQ_GPU on TOP (solid shape): outline of 1222 points within 61.01,81.93 69.24,87.53
FBVDDQ_GPU on TOP (solid shape): outline of 1242 points within 28.24,54.25 60.6,67.49
FBVDDQ_GPU on BOTTOM (solid shape): outline of 238 points within 60.95,72.44 69.05,84.06
FBVDDQ_GPU on IN1 (solid shape): outline of 1345 points within 31.39,77.11 68.68,85.6
FBVDDQ_GPU on IN3 (solid shape): outline of 6505 points within 29.79,54.07 69.9,86.84
FBVDDQ_MEM on TOP (solid shape): 55.07,92.81 55.07,92.35 54.99,92.28 54.35,92.28 54.1,92.53 51.86,92.53 51.2,93.19 51.2,94.11 48.87,96.45 48.87,97.18 49.44,97.75 49.82,97.75 49.83,97.76 50.11,97.76
FBVDDQ_MEM on TOP (solid shape): 42.43,67.76 42.41,67.62 42.45,67.47 42.49,67.42 42.54,67.37 42.58,67.29 42.54,67.21 42.42,67.08 42.37,66.9 42.37,66.85 42.43,66.7 42.54,66.59 42.59,66.5 42.55,66.41 42.38,66.04 42.65,65.74 42.67,65.74 42.69,65.72 42.7,65.69 42.69,65.65 42.68,65.64 42.58,65.61 42.49,65.61 41.96,65.07 41.94,65.06 41.88,65.06 41.59,65.06 41.22,65.43 41.22,67.76 41.41,67.95 42.24,67.95
FBVDDQ_MEM on TOP (solid shape): outline of 489 points within 42.86,65.02 46.78,69.49
FBVDDQ_MEM on TOP (solid shape): outline of 822 points within 41.16,89.46 47.72,94.47
FBVDDQ_MEM on TOP (solid shape): outline of 3595 points within 28.44,61.79 49.31,97.37
FBVDDQ_MEM on BOTTOM (solid shape): 37.97,69.9 38.05,69.86 38.07,69.77 38.06,69.74 38.06,69.7 38.12,69.53 38.27,69.43 38.28,69.43 38.39,69.31 38.4,69.29 38.39,69.23 38.38,69.19 38.34,69.18 38.17,69.12 38.07,68.97 38.06,68.95 37.92,68.81 37.91,68.81 37.71,68.7 37.64,68.48 37.61,68.41 37.54,68.38 37.35,68.3 37.26,68.12 37.26,68.1 37.23,68.07 37.21,68.07 37.15,68.07 36.92,67.97 36.82,67.74 36.83,67.7 36.8,67.62 36.73,67.58 36.72,67.58 36.68,67.6 36.67,67.64 36.67,67.7 36.57,67.93 36.34,68.03 36.28,68.03 36.26,68.03 36.23,68.06 36.22,68.07 36.22,68.12 36.24,68.16 36.28,68.18 36.34,68.17 36.57,68.27 36.67,68.5 36.67,68.55 36.67,68.57 36.68,68.59 36.71,68.62 36.74,68.62 36.94,68.7 37.02,68.9 37.02,68.93 37.05,69.01 37.12,69.04 37.14,69.04 37.36,69.12 37.47,69.33 37.5,69.39 37.56,69.42 37.75,69.51 37.82,69.7 37.81,69.76 37.82,69.78 37.94,69.9

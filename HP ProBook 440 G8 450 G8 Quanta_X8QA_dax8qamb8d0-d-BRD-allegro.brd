# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Nets (continued)
GND: C500.1 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.1 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.1 C734.2 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C749.2 C750.2 C751.2 C752.2 C753.2 C754.2 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C773.2 C800.1 C1100.2 C1101.1 C1400.2 C1401.2 C1402.2 C1403.1 C1404.1 C1405.1 C1406.1 C1500.2 C1501.1 C1502.2 C1503.1 C1504.1 C1600.2 C1601.2 C1602.2 C1603.2 C1604.2 C1605.2 C1606.2 C1607.2 C1608.2 C1609.1 C1610.1 C1611.2 C1612.2 C1613.2 C1614.2 C1615.2 C1616.2 C1617.2 C1618.2 C1619.2 C1620.2 C1621.2 C1622.2 C1623.2 C1624.2 C1625.2 C1626.2 C1627.2 C1628.2 C1629.2 C1630.2 C1631.2 C1632.2 C1633.2 C1634.2 C1635.2 C1636.2 C1637.2 C1638.1 C1639.2 C1640.2 C1641.1 C1642.2 C1643.2 C1644.1 C1645.2 C1646.1 C1647.2 C1648.1 C1649.1 C1650.1 C1651.1 C1652.1 C1653.2 C1654.2 C1655.2 C1656.2 C1700.1 C1701.2 C1702.1 C1703.2 C1704.2 C1705.2 C1706.2 C1707.2 C1708.2 C1709.2 C1710.2 C1711.2 C1712.2 C1713.2 C1714.2 C1715.2 C1716.2 C1717.2 C1718.2 C1719.2 C1720.2 C1721.2 C1722.2 C1723.2 C1724.2 C1725.2 C1726.2 C1727.2 C1800.2 C1801.2 C1802.2 C1803.2 C1808.2 C1809.2 C1810.2 C1815.2 C1816.2 C1900.2 C1902.2 C1906.2 C1907.2 C1908.2 C1912.2 C1914.2 C1915.2 C1916.2 C2000.2 C2001.2 C2002.2 C2008.2 C2009.2 C2010.2 C2011.2 C2016.2 C2018.2 C2800.1 C2801.2 C2802.2 C2803.2 C2804.2 C2805.2 C2806.2 C2807.2 C2808.2 C2809.2 C2810.2 C2811.2 C2812.2 C2813.2 C2814.2 C2815.2 C2816.2 C2817.2 C2818.2 C2819.2 C2821.2 C2822.2 C2823.2 C2824.2 C2825.2 C2826.2 C2827.2 C2900.1 C2901.2 C2903.2 C2904.2 C2905.2 C2907.2 C2908.2 C2909.2 C2910.2 C2911.2 C2912.2 C2913.2 C2914.2 C2915.2 C2916.2 C2917.2 C2918.2 C2919.2 C2920.2 C2921.2 C2922.2 C2923.2 C2924.2 C2925.2 C2926.2 C2927.2 C3300.1 C3400.2 C3401.1 C3403.2 C3404.2 C3405.2 C3406.2 C3407.1 C3408.1 C3410.2 C3412.2 C3413.1 C3414.2 C3416.2 C3420.1 C3421.2 C3422.1 C3423.2 C3425.2 C3426.2 C3427.2 C3500.2 C3501.2 C3502.2 C3503.2 C3504.2 C3525.2 C3526.2 C3527.2 C3528.2 C3529.2 C3530.2 C3531.2 C3600.1 C3602.1 C3609.1 C3610.2 C3611.1 C3612.2 C3614.1 C3615.2 C3617.1 C3618.1 C3619.2 C3620.1 C3621.2 C3622.1 C3623.1 C3624.2 C3625.1 C3626.1 C3627.1 C3628.1 C4100.2 C4101.2 C4103.1 C4109.2 C4110.1 C4111.2 C4112.1 C4113.1 C4114.2 C4200.2 C4203.2 C4204.2 C4205.2 C4206.2 C4207.1 C4208.2 C4209.2 C4210.1 C4211.2 C4212.1 C4213.2 C4214.1 C4215.1 C4216.1 C4217.1 C4218.1 C4219.1 C4300.1 C4301.1 C4302.1 C4303.1 C4313.1 C4314.1 C4315.1 C4400.2 C4401.2 C4402.2 C4403.1 C4405.2 C4406.2 C4700.2 C4701.2 C4702.2 C4703.2 C4704.2 C4705.1 C4706.2 C4707.1 C4712.2 C4713.2 C4714.2 C4715.2 C4716.1 C4717.1 C4718.1 C4719.1 C4722.1 C4800.1 C4801.1 C4802.1 C4804.2 C4805.1 C4806.2 C4807.2 C4808.1 C5000.2 C5001.2 C5029.1 C5031.2 C5034.1 C5045.1 C5100.2 C5107.2 C5108.1 C5109.1 C5110.1 C5111.1 C5112.1 C5201.2 C5202.3 C5203.3 C5204.2 C5205.2 C5206.2 C5207.2 C5208.2 C5209.2 C5210.2 C5400.2 C5401.1 C5402.2 C5403.2 C5404.2 C5405.1 C5406.2 C5410.2 C5412.2 C5600.2 C5601.1 C5604.2 C5605.2 C5606.1 C5916.1 C5917.1 C5918.1 C5919.2 C5920.2 C5921.2 C5922.2 C5923.1 C5924.1 C5925.1 C5926.1 C5927.1 C5928.1 C5929.1 C5930.1 C5931.1 C5932.1 C5933.1 C5934.1 C5935.1 C5936.2 C5937.2 C5938.2 C5939.1 C5940.1 C5941.1 C6100.1 C6101.1 C6102.2 C6103.1 C6104.2 C6105.2 C6106.1 C6107.1 C6108.1 C6109.2 C6112.1 C6113.1 C6200.2 C6201.2 C6202.2 C6203.2 C6204.1 C6205.1 C6210.3 C6211.3 C6212.2 C6213.2 C6214.1 C6215.1 C6216.1 C6217.2 C6306.2 C6600.1 C6601.1 C6602.1 C6603.2 C6604.2 C6605.1 C6606.2 C6607.1 C6608.1 C6612.2 C6613.1 C6614.1 C6615.2 C6616.1 C6617.1 C6619.1 C6620.1 C6621.2 C6622.1 C6623.1 C6624.1 C6626.1 C6628.2 C6630.2 C6631.1 C6632.1 C6633.1 C6635.1 C6636.1 C6637.1 C6638.1 C6639.1 C6641.1 C6642.2 C6644.1 C6645.2 C6646.2 C6647.1 C6648.2 C6649.1 C6650.2 C6651.2 C6653.2 C6654.2 C6662.1 C6663.1 C6664.1 C6665.2 C6666.1 C6667.2 C6668.1 C6669.2 C6670.1 C6671.1 C6672.1 C6673.2 C6674.1 C6675.1 C6676.2 C6677.1 C6678.2 C6680.1 C6682.1 C6683.2 C6684.1 C6686.1 C6687.2 C6688.2 C6689.2 C6693.1 C6697.2 C6698.2 C6699.2 C6700.1 C6701.1 C6702.1 C6703.1 C6704.1 C6705.1 C6706.1 C6707.1 C6708.1 C6709.1 C6710.1 C6711.1 C6712.1 C6713.1 C6714.1 C6715.2 C6716.1 C6717.1 C6718.2 C6719.1 C6800.1 C6802.1 C6803.1 C6806.1 C6807.1 C6808.2 C6809.2 C6810.2 C6818.2 C6900.1 C6901.2 C6902.2 C7000.1 C7001.1 C7002.1 C7003.1 C7004.1 C7005.1 C7006.1 C7007.1 C7008.1 C7009.1 C7010.1 C7011.1 C7012.1 C7013.1 C7014.1 C7015.1 C7016.1 C7017.1 C7018.1 C7019.1 C7020.1 C7021.1 C7022.2 C7023.2 C7024.2 C7025.2 C7026.2 C7027.2 C7028.2 C7029.1 C7030.1 C7031.1 C7032.1 C7033.1 C7034.1 C7035.1 C7036.1 C7037.1 C7038.1 C7039.1 C7040.1 C7041.1 C7042.1 C7043.2 C7044.2 C7045.2 C7046.2 C7047.2 C7048.2 C7049.2 C7050.2 C7051.2 C7052.2 C7053.2 C7054.2 C7055.2 C7056.2 C7057.2 C7058.2 C7059.2 C7060.2 C7061.2 C7200.1 C7201.1 C7202.1 C7203.1 C7204.1 C7205.1 C7206.1 C7207.1 C7208.1 C7209.1 C7210.1 C7215.2 C7216.1 C7217.2 C7218.2 C7219.1 C7220.1 C7221.2 C7222.2 C7223.1 C7224.1 C7225.1 C7226.1 C7227.1 C7228.1 C7229.1 C7230.1 C7231.1 C7232.1 C7233.1 C7234.1 C7236.1 C7237.2 C7238.1 C7239.2 C7600.1 C7601.2 C7602.2 C7603.2 C7606.2 C7607.2 C7608.2 C7609.2 C7610.2 C7611.1 C7612.2 C7613.1 C7614.2 C7615.1 C7616.2 C7617.2 C7618.1 C7619.1 C7700.2 C7701.1 C7730.1 C7731.1 C7732.2 C7733.1 C7734.2 C7735.1 C7736.1 C7737.1 C7738.2 C7739.1 C7740.2 C7741.1 C7742.1 C7743.1 C7744.2 C7745.1 C7746.2 C7747.1 C7748.1 C7749.2 C7750.1 C7751.1 C7752.1 C7753.1 C7754.1 C7755.1 C7756.1 C7757.1 C7758.1 C7759.1 C7760.1 C7761.1 C7762.1 C7763.1 C7764.1 C7765.2 C7766.1 C7767.2 C7768.2 CON1900.5 CON1900.6 CON1900.11 CON1900.12 CON3400.15 CON3400.18 CON3400.30 CON3400.34 CON3400.37 CON3400.41 CON3400.42 CON3401.7 CON3401.8 CON3501.2 CON3501.5 CON3501.8 CON3501.11 CON3501.17 CON3501.20 CON3501.21 CON3501.22 CON3501.23 CON3601.5 CON3601.6 CON4100.1 CON4100.7 CON4100.13 CON4100.18 CON4100.19 CON4100.33 CON4100.39 CON4100.45 CON4100.51 CON4100.57 CON4100.63 CON4100.69 CON4100.75 CON4100.76 CON4100.77 CON4202.3 CON4202.5 CON4202.11 CON4202.27 CON4202.33 CON4202.39 CON4202.45 CON4202.51 CON4202.57 CON4202.71 CON4202.73 CON4202.76 CON4202.77 CON4203.4 CON4203.5 CON4203.6 CON4204.5 CON4204.8 CON4204.9 CON4204.10 CON4204.11 CON4300.1 CON4300.3 CON4300.9 CON4300.15 CON4300.21 CON4300.27 CON4300.33 CON4300.39 CON4300.45 CON4300.51 CON4300.57 CON4300.71 CON4300.73 CON4300.76 CON4300.77 CON4400.4 CON4400.7 CON4400.8 CON4400.9 CON4400.10 CON4402.7 CON4402.14 CON4402.16 CON4402.17 CON4700.2 CON4700.3 CON4700.4 CON5000.2 CON5000.10 CON5000.43 CON5000.44 CON5002.7 CON5002.8 CON5002.9 CON5002.10 CON5200.5 CON5200.9 CON5200.10 CON5202.5 CON5202.9 CON5202.10 CON5400.1 CON5400.5 CON5400.6 CON6201.4 CON6201.7 CON6201.10 CON6201.11 CON6201.12 CON6201.13 CON6202.4 CON6202.7 CON6202.10 CON6202.11 CON6202.12 CON6202.13 CON6300.1 CON6300.2 CON6300.3 CON6300.4 CON6300.5 CON6300.6 CON6300.7 CON6300.8 CON6300.A1 CON6300.A12 CON6300.B1 CON6300.B12 CON7600.6(VSS) CON7600.10 CON7600.11 CON7600.12 CON7600.13 CON7600.14 CON7602.11 CON7602.14 CON7602.17 CON7602.20 CON7602.23 CON7602.26 CON7602.41 CON7602.42 CON7603.3 CON7603.4 CON7603.7 CON7603.8 CON7700.8 CON7700.10 CON7700.12 CON7700.14 CON7700.19 CON7700.20 CON7701.1 CON7701.5 CON7701.9 CON7701.16 CON7701.17(PAD_17) CON7702.3 CON7702.23 CON7702.24 CON7702.31 CON7702.32 CON7702.33 CON7702.34 CON7702.35 CON7703.2 CON7703.6 CON7703.7 CON7703.8 CON7703.13 CON7703.14 CON7703.19 CON7703.20 CON7703.25 CON7703.26 CON7703.31 CON7703.32 CON7703.37 CON7703.38 CON7703.49 CON7703.50 CON7703.59 CON7704.4 CON7704.5 CON7704.9 CON7704.10 D3700.1 D3701.2 D3702.2 D3703.2 D4203.1 D4204.1 D4205.1 D4206.1 D5900.2 D5901.2 D5902.2 D5903.2 D5904.2 D5905.2 D5906.2 D5907.2 D6300.2 D6306.2 D6307.2 D6309.2 D6310.2 D6313.3 D6314.3 EC1.2 EC2.2 EC3.2 EC4.2 EC5.2 EC2800.2 EC2802.2 EC2803.2 EC2900.2 EC2901.2 EC2902.2 EC2903.2 EC3600.1 EC3601.1 EC3602.2 EC3603.2 EC3604.1 EC3605.2 EC3606.2 EC3607.2 EC3700.2 EC3701.2 EC3702.2 EC3703.2 EC3704.2 EC4301.1 H7900.1(GND) H7901.1(GND) H7902.1(GND) H7903.1(GND) H7904.1(GND) H7905.1(GND) H7906.1(GND) H7907.1(GND) H7908.1(GND) H7909.1(GND) H7910.1(GND) H7911.1(GND) H7912.1(GND) H7913.1(GND) H7915.1(GND) H7916.1(GND) H7921.1(GND) H7922.1(GND) H7923.1(GND) H7924.1(GND) JDIM2800.1 JDIM2800.2 JDIM2800.5 JDIM2800.6 JDIM2800.9 JDIM2800.10 JDIM2800.14 JDIM2800.15 JDIM2800.18 JDIM2800.19 JDIM2800.22 JDIM2800.23 JDIM2800.26 JDIM2800.27 JDIM2800.30 JDIM2800.31 JDIM2800.35 JDIM2800.36 JDIM2800.39 JDIM2800.40 JDIM2800.43 JDIM2800.44 JDIM2800.47 JDIM2800.48 JDIM2800.51 JDIM2800.52 JDIM2800.56 JDIM2800.57 JDIM2800.60 JDIM2800.61 JDIM2800.64 JDIM2800.65 JDIM2800.68 JDIM2800.69 JDIM2800.72 JDIM2800.73 JDIM2800.77 JDIM2800.78 JDIM2800.81 JDIM2800.82 JDIM2800.85 JDIM2800.86 JDIM2800.89 JDIM2800.90 JDIM2800.93 JDIM2800.94 JDIM2800.98 JDIM2800.99 JDIM2800.102 JDIM2800.103 JDIM2800.106 JDIM2800.107 JDIM2800.167 JDIM2800.168 JDIM2800.171 JDIM2800.172 JDIM2800.175 JDIM2800.176 JDIM2800.180 JDIM2800.181 JDIM2800.184 JDIM2800.185 JDIM2800.188 JDIM2800.189 JDIM2800.192 JDIM2800.193 JDIM2800.196 JDIM2800.197 JDIM2800.201 JDIM2800.202 JDIM2800.205 JDIM2800.206 JDIM2800.209 JDIM2800.210 JDIM2800.213 JDIM2800.214 JDIM2800.217 JDIM2800.218 JDIM2800.222 JDIM2800.223 JDIM2800.226 JDIM2800.227 JDIM2800.230 JDIM2800.231 JDIM2800.234 JDIM2800.235 JDIM2800.238 JDIM2800.239 JDIM2800.243 JDIM2800.244 JDIM2800.247 JDIM2800.248 JDIM2800.251 JDIM2800.252 JDIM2800.261 JDIM2800.262 JDIM2900.1 JDIM2900.2 JDIM2900.5 JDIM2900.6 JDIM2900.9 JDIM2900.10 JDIM2900.14 JDIM2900.15 JDIM2900.18 JDIM2900.19 JDIM2900.22 JDIM2900.23 JDIM2900.26 JDIM2900.27 JDIM2900.30 JDIM2900.31 JDIM2900.35 JDIM2900.36 JDIM2900.39 JDIM2900.40 JDIM2900.43 JDIM2900.44 JDIM2900.47 JDIM2900.48 JDIM2900.51 JDIM2900.52 JDIM2900.56 JDIM2900.57 JDIM2900.60 JDIM2900.61 JDIM2900.64 JDIM2900.65 JDIM2900.68 JDIM2900.69 JDIM2900.72 JDIM2900.73 JDIM2900.77 JDIM2900.78 JDIM2900.81 JDIM2900.82 JDIM2900.85 JDIM2900.86 JDIM2900.89 JDIM2900.90 JDIM2900.93 JDIM2900.94 JDIM2900.98 JDIM2900.99 JDIM2900.102 JDIM2900.103 JDIM2900.106 JDIM2900.107 JDIM2900.167 JDIM2900.168 JDIM2900.171 JDIM2900.172 JDIM2900.175 JDIM2900.176 JDIM2900.180 JDIM2900.181 JDIM2900.184 JDIM2900.185 JDIM2900.188 JDIM2900.189 JDIM2900.192 JDIM2900.193 JDIM2900.196 JDIM2900.197 JDIM2900.201 JDIM2900.202 JDIM2900.205 JDIM2900.206 JDIM2900.209 JDIM2900.210 JDIM2900.213 JDIM2900.214 JDIM2900.217 JDIM2900.218 JDIM2900.222 JDIM2900.223 JDIM2900.226 JDIM2900.227 JDIM2900.230 JDIM2900.231 JDIM2900.234 JDIM2900.235 JDIM2900.238 JDIM2900.239 JDIM2900.243 JDIM2900.244 JDIM2900.247 JDIM2900.248 JDIM2900.251 JDIM2900.252 JDIM2900.261 JDIM2900.262 PC8000.2 PC8001.2 PC8004.2 PC8005.2 PC8100.2 PC8101.1 PC8102.1 PC8103.1 PC8104.1 PC8105.2 PC8106.1 PC8107.1 PC8108.1 PC8109.2 PC8201.1 PC8202.2 PC8203.1 PC8205.2 PC8206.2 PC8207.2 PC8208.2 PC8209.1 PC8210.2 PC8211.2 PC8213.2 PC8214.2 PC8215.2 PC8216.2 PC8217.2 PC8218.2 PC8219.2 PC8220.2 PC8222.2 PC8223.2 PC8224.2 PC8225.1 PC8226.2 PC8227.1 PC8400.1 PC8401.1 PC8402.1 PC8403.1 PC8404.1 PC8405.1 PC8406.2 PC8407.2 PC8408.1 PC8409.1 PC8410.1 PC8411.2 PC8600.2 PC8601.2 PC8602.1 PC8603.1 PC8604.1 PC8605.2 PC8606.1 PC8607.1 PC8608.1 PC8610.2 PC8611.2 PC8612.2 PC8613.2 PC8614.2 PC8615.2 PC8616.2 PC8618.2 PC8619.2 PC8620.1 PC8621.1 PC8622.1 PC8623.1 PC8624.1 PC8625.1 PC8626.1 PC8627.1 PC8629.2 PC8630.2 PC8631.2 PC8632.2 PC8633.2 PC8634.1 PC8636.2 PC8637.2 PC8638.2 PC8700.2 PC8701.2 PC8702.2 PC8703.2 PC8704.2 PC8705.2 PC8706.1 PC8707.2 PC8708.2 PC8709.2 PC8711.2 PC8712.2 PC8713.2 PC8714.1 PC8715.2 PC8716.2 PC8717.2 PC8718.2 PC8719.2 PC8720.1 PC8721.2 PC8722.2 PC8723.2 PC8724.2 PC8726.1 PC8800.1 PC8801.1 PC8802.2 PC8805.1 PC8806.1 PC8808.2 PC8811.1 PC8812.1 PC8814.1 PC8816.1 PC8817.1 PC8818.1 PC8819.1 PC8900.2 PC8901.1 PC8902.2 PC8903.2 PC8904.2 PC8905.2 PC8906.2 PC8907.2 PC8908.1 PC8910.1 PC8917.2 PC8918.2 PC8919.2 PC8920.2 PC8921.1 PC8922.2 PC8923.2 PC8924.2 PC8925.2 PC8926.2 PC8928.1 PC8929.1 PC8937.2 PC8938.2 PC8939.2 PC9100.2 PC9101.1 PC9102.2 PC9103.2 PC9104.2 PC9105.2 PC9106.2 PC9107.2 PC9108.1 PC9110.2 PC9111.2 PC9112.2 PC9113.2 PC9114.2 PC9118.2 PC9120.2 PC9121.1 PC9122.2 PC9123.2 PC9201.2 PC9202.1 PC9203.2 PC9204.2 PC9205.2 PC9206.2 PC9207.2 PC9208.1 PC9209.1 PC9211.2 PC9212.2 PC9213.2 PC9214.2 PC9215.1 PC9216.2 PC9217.2 PC9500.2 PC9501.2 PC9502.2 PC9503.2 PC9504.1 PC9505.2 PC9506.1 PC9507.1 PC9508.2 PC9509.2 PC9510.2 PC9511.2 PC9512.2 PC9513.2 PC9514.2 PC9515.2 PC9516.2 PC9517.2 PC9518.2 PC9519.2 PC9520.2 PC9521.2 PC9522.2 PC9523.2 PC9526.1 PC9527.2 PC9528.2 PC9529.1 PC9534.2 PC9536.2 PC9537.2 PC9538.2 PC9543.2 PC9601.2 PC9605.2 PC9800.1 PC9801.2 PC9802.1 PC9803.2 PC9804.2 PC9805.1 PC9900.2 PC9901.2 PC9902.2 PC9903.2 PC9904.2 PC9906.1 PC9909.2 PC9910.2 PC9911.2 PC9912.2 PC9913.2 PC9914.1 PC9915.2 PC9916.2 PC9917.2 PC9920.2 PC9921.2 PC9922.1 PC9923.2 PC9924.2 PC9925.2 PC9926.2 PC10200.2 PC10201.2 PC10202.1 PC10203.1 PC10204.1 PC10206.1 PC10207.1 PC10208.2 PC10209.2 PC10211.1 PC10212.2 PC10213.2 PC10214.2 PC10215.2 PC10216.1 PC10217.2 PC10218.1 PC10219.1 PC10220.2 PC10221.2 PC10500.2 PC10501.2 PC10502.2 PC10503.2 PC10504.2 PC10506.2 PC10507.2 PC10508.2 PC10509.2 PC10510.2 PC10511.2 PC10512.2 PC10513.2 PC10514.2 PC10515.2 PC10516.2 PC10624.2 PC10625.2 PC10626.2 PC10627.2 PC10628.2 PC10629.2 PC10630.2 PC10631.2 PC10632.2 PC10633.1 PC10634.2 PC10635.2 PC10636.1 PC10637.2 PC10638.2 PC10639.2 PC10640.2 PC10641.2 PC10642.2 PCN8000.5 PCN8000.6 PCN8000.7 PCN8000.8 PCN8000.9 PCN8400.1 PCN8400.2 PCN8400.3 PCN8400.11 PCN8400.12 PD8000.2 PD8200.2 PD8203.2 PD8206.2 PD8400.1 PD8401.1 PD8402.2 PQ8003.1(S) PQ8204.1 PQ8204.2 PQ8204.3(S_3) PQ8205.1(S) PQ8400.3 PQ8402.1(S) PQ8403.1(S) PQ8700.5 PQ8700.6 PQ8700.7(S2#3) PQ8702.1(S) PQ8703.1(S) PQ8703.4 PQ9100.1(S) PQ9100.4 PQ9601.1(S) PQ9800.1(S) PQ9800.4 PQ9802.1(S) PQ10200.1(S) PQ10200.4 PQ10500.1(S) PQ10500.4 PQ10501.1(S) PQ10501.4 PQ10603.1(S) PQ10603.4 PR8009.2 PR8013.1 PR8016.2 PR8017.2 PR8018.1 PR8020.2 PR8021.2 PR8022.2 PR8023.1 PR8024.1 PR8025.2 PR8026.2 PR8108.1 PR8113.2 PR8114.2 PR8119.1 PR8122.1 PR8203.1 PR8204.2 PR8207.2 PR8208.2 PR8217.2 PR8220.1 PR8228.1 PR8237.2 PR8244.2 PR8403.1 PR8408.2 PR8409.1 PR8415.1 PR8416.1 PR8417.1 PR8608.1 PR8609.1 PR8616.2 PR8621.2 PR8622.1 PR8702.1 PR8710.2 PR8715.2 PR8725.1 PR8809.2 PR8811.2 PR8813.2 PR8822.2 PR8837.1 PR8838.2 PR8840.2 PR8841.2 PR8842.2 PR9102.1 PR9103.1 PR9111.2 PR9116.2 PR9117.2 PR9118.1 PR9122.2 PR9204.1 PR9210.2 PR9213.1 PR9603.1 PR9611.1 PR9805.1 PR9807.1 PR9809.2 PR9812.2 PR9821.1 PR9827.1 PR10207.1 PR10211.2 PR10214.2 PR10509.2 PR10511.1 PR10520.2 PR10619.2 PU8100.4 PU8101.1(VEE) PU8101.7 PU8102.3 PU8200.22 PU8200.29 PU8201.2 PU8601.3 PU8601.11 PU8602.2 PU8700.1 PU8700.14 PU8700.21 PU8701.2 PU8800.33 PU8900.3 PU8900.9 PU8900.20 PU8900.23 PU8901.3 PU8901.9 PU8901.20 PU8901.23 PU9100.1 PU9100.3 PU9100.4 PU9100.19 PU9200.2 PU9200.3 PU9200.4 PU9500.11 PU9500.15 PU9501.11 PU9501.15 PU9502.11 PU9502.15 PU9600.3 PU9601.3 PU9800.11 PU9800.21 PU9900.5 PU9900.12 PU9900.13 PU9900.19 PU9901.5 PU9901.12 PU9901.13 PU9901.19 PU10200.4 PU10200.12 PU10200.13 PU10200.14 PU10200.15 PU10200.19 PU10500.2 PU10501.11 PU10501.15 PU10601.11 PU10601.15 PU10602.3 PU10603.3 PU10604.3 PU10605.3 PU10606.3 Q500.1(S) Q501.1(EMITTER) Q800.1(S) Q801.1(S) Q1000.1(S) Q1400.1(S) Q3403.1(S) Q3404.1(S) Q3405.1(S) Q4106.1(S) Q4108.1(EMITTER) Q4111.1(EMITTER) Q4300.1(S) Q4400.1(S) Q4401.1(S) Q4703.1(S) Q4703.4 Q5000.1(S) Q5000.4 Q5001.1(S) Q5004.1(S) Q5006.1(S) Q5101.1(S) Q5101.4 Q5201.1(S) Q5202.1(S) Q5401.1(S) Q6600.1(EMITTER) Q6601.1(EMITTER) Q6801.1(EMITTER) Q6802.1(EMITTER) Q6901.1(S) Q6901.4 Q6903.1(S) Q6903.4 Q6904.1(S) Q7000.1(S) Q7001.1(S) Q7506.1(S) Q7507.1(S) Q7508.1(S) R401.1 R402.2 R403.2 R404.2 R405.2 R500.2 R511.1 R513.1 R606.1 R608.1 R617.2 R618.2 R620.2 R624.1 R800.2 R801.2 R802.2 R803.2 R1000.2 R1001.1 R1002.2 R1003.2 R1006.2 R1008.1 R1009.2 R1010.2 R1011.2 R1022.2 R1030.2 R1031.2 R1034.2 R1037.1 R1038.2 R1039.2 R1040.2 R1041.2 R1042.2 R1043.2 R1121.1 R1122.2 R1123.1 R1127.2 R1135.2 R1137.2 R1139.2 R1142.2 R1144.2 R1201.1 R1203.1 R1205.1 R1211.1 R1213.2 R1215.2 R1216.2 R1217.2 R1218.2 R1219.2 R1224.2 R1225.2 R1228.2 R1229.2 R1233.2 R1235.2 R1239.2 R1240.2 R1243.1 R1244.2 R1248.2 R1249.2 R1301.1 R1302.1 R1303.2 R1307.1 R1405.2 R1412.2 R1413.2 R1417.1 R1420.2 R1422.1 R1504.2 R1522.2 R1528.2 R1529.2 R1533.2 R1537.1 R1538.1 R1539.1 R1540.1 R1541.1 R1542.1 R1544.1 R1545.1 R1546.1 R1548.1 R1549.1 R1553.2 R1562.2 R1574.2 R1575.2 R1576.2 R1602.2 R1603.2 R1617.2 R2817.1 R2818.1 R2819.1 R2820.1 R2821.1 R2905.2 R2906.2 R2907.2 R2917.1 R2920.2 R3405.1 R3406.1 R3414.1 R3429.1 R3505.2 R3508.2 R3515.2 R3607.2 R3613.2 R4135.2 R4151.2 R4152.2 R4208.1 R4209.1 R4213.1 R4230.2 R4311.1 R4409.2 R4410.2 R4412.2 R4414.1 R4720.1 R4732.2 R4741.2 R4742.2 R4743.1 R4744.1 R4753.1 R4809.2 R4810.1 R4811.2 R4813.2 R4814.1 R4815.1 R4821.2 R4824.2 R5010.2 R5014.2 R5017.1 R5019.1 R5111.2 R5112.2 R5121.2 R5126.1 R5129.1 R5202.1 R5408.2 R5627.2 R5913.2 R5914.2 R5915.2 R5917.2 R5920.2 R5922.2 R5924.2 R5926.2 R5930.2 R5932.2 R5935.2 R6105.2 R6112.2 R6200.2 R6201.2 R6202.1 R6304.2 R6305.2 R6306.2 R6307.2 R6308.2 R6309.2 R6310.2 R6311.2 R6314.1 R6319.1 R6611.1 R6616.2 R6617.1 R6618.1 R6619.1 R6703.1 R6704.2 R6706.1 R6707.1 R6712.1 R6713.1 R6805.2 R6806.2 R6810.1 R6812.1 R6911.1 R6912.1 R6913.1 R6914.1 R6915.1 R6916.1 R6917.1 R6918.1 R6919.1 R6961.1 R6962.2 R6963.2 R6964.1 R7002.1 R7003.1 R7004.1 R7005.1 R7006.1 R7007.1 R7013.1 R7016.1 R7017.1 R7018.1 R7520.1 R7601.1 R7607.1 R7613.1 R7707.2 SW5000.2 U400.A27 U400.A32 U400.A45 U400.A49 U400.AA41 U400.AA48 U400.AB5 U400.AB7 U400.AB8 U400.AC44 U400.AC49 U400.AD4 U400.AD8 U400.AD48 U400.AF4 U400.AF8 U400.AG41 U400.AG42 U400.AG44 U400.AG45 U400.AG47 U400.AG48 U400.AG53 U400.AH4 U400.AH8 U400.AK4 U400.AK5 U400.AK7 U400.AK8 U400.AK12 U400.AK48 U400.AM1 U400.AM2 U400.AM4 U400.AM8 U400.AN41 U400.AN42 U400.AN44 U400.AN45 U400.AN47 U400.AN48 U400.AN53 U400.AP4 U400.AP8 U400.AT4 U400.AT8 U400.AT48 U400.AT51 U400.AV4 U400.AV5 U400.AV7 U400.AV8 U400.AV12 U400.AV39 U400.AW1 U400.AW2 U400.AW48 U400.AY4 U400.AY8 U400.AY9 U400.AY41 U400.AY42 U400.AY44 U400.AY45 U400.AY47 U400.B2 U400.B8 U400.B13 U400.B19 U400.B23 U400.B27 U400.B32 U400.B36 U400.B39 U400.B42 U400.B48 U400.B52 U400.BA48 U400.BA53 U400.BB4 U400.BB8 U400.BC1 U400.BC2 U400.BD4 U400.BD8 U400.BD12 U400.BD48 U400.BF4 U400.BF5 U400.BF7 U400.BF8 U400.BF39 U400.BF41 U400.BF42 U400.BF44 U400.BF45 U400.BF47 U400.BG48 U400.BG53 U400.BH1 U400.BH2 U400.BH4 U400.BH8 U400.BK4 U400.BK8 U400.BK12 U400.BK48 U400.BL49 U400.BM1 U400.BM4 U400.BM8 U400.BM41 U400.BM42 U400.BM44 U400.BM45 U400.BM47 U400.BN48 U400.BP5 U400.BP7 U400.BP41 U400.BP49 U400.BP50 U400.BT44 U400.BT48 U400.BU49 U400.BV3 U400.BV5 U400.BV48 U400.BW10 U400.BY9 U400.BY41 U400.BY42 U400.BY44 U400.BY45 U400.BY47 U400.BY49 U400.C13 U400.C19 U400.C23 U400.CA48 U400.CB41 U400.CC3 U400.CC5 U400.CC10 U400.CD7 U400.CD44 U400.CD48 U400.CE49 U400.CG9 U400.CG48 U400.CG51 U400.CG52 U400.CH41 U400.CH42 U400.CH44 U400.CH45 U400.CH47 U400.CJ3 U400.CJ5 U400.CJ9 U400.CK39 U400.CK48 U400.CK53 U400.CL9 U400.CN9 U400.CN12 U400.CN48 U400.CN51 U400.CN52 U400.CP3 U400.CP5 U400.CP41 U400.CP42 U400.CP44 U400.CP45 U400.CR9 U400.CR48 U400.CR53 U400.CT5 U400.CU4 U400.CU9 U400.CV5 U400.CV10 U400.CV48 U400.CV51 U400.CV52 U400.CY5 U400.CY17 U400.CY22 U400.CY35 U400.CY41 U400.CY42 U400.CY44 U400.CY45 U400.CY47 U400.D5 U400.D27 U400.D32 U400.D36 U400.D42 U400.D49 U400.DA30 U400.DA33 U400.DA53 U400.DC17 U400.DD15 U400.DD24 U400.DD26 U400.DD28 U400.DD31 U400.DD33 U400.DD35 U400.DD39 U400.DD45 U400.DD51 U400.DD52 U400.DE3 U400.DE5 U400.DF19 U400.DF37 U400.DG5 U400.DG6 U400.DG15 U400.DG21 U400.DG27 U400.DG33 U400.DG39 U400.DG45 U400.DG53 U400.DJ1 U400.DJ2 U400.DJ4 U400.DK51 U400.DL3 U400.DL5 U400.DM4 U400.DM10 U400.DM15 U400.DM21 U400.DM27 U400.DM33 U400.DM39 U400.DM45 U400.DN1 U400.DN2 U400.DP53 U400.DR11 U400.DR16 U400.DR22 U400.DR28 U400.DR34 U400.DR40 U400.DR46 U400.DT4 U400.DT50 U400.DU11 U400.DU16 U400.DU22 U400.DU28 U400.DU34 U400.DU40 U400.DU46 U400.DV1 U400.DV40 U400.DV51 U400.DV52 U400.DW51 U400.E13 U400.E19 U400.E35 U400.E48 U400.G22 U400.G28 U400.G34 U400.G39 U400.G48 U400.G51 U400.G52 U400.H8 U400.H12 U400.H22 U400.H28 U400.H34 U400.J39 U400.J49 U400.K5 U400.K16 U400.K18 U400.K20 U400.K22 U400.K28 U400.K34 U400.K48 U400.L22 U400.L28 U400.L34 U400.L39 U400.L41 U400.L42 U400.L44 U400.L45 U400.L47 U400.L49 U400.M1 U400.M2 U400.M50 U400.N22 U400.N28 U400.N34 U400.N39 U400.N41 U400.N48 U400.P4 U400.P8 U400.P11 U400.P14 U400.P16 U400.P18 U400.P20 U400.P22 U400.P33 U400.P35 U400.P49 U400.R39 U400.R44 U400.T4 U400.T8 U400.T19 U400.T29 U400.T33 U400.T48 U400.U19 U400.U25 U400.U39 U400.U49 U400.V4 U400.V8 U400.V19 U400.W1 U400.W16 U400.W26 U400.W30 U400.W39 U400.W41 U400.W42 U400.W44 U400.W45 U400.W47 U400.W48 U400.Y4 U400.Y8 U400.Y49 U400.Y50 U1501.3 U1502.3 U1600.2 U1800.C1 U1800.C3 U1801.B3 U1801.C1 U1801.C3 U1802.B3 U1802.C1 U1803.C1 U1804.B3 U1804.C1 U1805.C1 U1806.C1 U1807.B3 U1807.C1 U1809.C1 U1900.C1 U1902.C1 U1903.C1 U1903.C3 U1904.C1 U1904.C3 U1905.C1 U1906.C1 U1906.C3 U1907.C1 U1907.C3 U1908.C1 U1909.B3 U1909.C1 U2000.C1 U2001.C1 U2002.B3 U2002.C1 U2002.C3 U2004.C1 U2005.C1 U2005.C3 U2006.B3 U2006.C1 U2007.C1 U2008.C1 U2010.B3 U2010.C1 U3400.2 U3402.2 U3404.2 U3405.2 U3500.2 U3501.14 U3501.33 U3501.34 U3501.35 U3501.36 U3501.37 U3501.38 U3501.39 U3501.40 U3501.41 U3600.41 U4102.3 U4200.2 U4200.3 U4400.2 U4700.A1 U4700.A5 U4700.A8 U4700.E12 U4700.G1 U4700.J12 U4700.M3 U4700.M9 U4701.2 U5100.23 U5100.33 U5400.5 U5401.2 U5401.4 U5403.5 U5602.4 U5603.4 U5604.4 U5604.9 U5605.4 U5605.9 U5900.A11 U5900.B1 U5900.B2 U5900.B11 U5900.B12 U5900.D1 U5900.D2 U5900.D11 U5900.D12 U5900.F1 U5900.F2 U5900.F3 U5900.F5 U5900.F7 U5900.F9 U5900.F11 U5900.F12 U5900.G5 U5900.G7 U5900.H1 U5900.H2 U5900.H11 U5900.H12 U5900.J9 U5900.K1 U5900.K2 U5900.K11 U5900.K12 U5900.L12 U5900.M2 U5900.M3 U5900.M12 U5901.4 U5902.4 U5904.B1 U6100.49 U6101.5 U6101.9 U6200.3 U6200.8 U6201.3 U6201.8 U6202.2 U6203.14 U6203.17 U6600.A2 U6600.A26 U6600.AA7 U6600.AB7 U6600.AB11 U6600.AB14 U6600.AB17 U6600.AB20 U6600.AB24 U6600.AC2 U6600.AC5 U6600.AC8 U6600.AC22 U6600.AC26 U6600.AD12 U6600.AD13 U6600.AD15 U6600.AD16 U6600.AD18 U6600.AD19 U6600.AD21 U6600.AD22 U6600.AE11 U6600.AE14 U6600.AE17 U6600.AE20 U6600.AF1 U6600.AF5 U6600.AF8 U6600.AF11 U6600.AF14 U6600.AF17 U6600.AF20 U6600.AF23 U6600.AG2 U6600.AG26 U6600.B1 U6600.B5 U6600.B8 U6600.B11 U6600.B14 U6600.B17 U6600.B20 U6600.B23 U6600.B27 U6600.E2 U6600.E5 U6600.E8 U6600.E11 U6600.E14 U6600.E17 U6600.E20 U6600.E22 U6600.E25 U6600.H23 U6600.H25 U6600.K11 U6600.K13 U6600.K15 U6600.K17 U6600.L5 U6600.L10 U6600.L12 U6600.L14 U6600.L16 U6600.L18 U6600.L23 U6600.L25 U6600.M11 U6600.M13 U6600.M15 U6600.M17 U6600.N10 U6600.N12 U6600.N14 U6600.N16 U6600.N18 U6600.P11 U6600.P13 U6600.P15 U6600.P17 U6600.P23 U6600.P26 U6600.R10 U6600.R12 U6600.R14 U6600.R16 U6600.R18 U6600.T11 U6600.T13 U6600.T15 U6600.T17 U6600.U10 U6600.U12 U6600.U14 U6600.U16 U6600.U18 U6600.U23 U6600.U26 U6600.V11 U6600.V13 U6600.V15 U6600.V17 U6600.Y2 U6600.Y5 U6600.Y23 U6600.Y26 U6601.3 U6701.3 U6801.4 U6801.9 U6901.3 U6902.3 U7500.5 U7600.33 U7601.5 VC3500.2 VC5001.2 VC6200.1 VC6201.1 VC6202.2 VRAM7000.A1 VRAM7000.A3 VRAM7000.A12 VRAM7000.A14 VRAM7000.B5 VRAM7000.B10 VRAM7000.C1 VRAM7000.C3 VRAM7000.C4 VRAM7000.C11 VRAM7000.C12 VRAM7000.C14 VRAM7000.D10 VRAM7000.E1 VRAM7000.E3 VRAM7000.E12 VRAM7000.E14 VRAM7000.F5 VRAM7000.F10 VRAM7000.G5 VRAM7000.G10 VRAM7000.H1 VRAM7000.H2 VRAM7000.H13 VRAM7000.H14 VRAM7000.K1 VRAM7000.K2 VRAM7000.K13 VRAM7000.K14 VRAM7000.L5 VRAM7000.L10 VRAM7000.M5 VRAM7000.M10 VRAM7000.N1 VRAM7000.N3 VRAM7000.N12 VRAM7000.N14 VRAM7000.P10 VRAM7000.R1 VRAM7000.R3 VRAM7000.R4 VRAM7000.R11 VRAM7000.R12 VRAM7000.R14 VRAM7000.T5 VRAM7000.T10 VRAM7000.U1 VRAM7000.U3 VRAM7000.U12 VRAM7000.U14 VRAM7001.A1 VRAM7001.A3 VRAM7001.A12 VRAM7001.A14 VRAM7001.B5 VRAM7001.B10 VRAM7001.C1 VRAM7001.C3 VRAM7001.C4 VRAM7001.C11 VRAM7001.C12 VRAM7001.C14 VRAM7001.D10 VRAM7001.E1 VRAM7001.E3 VRAM7001.E12 VRAM7001.E14 VRAM7001.F5 VRAM7001.F10 VRAM7001.G5 VRAM7001.G10 VRAM7001.H1 VRAM7001.H2 VRAM7001.H13 VRAM7001.H14 VRAM7001.K1 VRAM7001.K2 VRAM7001.K13 VRAM7001.K14 VRAM7001.L5 VRAM7001.L10 VRAM7001.M5 VRAM7001.M10 VRAM7001.N1 VRAM7001.N3 VRAM7001.N12 VRAM7001.N14 VRAM7001.P10 VRAM7001.R1 VRAM7001.R3 VRAM7001.R4 VRAM7001.R11 VRAM7001.R12 VRAM7001.R14 VRAM7001.T5 VRAM7001.T10 VRAM7001.U1 VRAM7001.U3 VRAM7001.U12 VRAM7001.U14 Y1401.2 Y1401.4 Y5900.2 Y5900.4 Y6800.2 Y6800.4
VBUS_P: R6104.1 R6127.1 U6100.4 U6100.5 U6100.6 U6100.7
VCC1_RST#: R4804.1 R4813.1 R7719.1 U4700.K6(V\C\C\1\_\R\S\T\/GPO77)
VCC1_RST#_R1: CON7702.16(VCC1_RST#) R7719.2
VCC3V3_FLASH: C1911.2 C5937.1 R5901.1 R5938.1 R5940.2 R5942.2 R5944.2 R5945.2 TP5905.1 U1905.D1 U1905.D2 U5901.8 U5902.8
VCC_AUX_SENSE: PR9124.1 U400.AT9
VCCA_CLKLDO_1V8: C1646.2 R1601.1 U400.DC15 U400.DV16
VCCAUX_VID: PD9602.3(COMMON ANODE) PU9600.1 PU9601.2 PU10604.4(Y)
VCCAUX_VID0: PD9602.2 PR9100.1 PR9102.2 PR9106.1 PU10604.2 R1605.1
VCCAUX_VID0_R: R1605.2 R1611.2 U400.DB37
VCCAUX_VID1: PD9602.1 PR9101.1 PR9103.2 PR9105.1 PU10604.1 R1607.1
VCCAUX_VID1_R: R1607.2 R1612.2 U400.DB38
VCCDSW_3P3: C1652.2 R1606.1 U400.DD37
VCCIN_V1N: PR8812.1 PR8819.1 PR8906.1
VCCIN_V1P: PR8807.2 PR8808.1 PR8905.1
VCCIN_V2N: PR8806.1 PR8821.1 PR8913.1
VCCIN_V2P: PR8815.2 PR8816.1 PR8912.1
VCCSENSE: PR8843.1 U400.R38
VCCST_EN_OR: PR9600.2 PR9603.2 PR10612.2 PU9600.4(Y)
VCCST_OVERRIDE: PR10621.1 R1523.2 U400.BP9
VCCST_OVRD: PD9601.3(COMMON ANODE) PR9601.2 PU9600.2 PU10603.4(Y)
VCCST_OVRD_R1: PD9600.3(COMMON ANODE) PD9601.2 PR9600.1 PR9601.1 PU10602.4(Y) PU10603.2
VCCST_OVRD_R2: PD9601.1 PD9604.2 PQ9601.3 PR9606.1 PU10603.1 PU10606.2
VCCST_PWRGD_TCSS: PR10622.1 R1524.2 U400.CE5
VCCSTG_EN_OR: PR9611.2 PR9613.2 PR10614.1 PU9601.4(Y)
VCCSTG_OVRD: PD9604.3(COMMON ANODE) PR9612.2 PU9601.1 PU10606.4(Y)
VCCSTG_OVRD_R1: PD9603.3(COMMON ANODE) PD9604.1 PR9612.1 PR9613.1 PU10605.4(Y) PU10606.1
VDD_SIM: CON4402.10 R4414.2 R4415.1
VINSEN_NVVDD: PR9806.2 PR9900.1
VSS_AUX_SENSE: PR9125.1 U400.AV9
VSSSENSE: PR8844.1 U400.R37
27M_XTAL_IN: C6806.2 U6600.C11 Y6800.3
27M_XTAL_OUT: C6807.2 U6600.B10 Y6800.1
2260_BST_1.35V: PR10203.2 PU10200.20
2260_EN_1.35V: PC10217.1 PQ10200.2 PR10208.1 PU10200.2
2260_FB_1.35V: PR10210.1 PR10211.1 PU10200.5
2260_FB_1.35V_S: PR10209.2 PR10210.2
2260_LX_1.35V: PC10210.2 PL10201.1 PR10206.2 PU10200.10 PU10200.16 PU10200.17 PU10200.18
2260_PFM_1.35V: PR10205.2 PR10207.2 PU10200.3
2260_PG_1.35V: PR10204.1 PU10200.1
2260_SS_1.35V: PC10218.2 PU10200.23
2260_TON_1.35V: PR10200.2 PU10200.6
2260_VCC_1.35V: PC10207.2 PR10201.2 PU10200.21(VCC)
8051_RX_CAPS_LED#: CON7702.14 R4734.1 R4745.1 U4700.J7 U4701.3
8051_TX_LED_PWRSTBY#: CON7702.13 R4737.1 R4746.1 U4700.H8 U4701.1
8097_EN_2.5V: PC8726.2 PR8722.1 PR8724.2 PU8701.1
8097_LX_2.5V: PL8702.1 PU8701.3
8097_PG_2.5V: PR8716.1 PU8701.5
8097_VFB_2.5V: PC8725.2 PR8723.2 PR8725.2 PU8701.6
8097_VFB_2.5V_S: PC8725.1 PR8721.2 PR8723.1
8097_VIN_2.5V: PC8721.1 PR8719.2 PU8701.4(VIN)
8231_BT: PR8705.2 PU8700.18
8231_BT_S: PC8710.1 PR8705.1
8231_CS: PR8702.2 PU8700.13
8231_LG: PQ8700.8 PU8700.15
8231_PG: PR8700.1 PU8700.10
8231_PH: PC8710.2 PL8701.1 PQ8700.9 PR8708.2 PU8700.16
8231_S3: PC8706.2 PR8703.2 PU8700.7
8231_S5: PC8700.1 PR8701.2 PU8700.8
8231_TON: PR8704.1 PU8700.9
8231_UG: PQ8700.1 PU8700.17
8231_VDDQ: PR8711.1 PR8714.2 PU8700.5
8231_VID: PR8712.1 PU8700.11
8231_VLDOIN: PC8713.1 PR8709.2 PU8700.19
8231_VTTREF: PC8712.1 PR8707.2 PU8700.4
+BAT_DIS: PL8202.2 PQ8200.5 PR8215.1 PR8221.2 PR8227.2 PR8245.2
+BATCHG: PC8214.1 PC8215.1 PC8216.1 PC8217.1 PC8218.1 PC8405.2 PC8406.1 PD8204.2 PD8206.1(CATHODE) PL8400.1 PR8215.2 PR8222.2 PR8421.1
+BATCHG+: PC8221.2 PC8222.1 PR8222.1 PR8231.2
+BATCHG-: PC8220.1 PC8221.1 PR8221.1 PR8229.2
+BATCHG_-: C2005.2 PR8421.2 U2000.D1 U2000.D2
+FB_PLLAVDD: C6715.1 C6716.2 C6717.2 C6718.1 C7730.2 L6700.2 L6701.2 U6600.F16 U6600.H22 U6600.P22
+OLEDVDD: C7221.1 CON3401.5 CON3401.6 F3403.1
+OLEDVSS: C7220.2 C7222.1 CON3401.1 CON3401.2 F3405.1
+PVT_VCC: C5604.1 C5605.1 R5628.1 R5629.1 R5631.1 R5632.2 U5603.8 U5605.8
+SMDDR_VREF_DIMM: C2822.1 C2823.1 R2800.2 R2811.1 R2815.2 R2820.2
+SMDDR_VREF_DQ0: JDIM2800.164 R2800.1
+SMDDR_VREF_DQ1: JDIM2900.164 R2900.1
+SPI_VCC: C1910.2 C5100.1 C5107.1 C5109.2 C5110.2 C5111.2 C5600.1 C5601.2 R5100.1 R5101.1 R5108.1 R5122.2 R5124.2 R5125.1 R5622.2 R5623.1 R5624.2 R5625.1 R5626.2 U1904.D1 U1904.D2 U5100.1(VDD#3) U5100.8 U5100.22 U5602.8 U5604.8
+UIM_PWR: C4205.1 C4206.1 C4207.2 CON4202.36 CON4204.1 R4220.2
+VAC: PC8000.1 PCN8000.1 PCN8000.2 PCN8000.3 PL8000.1 PL8001.1 PR8027.1
+VAC_IN: PC8001.1 PC8002.1 PD8000.1 PL8000.2 PL8001.2 PQ8000.1 PQ8000.2 PQ8000.3(S3) PQ8002.1(S) PR8000.1 PR8001.1 PR8014.1
+VHIF: C4700.1 C4703.1 R4725.2 U4700.F1
+VLVDD: F3403.2
+VLVSS: F3405.2
+VSPI: C4704.1 C4705.2 R4729.2 U4700.H12
A_3S_ICHSPKR: R1200.2 R1213.1 R3612.1 U400.DC50
A_SD#: D3600.1(CATHODE) R3618.2 U4700.L8
AC_DC#_ALERT: D6902.1(CATHODE) R4748.2 U4700.F6
ACZ_RST#: R1503.1 U400.DV41
ACZ_RST#_AUDIO: R1503.2 R3620.2
ACZ_SDIN0_AUDIO: EC3600.2 R3614.1 U400.DV37
ACZ_SDOUT: Q1500.3 Q1502.3 U400.DT37
ACZ_SDOUT_AUDIO: EC3604.2 R1232.2 R1543.1 U3600.4
ACZ_SDOUT_G: Q1500.2 R1530.1
ACZ_SDOUT_R: Q1500.1(S) R1543.2
ACZ_SYNC: R1502.1 U400.DU37
ACZ_SYNC_AUDIO: EC3601.2 R1502.2 U3600.9
ADP_DET: PR8230.1 PR8232.1 PU8200.5 U4700.M5
ADP_ID_ADC_R: C4710.2 R4714.1 U4700.E2
ADP_PRES_OUT: R1534.2 R1538.2 U400.DK43 U4700.H3
ALERT: R6953.1 U6600.F8
AMBER_BATLED#: C4800.2 R7616.2 U4700.L9
AMP_BEEP: C3616.2 C4404.2 U3600.11
AMP_BEEP_L: C3616.1 C3617.2 R3612.2 R3613.1
AN_RBIAS: R5931.1 U5900.L4
AN_RSENSE: R5931.2 U5900.L5
AOZ5507_BST1: PR8901.2 PU8900.4
AOZ5507_BST2: PR8908.2 PU8901.4
AOZ5507_PHASE1: PC8909.2 PU8900.5
AOZ5507_PHASE2: PC8927.2 PU8901.5
AOZ5507_SW1: PL8902.1 PR8904.1 PR8905.2 PU8900.12(VSWH)
AOZ5507_SW2: PL8903.1 PR8911.1 PR8912.2 PU8901.12(VSWH)
AOZ5507_VCC1: PC8908.2 PR8900.2 PU8900.2
AOZ5507_VCC2: PC8928.2 PR8907.2 PU8901.2
AP12: TP1602.1 U400.AP12
B/I: PCN8400.4 PR8414.2
B_RTC: PCN8400.5 PR8420.1
BARREL_ADP_DET: C4804.1 PQ8011.3 PR8019.1 PR8022.1 U4700.H5
BARREL_ADP_EN: PQ8004.1(S) PR8011.2 U4700.F4
BAT_GRNLED#: C4805.2 R7615.2 U4700.F7
BATLOW#: Q4800.3 R1532.1 R1535.1 U400.DN41 U4700.A9
BATT+: PC8407.1 PCN8400.8 PCN8400.9 PCN8400.10 PL8400.2 PR8422.1
BATT+_+: C2005.1 PR8422.2 U2000.D3
BB_TCP0_RESET#: CON7701.15 R5920.1 R5928.2 U6100.30
BIOS_WP#: R5632.1 R5633.2 TP5618.1 U5603.3(W\P\) U5605.3(W\P\(IO2))
BIT_CLK: R1500.1 R1575.1 U400.DR38
BIT_CLK_AUDIO: C1504.2 R1500.2 R3617.1
BIT_CLK_AUDIO_L: C3623.2 R3617.2 U3600.5
BK_DIGITAL_CLK: R1546.2 U400.DL49
BK_DIGITAL_D1: TP1500.1 U400.DG50
BLON_CON: CON3400.5 CON3400.38 Q3403.3 R3402.1
BOARD_ID1: R1201.2 R1202.1 U400.DR32
BOARD_ID2: R1203.2 R1204.1 U400.DT31
BOARD_ID3: R1205.2 R1206.1 U400.DK29
BOARD_ID4: R1211.2 R1212.1 U400.DN29
BQACDET: PC8213.1 PD8207.1(CATHODE) PR8213.2 PR8217.1 PR8232.2 PU8200.6
BQACDRV: PU8200.4 TP8200.1
BQACN: PR8206.2 PR8209.1 PU8200.1
BQACP: PR8205.2 PU8200.2
BQBATDRV: PU8200.18 TP8202.1
BQBATPRES: PR8226.2 PR8228.2 PU8200.15
BQBATSRC: PR8227.1 PU8200.17
BQBTST: PR8212.2 PU8200.25
BQCMPIN: PC8227.2 PR8240.2 PR8241.1 PR8243.1 PU8200.13
BQCMPOUT: PR8239.1 PR8241.2 PR8242.1 PU8200.14
BQCMSRC: PR8210.1 PU8200.3
BQHIDRV: PQ8203.4 PU8200.26
BQIADP: PC8223.1 PR8233.2 PU8200.7
BQIDCHG: PC8224.1 PR8234.2 PU8200.8
BQILIM: PQ8205.3 PR8235.1 PU8200.21
BQLODRV: PQ8204.4 PU8200.23
BQPHASE: PC8212.2 PL8202.1 PQ8203.1 PQ8203.2 PQ8203.3(S_3) PQ8204.5 PR8218.2 PU8200.27
BQPMON: PR8236.1 PR8237.1 PU8200.9
BQPROCHOT: PR8225.2 PU8200.10
BQSCL: PR8224.1 PU8200.12
BQSDA: PR8223.1 PU8200.11
BQSRN: PR8231.1 PU8200.19
BQSRP: PR8229.1 PU8200.20
BQTB_STAT: PU8200.16 TP8201.1
BQVCC: PC8211.1 PR8211.2 PU8200.28(VCC)
BT_OFF: R4152.1 R4156.1 U400.DH49
BXTALOUT: R6804.1 R6806.1 U6600.C10
C_TX0_HDMI+: C3521.1 U3501.6
C_TX0_HDMI-: C3522.1 U3501.7
C_TX1_HDMI+: C3507.1 U3501.4
C_TX1_HDMI-: C3508.1 U3501.5
C_TX2_HDMI+: C3505.1 U3501.1
C_TX2_HDMI-: C3506.1 U3501.2
C_TXC_HDMI+: C3523.1 U3501.9
C_TXC_HDMI-: C3524.1 U3501.10
CABLE_SIZE_DET: CON3400.11 R1138.2 R1139.1 U400.DN13
CAMERA_ON: CON3400.9 R810.1 U400.DA50 U3402.3
CAMERA_WP#: R3413.2 R4743.2 U4700.E8
CAMERA_WP#_LCD: CON3400.25 R3413.1
CAPS_LED#: C5029.2 R4738.1 R4745.2 R5011.1 U4701.4
CCG5_HOTPLUG_DET_P1_C: Q6100.3 R6101.1 R6115.2 U6100.27
CCG5_SWD_CLK: CON7702.26 R6100.2 R6105.1 U6100.15
CCG5_SWD_IO: CON7702.25 R6102.1 U6100.14
CCG5_VBUS_C_CTRL_P1: PD8002.1(CATHODE) PR8002.2 U6100.47
CCG5_XRES: C6106.2 CON7702.27 R6106.2 U6100.34(XRES)
CCG6_BB_RT_A_EN: R5948.1 U5904.B2 U6100.31
CCG6_SBU1_A: R5909.1 R6122.1 U6100.41
CCG6_SBU1_A_M: R6122.2 U6101.1
CCG6_SBU1_R_A: R5909.2 R5914.1 U5900.M10
CCG6_SBU2_A: R5910.1 R6123.1 U6100.40
CCG6_SBU2_A_M: R6123.2 U6101.2
CCG6_SBU2_R_A: R5910.2 R5913.1 U5900.L10(PB_SBU2)
CFG0: CON7703.9 R1028.1 R7703.2 U400.E7
CFG0_R: R1012.2 R1028.2 R1030.1 TP1031.1
CFG1: CON7703.11 R1013.2 R1039.1 U400.D9
CFG2: CON7703.15 R1014.2 R1031.1 U400.E9
CFG3: CON7703.17 R1015.2 R1040.1 U400.H5
CFG4: CON7703.27 R1016.2 R1034.1 U400.E6
CFG5: CON7703.29 R1017.2 R1041.1 U400.H9
CFG6: CON7703.33 R1018.2 R1042.1 U400.K8
CFG7: CON7703.35 R1019.2 R1038.1 U400.H7
CFG8: CON7703.10 R1020.2 R1043.1 TP7700.1 U400.K7
CFG9: CON7703.12 R1006.1 R1021.2 U400.T17
CFG10: CON7703.16 R1009.1 R1023.2 U400.K9
CFG11: CON7703.18 R1022.1 R1024.2 U400.K12
CFG12: CON7703.28 R1010.1 R1025.2 U400.K11
CFG13: CON7703.30 R1011.1 R1026.2 U400.U15
CFG14: CON7703.34 R1003.1 R1027.2 U400.V17
CFG15: CON7703.36 R1002.1 R1029.2 U400.T15
CFG16: CON7703.21 R1037.2 U400.H11
CFG17: CON7703.4 U400.U17
CFG_RCOMP: R1000.1 U400.B5
CHA_SA0: JDIM2800.256 R2812.1 R2817.2
CHA_SA1: JDIM2800.260 R2813.1 R2818.2
CHA_SA2: JDIM2800.166 R2814.1 R2819.2
CHB_SA0: JDIM2900.256 R2902.2 R2905.1
CHB_SA1: JDIM2900.260 R2903.2 R2906.1
CHB_SA2: JDIM2900.166 R2904.2 R2907.1
CK_XDP_N: CON7703.42 TP7704.1
CK_XDP_P: CON7703.40 TP7703.1
CL_CLK: C4112.2 R4130.1 U400.DH3
CL_CS_ME_CL: D7501.2 Q7506.3 R7509.2 R7515.1
CL_DATA: R4129.1 U400.DH4
CL_RST: R4128.1 U400.DF2
CLICKPAD_INT#: CON5202.4 R5212.2 U400.DT25
CLK_BIASREF: R1422.2 U400.DJ5
CLK_GFX_N: U400.CL8 U6600.AD8
CLK_GFX_P: U400.CL7 U6600.AE8
CLK_PCIE_CRN: U400.CB1 U7600.6
CLK_PCIE_CRP: U400.CB2 U7600.5
CLK_PCIE_LANN: R7617.2 U400.CB5
CLK_PCIE_LANN_R: CON7602.18 R7617.1
CLK_PCIE_LANP: R7618.2 U400.CB4
CLK_PCIE_LANP_R: CON7602.19 R7618.1
CLK_PCIE_SSDN: CON4300.53 U400.CN8
CLK_PCIE_SSDP: CON4300.55 U400.CN7
CLK_PCIE_WLANN: CON4100.49 U400.BW5
CLK_PCIE_WLANP: CON4100.47 U400.BW4
CLK_PCIE_WWANN: CON4202.53 U400.BY3
CLK_PCIE_WWANP: CON4202.55 U400.BY4
CLKREQ_C1: Q6600.2 Q6601.3 R6615.1
CNV_BRI_DT: CON4100.36 R1410.2 R4144.2
CNV_BRI_DT_R: R1241.2 R1243.2 R1410.1 U400.DF17
CNV_BRI_RSP: R1400.2 R4126.1 U400.DF15
CNV_BRI_RSP_R: CON4100.22 R4126.2
CNV_RF_RESET#: R1412.1 R4153.2 U400.DK10
CNV_RF_RESET#_L: CON4100.10 R4153.1
CNV_RGI_DT: CON4100.32 R1409.2 R4141.1
CNV_RGI_DT_R: R1222.1 R1225.1 R1409.1 U400.DG13
CNV_RGI_RSP: R1401.2 R4127.1 U400.DJ13
CNV_RGI_RSP_R: CON4100.34 R4127.2
CNV_WT_RCOMP: R1405.1 U400.DN51
CPPWR_EN: U4700.E9 U6203.8
CPU_C10_GATE#: PD9603.1 PR10613.1 PU10605.1 R1507.1 R1576.1 U400.DN27
CPU_EAR: R621.1 R624.2 U400.G1
CPU_EDP_HPD: L3403.2 R401.2 U400.DR5
CPU_POPI_RCOMP: R606.2 U400.CT39
CPU_PRDY#: CON7703.5 TP607.1 U400.D11
CPU_PREQ#: CON7703.3 R614.1 R7701.2 TP606.1 U400.C11
CPU_PROCHOT#: D1600.2 PR8411.1 PR8803.2 PR8829.1 R602.1 R603.1 R1614.2 R5419.1
CPU_SVID_CLK: R706.1 U400.M11
CPU_SVID_DAT: R707.1 U400.M12
CPU_THERM#: Q5401.2 R5407.1 U5400.4
CPU_VIDALERT#: R705.1 U400.P12
CR_GPIO: R7600.2 U7600.28
CSI_RCOMP: R1417.2 U400.K14
CSP_N: R6127.2 U6100.38
CSP_P: R6128.2 U6100.39
CYPRE_INT: CON7701.8 R1510.2 U400.CW40 U6100.17
CYPRE_INT_EC#: CON7701.4 R6114.2 U4700.A11 U6100.26
D64019_N: D7501.3(COMMON ANODE) R7515.2 R7516.2 R7518.2 R7519.2 R7520.2
DBG_PMODE: R1242.1 R1244.1 R7706.1 TP1201.1 U400.DF4
DCIN_EN: R3506.1 U3501.8
DCPRTC: C1653.1 U400.DV34
DDIB_AUX_DN: TP401.1 U400.AD9
DDIB_AUX_DP: TP400.1 U400.AB9
DDR3_DRAMRST#: C500.2 C2800.2 C2900.2 JDIM2800.108 JDIM2900.108 R510.2
DDR_RCOMP0: R500.1 U400.C49
DDR_VTT: C2817.1 C2818.1 C2819.1 C2821.1 C2904.1 C2908.1 C2910.1 EC2800.1 EC2802.1 EC2803.1 EC2900.1 EC2902.1 JDIM2800.258(VTT) JDIM2900.258(VTT) PC8705.1 PR8718.1 PU8700.2(VTTSNS) PU8700.20
DDR_VTT_CTRL: R512.1 U400.E52
DDR_VTT_PG_CTRL: PQ8702.2 Q500.3 R504.2 R511.2 R3307.1
DDR_VTTREF: PC8711.1 PR8707.1
DDSP_1_HPD1: Q6100.1(S) R405.1 R6115.1 U400.DF45
DEVSLP1: R4304.1 U400.DN6
DEVSLP1_R: CON4300.38 R4304.2
DG_SMBUS_SCL: R5916.1 U5900.A7
DG_SMBUS_SDA: R5918.1 U5900.B7
DGPU_EDIDCLK: R6924.1 U6600.A9
DGPU_EDIDDATA: R6926.1 U6600.B9
DGPU_HOLD_RST#: R1307.2 U400.DD8 U6601.1
DGPU_OVT#: D6901.1 Q6902.3 Q6903.3 R6946.2
DGPU_PGOK-1: C6809.1 Q6800.3 Q6801.2 R6809.1
DGPU_POK2: C6810.1 Q6802.2 R6811.1
DGPU_POK4: C6808.1 Q6800.2 R6808.1
DGPU_PRSNT#: R1124.1 R1127.1 U400.DK8
DGPU_PWR_EN: R1121.2 R1146.2 R6710.1 U400.DJ6 U6901.2 U6902.1
DISP_UTILS: TP402.1 U400.CE4
DP_RCOMP: R402.1 U400.AB1
DPB_DDCCLK: R3516.1 U400.DM29 U3501.31
DPB_DDCDATA: R3517.1 U400.DK27 U3501.32
DPWROK: C1502.1 PR8127.1 PU8102.4 R1527.2 R1528.1 U4700.E7
DPWROK_Q: PR8123.2 PR8124.2 PU8102.1 Q4703.5
DRAM_RESET#: R509.2 R510.1 U400.DV47
DSI_DE_TE_2: R403.1 U400.M8
EC_PECI: R4812.1 U400.BK9
EC_PECI_R: C4802.2 R4812.2 U4700.M7
EC_RTCRST_CTRL: D7501.1 R4744.2 R7519.1 U4700.J11
EDIDCLK_R: C3419.1 CON3400.20 R3429.2
EDIDDATA_R: C3418.1 CON3400.19 R3421.2
EMU_LID: R3409.2 U4700.J10
EN_1V8: PR9209.1 R3308.2
EN_3V: PR8606.1 R3306.2
EN_5V: PR8619.1 R3305.2
EN_5V_3V: R3301.2 R3305.1 R3306.1 R3308.1 R5406.2 R7506.1 U5401.3
EN_VRPVDDQ: D3300.2 PR8701.1 R3304.1
EN_VRPVTT: PR8703.1 R3307.2
EQ: R3507.1 R3508.1 U3501.13
ESPI_0: R1112.2 R7716.2 U4700.H1
ESPI_0_R: R1112.1 U400.DP52
ESPI_1: R1111.2 R7715.2 U4700.J1
ESPI_1_R: R1111.1 U400.DP50
ESPI_2: R1110.2 R7714.2 U4700.K1
ESPI_2_R: R1110.1 U400.DH50
ESPI_3: R1109.2 R7713.2 U4700.L1
ESPI_3_R: R1109.1 U400.DJ53
ESPI_ALERT#: TP4700.1 U4700.L3
ESPI_CLK: C1101.2 R1108.2 R4747.1 R7717.2 U4700.M1
ESPI_CLK_R: R1108.1 U400.DN53
ESPI_CS#: R1115.2 R1122.1 R7712.2 U4700.L2
ESPI_CS#_L_R: CON7702.6 R7712.1
ESPI_CS#_R: R1115.1 U400.DK52
ESPI_EC_IO0_R_R: CON7702.10 R7716.1
ESPI_EC_IO1_R_R: CON7702.9 R7715.1
ESPI_EC_IO2_R_R: CON7702.8 R7714.1
ESPI_EC_IO3_R_R: CON7702.7 R7713.1
ESPI_RESET#: R1117.2 R1123.2 R7718.2 U4700.K3
ESPI_RESET#_R: R1117.1 U400.DL50
EXT_SMI#: R628.1 U400.DF8 U4700.J4
FAN1_PWM: Q5401.5 U4700.G8
FAN1_PWM_Y: C5402.1 CON5400.4 R5402.2
FB_CAL_PD_VDDQ: R6705.2 U6600.D22
FB_CAL_PU_GND: R6706.2 U6600.C24
FB_CAL_TERM_GND: R6707.2 U6600.B25
FBA_CMD0: U6600.C27 VRAM7000.G12
FBA_CMD1: U6600.C26 VRAM7000.H10
FBA_CMD2: U6600.E24 VRAM7000.H11
FBA_CMD3: U6600.F24 VRAM7000.K11
FBA_CMD4: U6600.D27 VRAM7000.K10
FBA_CMD5: U6600.D26 VRAM7000.L12
FBA_CMD6: U6600.F25 VRAM7000.K4
FBA_CMD7: U6600.F26 VRAM7000.K5
FBA_CMD8: U6600.F23 VRAM7000.J4
FBA_CMD9: U6600.G22 VRAM7000.J5
FBA_CMD10: U6600.G23 VRAM7000.H4
FBA_CMD11: U6600.G24 VRAM7000.H5
FBA_CMD12: U6600.F27 VRAM7000.G3
FBA_CMD13: R6703.2 U6600.G25 VRAM7000.J2
FBA_CMD14: R6701.2 U6600.G27 VRAM7000.J3
FBA_CMD15: U6600.G26 VRAM7000.L3
FBA_CMD16: U6600.M24 VRAM7001.G12
FBA_CMD17: U6600.M23 VRAM7001.H10
FBA_CMD18: U6600.K24 VRAM7001.H11
FBA_CMD19: U6600.K23 VRAM7001.K11
FBA_CMD20: U6600.M27 VRAM7001.K10
FBA_CMD21: U6600.M26 VRAM7001.L12
FBA_CMD22: U6600.M25 VRAM7001.K4
FBA_CMD23: U6600.K26 VRAM7001.K5
FBA_CMD24: U6600.K22 VRAM7001.J4
FBA_CMD25: U6600.J23 VRAM7001.J5
FBA_CMD26: U6600.J25 VRAM7001.H4
FBA_CMD27: U6600.J24 VRAM7001.H5
FBA_CMD28: U6600.K27 VRAM7001.G3
FBA_CMD29: R6704.1 U6600.K25 VRAM7001.J2
FBA_CMD30: R6702.1 U6600.J27 VRAM7001.J3
FBA_CMD31: U6600.J26 VRAM7001.L3
FBA_DBI0: U6600.D19 VRAM7000.D2
FBA_DBI1: U6600.D14 VRAM7000.D13
FBA_DBI2: U6600.C17 VRAM7000.P13
FBA_DBI3: U6600.C22 VRAM7000.P2
FBA_DBI4: U6600.P24 VRAM7001.D2
FBA_DBI5: U6600.W24 VRAM7001.D13
FBA_DBI6: U6600.AA25 VRAM7001.P13
FBA_DBI7: U6600.U25 VRAM7001.P2
FBA_EDC0: U6600.E19 VRAM7000.C2
FBA_EDC1: U6600.C15 VRAM7000.C13
FBA_EDC2: U6600.B16 VRAM7000.R13
FBA_EDC3: U6600.B22 VRAM7000.R2
FBA_EDC4: U6600.R25 VRAM7001.C2
FBA_EDC5: U6600.W23 VRAM7001.C13
FBA_EDC6: U6600.AB26 VRAM7001.R13
FBA_EDC7: U6600.T26 VRAM7001.R2
FBVDD_EN: PR10208.2 R6712.2 U6701.4(Y)
FBVDD_PWROK: PR10204.2 Q6801.3 R1145.2 R6807.1 R6810.2 U400.DM6 U6901.1
FBVDDQ_GPU: C6700.2 C6701.2 C6702.2 C6703.2 C6704.2 C6705.2 C6706.2 C6707.2 C6708.2 C6709.2 C6710.2 C6711.2 C6712.2 C6713.2 C7215.1 C7216.2 PR10215.2 R6701.1 R6702.2 R6708.1 R6709.1 U6600.B26 U6600.C25 U6600.E23 U6600.E26 U6600.F14 U6600.F21 U6600.G13 U6600.G14 U6600.G15 U6600.G16 U6600.G18 U6600.G19 U6600.G20 U6600.G21 U6600.H24 U6600.H26 U6600.J21 U6600.K21 U6600.L22 U6600.L24 U6600.L26 U6600.M21 U6600.N21 U6600.R21 U6600.T21 U6600.V21 U6600.W21
FBVDDQ_MEM: C7000.2 C7001.2 C7002.2 C7003.2 C7004.2 C7005.2 C7006.2 C7007.2 C7008.2 C7009.2 C7010.2 C7011.2 C7012.2 C7013.2 C7014.2 C7015.2 C7016.2 C7017.2 C7018.2 C7019.2 C7020.2 C7021.2 C7022.1 C7023.1 C7024.1 C7025.1 C7026.1 C7027.1 C7028.1 C7029.2 C7030.2 C7031.2 C7032.2 C7033.2 C7034.2 C7035.2 C7036.2 C7037.2 C7038.2 C7039.2 C7040.2 C7041.2 C7042.2 C7043.1 C7044.1 C7045.1 C7046.1 C7047.1 C7048.1 C7049.1 C7050.1 C7051.1 C7052.1 C7053.1 C7054.1 C7055.1 C7056.1 C7057.1 PR10202.2 PR10213.1 R6705.1 R6811.2 R7000.1 R7009.1 R7011.1 VRAM7000.B1 VRAM7000.B3 VRAM7000.B12 VRAM7000.B14 VRAM7000.C5 VRAM7000.C10 VRAM7000.D1 VRAM7000.D3 VRAM7000.D11 VRAM7000.D12 VRAM7000.D14 VRAM7000.E5 VRAM7000.E10 VRAM7000.F1 VRAM7000.F3 VRAM7000.F12 VRAM7000.F14 VRAM7000.G1 VRAM7000.G2 VRAM7000.G4 VRAM7000.G11 VRAM7000.G13 VRAM7000.G14 VRAM7000.H3 VRAM7000.H12 VRAM7000.K3 VRAM7000.K12 VRAM7000.L1 VRAM7000.L2 VRAM7000.L4 VRAM7000.L11 VRAM7000.L13 VRAM7000.L14 VRAM7000.M1 VRAM7000.M3 VRAM7000.M12 VRAM7000.M14 VRAM7000.N5 VRAM7000.N10 VRAM7000.P1 VRAM7000.P3 VRAM7000.P11 VRAM7000.P12 VRAM7000.P14 VRAM7000.R5 VRAM7000.R10 VRAM7000.T1 VRAM7000.T3 VRAM7000.T12 VRAM7000.T14 VRAM7001.B1 VRAM7001.B3 VRAM7001.B12 VRAM7001.B14 VRAM7001.C5 VRAM7001.C10 VRAM7001.D1 VRAM7001.D3 VRAM7001.D11 VRAM7001.D12 VRAM7001.D14 VRAM7001.E5 VRAM7001.E10 VRAM7001.F1 VRAM7001.F3 VRAM7001.F12 VRAM7001.F14 VRAM7001.G1 VRAM7001.G2 VRAM7001.G4 VRAM7001.G11 VRAM7001.G13 VRAM7001.G14 VRAM7001.H3 VRAM7001.H12 VRAM7001.K3 VRAM7001.K12 VRAM7001.L1 VRAM7001.L2 VRAM7001.L4 VRAM7001.L11 VRAM7001.L13 VRAM7001.L14 VRAM7001.M1 VRAM7001.M3 VRAM7001.M12 VRAM7001.M14 VRAM7001.N5 VRAM7001.N10 VRAM7001.P1 VRAM7001.P3 VRAM7001.P11 VRAM7001.P12 VRAM7001.P14 VRAM7001.R5 VRAM7001.R10 VRAM7001.T1 VRAM7001.T3 VRAM7001.T12 VRAM7001.T14
FCCM: PR8903.1 PR8910.1 PU8800.13
FCCM_PH1: PR8903.2 PU8900.1
FCCM_PH2: PR8910.2 PU8901.1
FN_KEY_LED#: C5034.2 R4807.1 R5004.1 U4700.A10
FP_FUSE_SRC: C6684.2 R6619.2 U6600.AB6 U7601.6
FPR_LOCK#: C5202.1 CON5200.6 R5202.2 U400.DW21
FPR_OFF#: C5202.2 CON5200.7 R807.1 U400.DR27
FT_DIGITAL_CLK: L3401.1 R1545.2 U400.DL53
FT_DIGITAL_CLK_L: C3410.1 CON3400.8 L3401.2
FT_DIGITAL_D1: Q3406.3 R3435.2 U400.DG51
FT_DIGITAL_D1_L: C3416.1 CON3400.7 L3402.2
GC6_FB_EN: Q6901.2 Q6903.2 R6962.1 U6600.B2 U6701.1
GC6_FB_EN_Q: Q6901.3 R1413.1 R6943.1 U400.DJ25
GPD7: R1214.2 R1219.1 U400.DN43
GPIO10_VREF: Q7000.2 Q7001.2 R6964.2 U6600.C5
GPIO18_FP_FUSE: R6618.2 U6600.C2 U7601.4
GPIO40: TP4800.1 U4700.E5
GPP_B18: R1220.2 U400.DA51
GPP_B23: R1223.2 R1228.1 U400.CY50
GPP_RCOMP: R800.1 U400.DR51
GPPC_E6: R1230.1 R1231.1 R1233.1 U400.DT8
GPS_XMIT_OFF#: CON4202.26 R627.1 U400.DB42
GPU_BST1: PC9907.1 PU9900.21
GPU_BST2: PC9918.1 PU9901.21
GPU_CS1: PR9822.2 PU9800.16 PU9900.18
GPU_CS2: PR9823.2 PU9800.15 PU9901.18
GPU_EVENT#: D6900.1(CATHODE) R1119.2 U400.DK6
GPU_EVENT#_GPU: D6900.2 R6956.1 U6600.D6
GPU_PWM1: PR9814.1 PU9900.15
GPU_PWM2: PR9816.1 PU9901.15
GPU_SW1: PC9907.2 PL9900.1 PR9901.1 PU9900.2 PU9900.3 PU9900.4
GPU_SW2: PC9918.2 PL9901.1 PR9902.1 PU9901.2 PU9901.3 PU9901.4
GPU_SYNC: PR9830.1 PR9831.2 PR9832.2 PU9900.16 PU9901.16
GPU_TEMP: PR9820.1 PU9900.17(VTEMP/FLT) PU9901.17(VTEMP/FLT)
GPU_VCC_SENSE: PR9813.2 PR9815.1 U6600.F2
GPU_VID: PR9804.1 U6600.C6
GPU_VSS_SENSE: PR9809.1 PR9811.2 U6600.F1
GPUT_CLK_L: Q6900.4(S2) R6927.2 U6600.D9
GPUT_DATA_L: Q6900.1 R6923.2 U6600.D8
H_CATERR#: R600.1 U400.M7
H_VCCST_PWRGD: R1566.2 U400.BP8
H_VCCST_PWRGD_R: C1503.2 D1500.2 R1561.2 R1566.1
HD_SDIN0: R3614.2 U3600.7
HDMI_HPD: C3504.1 CON3501.19 U3501.25 VC3500.1
HDMI_HPD_CON: R404.1 U400.DG43 U3501.3
HDMI_UP_CLK: C3527.1 CON3501.15 R3509.2 U3501.28
HDMI_UP_DATA: C3526.1 CON3501.16 R3514.2 U3501.29
HOLD#_7: R6841.2 TP6809.1 U6801.7(\\S\P\I\_\H\O\L\D)
HOOK2: CON7703.45 R7703.1 R7710.2
HOOK3: C5606.2 CON7703.47 R5635.2 R5636.2
HPOUT_JD: CON3700.6 D3701.1 R3609.2
HPOUT_L: R3602.1 R3701.2
HPOUT_L_C: C3702.2 CON3700.1 D3700.2 R3701.1
HPOUT_L_L: R3602.2 U3600.25
HPOUT_R: R3601.1 R3702.2
HPOUT_R_C: C3700.2 CON3700.2(R) D3702.1 R3702.1
HPOUT_R_R: R3601.2 U3600.26
I2C_CLICK_SCL: C5206.1 CON5202.7 R5208.1
I2C_CLICK_SDA: C5208.1 CON5202.6 R5211.1
I2C_INT_M2: CON4202.28 R4233.2
I2C_SCL_M2: CON4202.20 R4231.2
I2C_SDA_M2: CON4202.24 R4232.2
I2C_TS_SCL: CON3400.21 R3403.2 U400.DJ23
I2C_TS_SDA: CON3400.22 R3401.2 U400.DT18
I2CA_SCL: R6800.1 U6600.B7
I_ADP_ADC0: PR8233.1 R4710.2
I_ADP_ADC0_R: C4708.2 R4710.1 U4700.F2
I_DCHG_ADC1: PR8234.1 R4712.2
I_DCHG_ADC1_R: C4709.2 R4712.1 U4700.E3
I_SET: PQ8401.3 PR8209.2
IFP_IOVDD_1: U6600.W6
IFP_IOVDD_2: U6600.Y6
IFPAB_PLLVDD: U6600.W7
ILIM_H: R6200.1 U6203.16
ILIM_LO: R6201.1 U6203.15
ILIM_SEL: R4822.2 R6202.2 U4700.A12 U6203.4
IM_5S_CLK: R4719.2 R5203.1 U4700.C1
IM_5S_DAT: R4718.2 R5204.1 U4700.B2
IMVP_PSYS: PC8226.1 PR8236.2 PR8836.2
IN_CLK: C3523.2 U400.T12
IN_CLK#: C3524.2 U400.T11
IN_D0: C3521.2 U400.Y11
IN_D0#: C3522.2 U400.Y9
IN_D1: C3507.2 U400.T9
IN_D1#: C3508.2 U400.P9
IN_D2: C3505.2 U400.V11
IN_D2#: C3506.2 U400.V9
INB0_SCL: R1901.2 U1800.A1 U1801.A1 U1802.A1 U1802.C3 U1803.A1 U1804.A1 U1806.A1 U1806.B3 U1807.A1 U1809.A1 U1809.C3 U1903.A1 U1905.A1 U1905.B3 U1907.A1 U1907.B3 U2000.A1 U2001.A1 U2008.A1
INB0_SDA: R1902.2 U1800.A2 U1801.A2 U1802.A2 U1803.A2 U1804.A2 U1806.A2 U1807.A2 U1807.C3 U1809.A2 U1903.A2 U1903.B3 U1905.A2 U1905.C3 U1907.A2 U2000.A2 U2000.C3 U2001.A2 U2001.B3 U2001.C3 U2008.A2 U2008.B3
INB1_SCL: R1903.2 U1805.A1 U1900.A1 U1902.A1 U1904.A1 U1906.A1 U1908.A1 U1908.B3 U1909.A1 U2002.A1 U2004.A1 U2005.A1 U2005.B3 U2006.A1 U2007.A1 U2007.C3 U2010.A1 U2010.C3
INB1_SDA: R1904.2 U1805.A2 U1805.B3 U1900.A2 U1900.C3 U1902.A2 U1902.B3 U1902.C3 U1904.A2 U1906.A2 U1906.B3 U1908.A2 U1909.A2 U1909.C3 U2002.A2 U2004.A2 U2005.A2 U2006.A2 U2007.A2 U2007.B3 U2010.A2
INPUT3VSEL: R1247.2 R1249.1 U400.DT49
INT_BT_OFF#: CON4100.54(W_DISABLE2#) Q4106.3 R4118.2
INT_EDP_AUXN: C3418.2 U400.AJ1
INT_EDP_AUXP: C3419.2 U400.AJ2
INT_EDP_TXN0: C3417.2 U400.AG1
INT_EDP_TXN1: C3411.1 U400.AF2
INT_EDP_TXP0: C3415.2 U400.AG2
INT_EDP_TXP1: C3409.1 U400.AF1
INT_RF_OFF#: CON4100.56 Q4108.3 R4132.2
INTRUDER#: C1500.1 R1237.2 R1240.1 U400.DM37
INV_PWM_R: R3433.1 U3405.3
ISH_AE_INT_K: TP800.1 U400.DV27
ISL95860_ALERT#: PR8833.2 PU8800.28
ISL95860_CLK: PR8835.2 PU8800.29
ISL95860_COMP: PC8805.2 PR8818.1 PU8800.5
ISL95860_EN: PC8811.2 PR8827.2 PU8800.32
ISL95860_FB: PR8828.1 PR8830.2 PR8834.2 PU8800.6
ISL95860_HOT#: PR8829.2 PU8800.30
ISL95860_IMON: PC8818.2 PR8840.1 PU8800.2
ISL95860_ISEN1: PC8809.1 PR8806.2 PR8807.1 PR8846.1 PU8800.10
ISL95860_ISEN2: PC8810.1 PR8812.2 PR8815.1 PR8845.1 PU8800.11
ISL95860_ISEN3: PR8826.1 PU8800.12
ISL95860_ISUMN: PC8803.2 PC8804.2 PC8808.1 PC8809.2 PC8810.2 PR8814.2 PR8817.1 PR8819.2 PR8820.2 PR8821.2 PR8823.2
ISL95860_ISUMN_R: PC8807.1 PR8820.1 PU8800.8
ISL95860_ISUMP: PC8803.1 PC8804.1 PR8808.2 PR8810.1 PR8814.1 PR8816.2 PU8800.9
ISL95860_NTC: PC8817.2 PR8839.1 PU8800.3
ISL95860_PROG1: PR8809.1 PU8800.24
ISL95860_PROG2: PR8811.1 PU8800.23
ISL95860_PROG3: PR8813.1 PU8800.22
ISL95860_PSYS: PC8819.2 PR8836.1 PR8838.1 PU8800.1
ISL95860_RTN: PC8815.1 PC8816.2 PR8837.2 PR8844.2 PU8800.7
ISL95860_SDA: PR8831.2 PU8800.27
ISL95860_SLOPE: PR8822.1 PU8800.4
ISL95860_VDD: PC8802.1 PR8805.2 PU8800.26
ISL95860_VIN: PC8801.2 PR8804.2 PU8800.25
ISL95860_VRRDY: PR8824.1 PR8825.2 PU8800.31(VR_READY)
IST_TP_0: TP1012.1 U400.A4
IST_TP_1: TP1011.1 U400.A6
ITP_PMODE: CON7703.46 R7706.2 R7724.2
JTAG_TCK: TP6905.1 U6600.AE5
JTAG_TDI: TP6907.1 U6600.AE6
JTAG_TDO: TP6908.1 U6600.AF6
JTAG_TMS: TP6906.1 U6600.AD6
JTAG_TRST#: R6963.1 U6600.AG4
KBC_PWR_ON: PR9513.2 PR9522.1 PR10625.1 R4806.1 U1600.3 U4700.G7
KBC_PWR_ON_3: PR9505.2 PR9522.2
KBL_DET#: CON5002.6 R626.1 U400.DB41
KBSWON: R5027.1 SW5000.1
KSI0: D5000.6 R5015.1 U4700.A2
KSI1: D5000.3 R5015.2 U4700.A3
KSI2: D5001.6 R5015.3 U4700.A4
KSI3: D5001.3 R5015.4 U4700.B3
KSI4: D5002.6 R5015.8 U4700.B4
KSI5: D5002.3 R5015.7 U4700.C3
KSI6: D5003.6 R5015.6(R9) U4700.C4
KSI7: CON5000.20 R5015.9 U4700.C5
KSI_D_0: CON5000.34 D5000.1
KSI_D_1: CON5000.31 D5000.5
KSI_D_2: CON5000.32 D5001.1
KSI_D_3: CON5000.30 D5001.5
KSI_D_4: CON5000.33 D5002.1
KSI_D_5: CON5000.22 D5002.5
KSI_D_6: CON5000.21 D5003.1
KSI_D_8: CON5000.37 D5000.2
KSI_D_9: CON5000.17 D5000.4
KSI_D_10: CON5000.35 D5001.2
KSI_D_11: CON5000.18 D5001.4
KSI_D_12: CON5000.36 D5002.2
KSI_D_13: CON5000.19 D5002.4
KSI_D_14: CON5000.38 D5003.2
KSO0: CON5000.41 CON7702.17 U4700.B5
KSO1: CON5000.23 CON7702.18 U4700.B6
KSO2: CON5000.40 CON7702.20 U4700.B7
KSO3: CON5000.29 CON7702.19 U4700.B8
KSO4: CON5000.27 U4700.C7
KSO5: CON5000.39 U4700.C6
KSO6: CON5000.25 U4700.C8
KSO7: CON5000.26 CON7702.21 R4815.2 U4700.B9
KSO8: CON5000.28 U4700.C9
KSO9: CON5000.16 U4700.C10
KSO10: CON5000.24 U4700.B11
KSO11: CON5000.42 U4700.B10
KSO12: CON5000.15 R5014.1 U4700.C11
KSO13: CON5000.14 U4700.D11
L_SPK+: C3625.2 CON3601.1 U3600.35
L_SPK-: C3626.2 CON3601.2 U3600.36
LAN_DIS#: CON7602.38 R1539.2 U400.DT41
LAN_PWR_ON: PC9514.1 PU9501.3 R4750.1 R4751.1
LAN_PWR_ON_EC: R4750.2 R4752.1 R4753.2 U4700.D10
LAN_WAKE#: CON7602.35 R1531.2 U400.DM41
LANLINK_STATUS: CON7602.34 R814.1 U400.DF21

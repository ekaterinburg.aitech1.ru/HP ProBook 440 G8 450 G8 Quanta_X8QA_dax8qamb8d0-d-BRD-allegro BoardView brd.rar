# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17285548: length 1.2
  TOP w0.109: U5100.32 161.07,60.62 161.01,60.67 R5121.1
N17285713: length 2.4
  TOP w0.109: R5122.1 164.68,57.99 164.43,58.23 164.43,59.13 164.89,59.59 U5100.6
N18345378: length 1.6
  BOTTOM w0.109: R5408.1 31.01,72.24 30.67,72.58 U5401.1
N18490206: length 3.1
  TOP w0.109: R3514.1 204.3,49.33 203.01,49.33 v1(202.79,49.55) 202.59,49.35 202.12,49.35 202.04,49.27 D3500.2
N18697895: length 1.3
  TOP w0.109: C4722.2 202.97,12.82 202.97,13.12 R4747.2
N18861075: length 0.8
  TOP w0.109: R5110.2 165.02,66.75 165.05,66.77 C5108.2
N20937188: length 3
  BOTTOM w0.109: Q5401.3 33.9,58.1 33.55,57.76 R5402.1 33.34,57.34 33.12,57.12 R5401.2 32.46,57.12 v1(32.23,57.35)
N20937236: length 3.3
  BOTTOM w0.109: Q5401.4 35.7,58.1 35.51,57.91 35.51,56.92 35.62,56.8 Q5401.6 36.28,56.8 36.5,56.59 v1(36.5,56.16)
N21479772: length 5.3
  BOTTOM w0.109: Q6802.3 v1(41.7,58.27) 42.13,58.27 42.91,57.49 43.19,57.49 R6812.2 43.52,57.49 44.83,57.49 Q6800.1
N23161371: length 1.9
  TOP w0.109: R5127.2 169.72,64.59 R5130.1 168.83,65 168.83,65 Q5101.6
N23161400: length 1.8
  TOP w0.109: Q5101.5 168.48,65.07 168.38,64.97 R5130.2 C5112.2
N25318825: length 2.4
  BOTTOM w0.109: PQ8004.3 142.05,99.17 PR8006.1
N25319146: length 8.3
  TOP w0.109: PQ8002.2 v1(146.66,101) 146.29,101 145.74,101.55 v1(145.74,101.69)
  BOTTOM w0.109: PR8001.2 145.74,102.03 v1(145.74,101.69) 145.74,100.66 145.09,100.01 145.09,99.12 145.01,99.03 142.69,99.03 PR8006.2
N25319276: length 2.1
  BOTTOM w0.508: v1(153.21,98.65) 153.21,98.55 152.61,97.95 PQ8000.4
N26788301: length 5.7
  TOP w0.109: v1(199.31,49.02) 200,49.02 D3500.1 200.56,49.27 201.09,48.74 201.99,48.74 202.35,49.1 204.13,49.1 R3509.1
N27239944: length 1.7
  TOP w0.203: PR8710.1 104.33,9.08 PU8700.3
N27265640: length 3.5
  TOP w0.109: PU9501.5 25.52,9.8 25.49,9.77 25.49,8.52 25.81,8.19 PC9517.1 26.02,8.08 26.6,7.51 PR9507.1
N27265648: length 2
  TOP w0.109: PC9515.1 24.36,13.61 v1(24.36,13.1) 24.72,12.74 PU9501.12
N27265649: length 2
  TOP w0.109: PC9516.1 25.02,13.71 v1(25.63,13.1) 25.52,13 PU9501.10
N27265691: length 4.5
  TOP w0.109: PR9505.1 156.33,15.55 PC9521.1 156.33,15.26 156.69,14.9 156.69,14.37 v1(156.36,14.04) 155.95,13.64 155.95,12.92 155.91,12.88 PU9500.5
N27265699: length 2.5
  TOP w0.109: PC9519.1 156.61,8.41 156.73,8.52 156.73,9.83 156.71,9.85 PU9500.12
N27265700: length 2.7
  TOP w0.109: PC9520.1 155.99,8.28 155.99,8.98 155.91,9.06 PU9500.10
N27265702: length 3.3
  TOP w0.109: PU9500.3 156.71,13.1 157.75,14.14 PC9518.1 157.75,14.49 157.86,14.61 PR9504.2
N27303349: length 3.4
  TOP w0.109: PU9502.5 176.39,66 v1(176.48,65.91) 176.48,65.34 PC9543.1 176.72,65.12 PR9514.2
N27303375: length 5.4
  TOP w0.109: PU9502.3 175.59,66.34 174.41,65.16 174.15,65.16 v1(173.94,64.95) 173.81,64.82 173.81,64.56 173.69,64.45 PC9536.1 173.69,63.7 173.53,63.54 PR9513.1
N27367629: length 3.4
  TOP w0.203: PC10513.1 90.42,74.88 v1(90.12,74.57) 89.81,74.26 PU10501.5
  TOP w0.508: PD10500.2 90.92,76.03 PC10513.1
N27367762: length 2.5
  TOP w0.109: PU10501.10 86.69,74.26 v1(85.88,75.08) PC10515.1
N27367840:
  vias: v1(87.83,72.21) v1(87.96,75.56) v1(88.42,76.02) v1(88.62,71.6) v1(88.87,76.48) v1(89.08,72.06) v1(89.53,71.55)
N27367864:
  vias: v1(86.92,76.02)
N27367912: length 2.4
  TOP w0.109: PC10514.1 85.57,74.09 85.88,73.78 v1(86.24,73.78) 86.56,73.46 PU10501.12
N27367918: length 4.2
  TOP w0.109: PU10501.3 89.73,73.46 90.02,73.17 90.55,73.17 90.95,72.77 PC10516.1 91.54,71.9 PR10517.2 91.54,70.89 v1(91.51,70.86)
N27368301: length 4.7
  BOTTOM w0.109: PR10507.2 50.11,57.45 PR10509.1 50.7,58.01 v1(50.9,58.21) 50.94,58.25 PQ10500.6 52.54,58.25 52.65,58.14 52.65,57.71 52.55,57.6 PQ10500.5
N27368325:
  vias: v1(54.86,56.16)
N27673930: length 1.3
  TOP w0.109: PR8713.1 107.62,8.28 PQ8702.3
N30709649: length 3.5
  BOTTOM w0.109: VRAM7001.J13 35.52,70.08 34.14,70.08 33.7,70.51 33.12,70.51 33.04,70.58 R7005.2
N30709654: length 5.5
  BOTTOM w0.109: VRAM7000.J13 35.58,88.14 34.09,88.14 32.84,86.88 v1(32.84,86.62) 32.58,86.37 R7003.2
N30882249: length 2
  TOP w0.109: C7060.1 34.89,87.98 R7015.2 R7014.2
N30885322: length 2.1
  TOP w0.109: C7059.1 34.69,71.09 R7008.2 R7010.2
N31840009: length 3.1
  TOP w0.109: v1(129.28,8.01) 129.43,8.15 R5002.2
  BOTTOM w0.109: v1(129.28,8.01) 129.64,8.37 CON5000.5
N31840087: length 2.6
  TOP w0.109: v1(127.96,10.8) 127.7,10.53 R5007.2
  BOTTOM w0.109: CON5000.8 128.14,10.62 v1(127.96,10.8)
N31840108: length 2.5
  TOP w0.109: v1(127.33,10.8) 127.29,10.83 R5009.2
  BOTTOM w0.109: CON5000.9 127.64,10.48 v1(127.33,10.8)
N31840152: length 4.3
  TOP w0.109: R5004.2 128.48,8.12 v1(128.59,8.01)
  BOTTOM w0.109: v1(128.59,8.01) 128.11,7.53 127.64,7.53 126.64,8.53 CON5000.11
N31840183: length 2.5
  TOP w0.109: v1(126.2,10.79) 125.86,11.13 R5011.2
  BOTTOM w0.109: CON5000.12 126.14,10.03 126.2,10.09 v1(126.2,10.79)
N32484985: length 15.7
  TOP w0.109: PQ8008.2 169.55,101.61 165.3,105.86 v1(164.26,105.86) 163.14,105.86 162.79,106.22 159.18,106.22 158.97,106.43 157.23,106.43 156.95,106.15 PR8015.1 156.95,105.71 PR8014.2
N32484987: length 8
  TOP w0.109: PR8020.1 162.2,103.89 161.75,104.34 PR8019.2 161.21,104.34 161.06,104.19 161.06,103.53 v1(160.75,103.22) 160.44,103.54 160.44,104.63 158.85,106.22 157.62,106.22 PR8015.2
N32485009: length 9.3
  TOP w0.109: PQ8008.3 167.6,103.23 165.41,105.42 162.87,105.42 v1(162.6,105.7) 162.43,105.86 161.59,105.86 161.47,105.74 PR8021.1 160.57,105.51 PQ8011.2
N32890326: length 7.3
  TOP w0.109: R4301.1 11.41,5.29 v1(10.83,5.88)
  IN1 w0.079: v1(10.83,5.88) 9.74,6.96 8.97,6.96 v1(7.01,5)
  BOTTOM w0.109: CON4300.12 v1(7.01,5)
N34650123: length 1.4
  TOP w0.109: R4136.1 197.38,67.92 Q4111.2
N34650132: length 6.9
  TOP w0.109: R4133.2 194.28,68.82 Q4111.3 194.86,70.47 194.63,70.7 R4135.1 193.74,70.7 191.9,68.85 Q4108.2
N36049795: length 1.7
  BOTTOM w0.109: R4128.2 181.76,80.93 181.76,80.31 181.84,80.23 CON4100.38
N36049798: length 1.8
  BOTTOM w0.109: R4129.2 182.7,80.44 182.34,80.08 CON4100.40
N36049801: length 1.9
  BOTTOM w0.109: CON4100.42 182.84,80.15 183.11,80.41 183.11,80.72 R4130.2
N36756780: length 53.2
  TOP w0.254: PQ8703.3 161.08,16.26 160.78,16.56 158.47,16.56 v1(157.96,16.05) ; 116.94,13.56 117.4,13.1 v1(117.7,13.1) 117.9,13.1 118.51,12.49 119.28,12.49 119.6,12.81 119.6,14.23 121.87,16.5 122.52,16.5 123,16.98 123,18.26 123.26,18.51 125.08,18.51 125.34,18.26 125.34,17.79 v1(125.54,17.59)
  IN2 w0.254: v1(125.54,17.59) 126.65,16.48 130.07,16.48 130.76,17.17 135.66,17.17 136.69,16.13 140.95,16.13 142.14,17.32 144.32,17.32 144.57,17.07 147.88,17.07 148.79,17.98 155.6,17.98 156.64,16.94 157.07,16.94 v1(157.96,16.05)
N37096665: length 0.9
  BOTTOM w0.109: PR8016.1 175.33,91.75 PQ8012.3
N37096667: length 6.7
  BOTTOM w0.109: PQ8012.6 178.12,89.56 178.89,89.56 179.14,89.81 PR8023.2 179.55,90.25 v1(179.55,89.53) PQ8006.4
N37096688: length 3.5
  BOTTOM w0.109: PQ8012.2 PQ8012.5 177.98,90.73 178.05,90.65 PR8025.1 178.43,90.09 v1(178.33,89.99)
N37096692: length 13.8
  BOTTOM w0.109: PD8001.2 174.68,91.39 174.98,91.69 174.98,92.76 175.16,92.94 v1(175.16,95.65) 175.16,96.37 175.08,96.44 175.08,99.21 175.7,99.83 PQ8009.2 175.43,100.23 175.11,100.23 174.8,100.53 174.8,100.81 174.32,101.29 PR8018.2 173.83,101.88 173.47,102.24 PQ8010.2
N37096694: length 2.5
  BOTTOM w0.109: v1(176.25,82.27) 175.82,81.84 175.23,81.84 175.13,81.93 PR8017.1 175.02,82.35 PQ8013.3
N37096728: length 3.7
  BOTTOM w0.109: PR8026.1 PQ8013.2 174.15,83.13 172.87,83.13 172.74,83 PQ8013.5 171.83,83 v1(171.65,83.18)
N37096732:
  vias: v1(174.01,84.5)
N37096738: length 29.6
  TOP w0.109: v1(172.03,100.53) 172.67,100.53 173.18,100.02 173.18,93.57 v1(172.51,92.9) 171.55,91.95 170.28,91.95 169.32,92.9 169.32,94.33 v1(169.26,94.38)
  BOTTOM w0.109: PQ8013.4 171.96,82.35 171.55,82.77 171.48,82.8 171.35,82.8 171.1,83.05 171.1,83.22 170.89,83.43 169.78,83.43 169.5,83.7 169.5,89.24 169.67,89.41 169.67,93.04 169.26,93.44 v1(169.26,94.38) ; PQ8010.1 172.22,100.34 v1(172.03,100.53)
N37096862: length 8.7
  BOTTOM w0.109: PQ8009.1 177.25,97.93 v1(178.15,97.03) 178.15,93.24 177.98,93.06 177.98,92.63 178.13,92.48 178.13,92.07 177.6,91.55 PQ8012.4
N37277040: length 4.3
  TOP w0.109: v1(188.54,16.18) 188.54,16.58 C4707.2 189.59,17.63 190.35,17.63 190.38,17.6 191.41,17.6 191.78,17.97 U4700.A6
N37543651: length 1.4
  TOP w0.109: R3515.1 201.34,53.26 200.86,53.75 U3501.16
N37586765: length 2.6
  TOP w0.109: C3525.1 202.45,53.07 202.08,53.44 202.08,54 201.9,54.18 201.9,54.84 201.77,54.97 U3501.17
N38095593: length 2.5
  BOTTOM w0.109: CON4300.75 14.73,20.75 v1(15.01,21.03) 15.31,21.33 R4311.2
N38480242: length 1.9
  BOTTOM w0.109: CON4100.64 188.34,80.49 TP4104.1
N38512591: length 0.9
  TOP w0.254: R2821.2 154.12,24.05 154.02,23.95 C2828.2
N38515705: length 2.4
  TOP w0.109: R2920.1 114.93,21.96 C2929.2 114.63,21.71 114.17,21.26 113.84,21.26 113.71,21.13 C2928.2
N38936226: length 19.2
  TOP w0.381: v1(54.91,16.08) 54.5,15.66 PQ8202.6
  IN3 w0.254: v1(54.91,16.08) 55.07,16.23 58.8,16.23 59.62,15.41 60.01,15.41 61.14,16.53 63.19,16.53 63.49,16.24 68.06,16.24 v1(68.48,15.82)
  BOTTOM w0.254: v1(68.48,15.82) 68.48,15.67 68.07,15.27 PR8207.1 v1(67.03,15.27) 67,15.27 PQ8200.4
N38936233: length 3
  TOP w0.109: PQ8201.2 56.07,17.08 v1(55.8,17.35) 55.22,17.35 PR8204.1 54.06,17.16 PD8201.2
N38936236: length 230.9
  TOP w0.254: v1(61.84,15.58) 61.28,15.58 60.2,14.49 60.2,13.04 PC8203.2 60.05,12.28 PC8204.1 59.65,11.35 PR8205.1
  IN1 w0.254: v1(171.89,34.74) 172.06,34.92 172.21,34.92 173.53,33.61 174.26,33.61 175.11,32.76 175.11,32.36 175.71,31.75 176.97,31.75 180.21,28.5 180.64,28.5 181.26,27.88 181.88,27.88 182.42,27.35 182.42,26.2 181.9,25.69 181.9,24.11 183.5,22.5 183.5,20.14 184.07,19.57 184.07,18.08 182.14,16.15 180.88,16.15 180.56,15.82 180.36,15.74 180.09,15.74 179.3,16.53 173.38,16.53 172.31,17.6 170.48,17.6 169.74,17.29 165.87,17.29 165.59,17.02 155.82,17.02 155.1,16.3 152.96,16.3 152.69,16.03 148.6,16.03 147.99,15.41 136.14,15.41 135.82,15.09 132.09,15.09 131.18,16 125.56,16 124.69,15.12 115.57,15.12 115,14.55 110.98,14.55 109.69,13.26 106.94,13.26 106.18,14.02 97.97,14.02 97.7,13.75 93.88,13.75 93.19,14.44 93.19,14.69 91.95,15.93 89.37,15.93 88.84,15.39 88.17,15.39 87.95,15.62 80.71,15.62 78.77,17.55 73.14,17.55 70.9,15.32 65.54,15.32 64.8,16.05 62.31,16.05 v1(61.84,15.58)
  IN2 w0.254: v1(183.67,53.54) 183.67,57.48 183.84,57.65 183.84,65.3 185.53,66.99 185.53,68.88 186.27,69.19 186.48,69.4 186.48,69.93 184.27,72.13 184.27,72.77 183.89,73.15 183.89,74.83 183.15,75.56 183.15,77.34 178.87,81.62 178.87,84.36 177.72,85.51 177.72,85.67 177.44,85.95 v1(177.37,85.95)
  BOTTOM w0.254: v1(177.37,85.95) 177.41,85.95 PR8201.1 ; v1(171.89,34.74) 171.58,35.05 170.19,35.05 169.01,36.23 169.01,37.03 169.49,37.51 169.49,38.45 172.31,41.27 172.31,42.58 172.86,43.14 173.99,43.14 175.61,44.75 175.61,46.67 176.14,47.2 176.96,47.2 177.39,47.63 177.39,49.77 177.76,50.14 178.79,50.14 179.45,49.48 179.81,49.48 180.51,50.19 180.51,52.98 181.24,53.71 183.27,53.71 183.55,53.43 v1(183.67,53.54)
N38936237: length 231.5
  TOP w0.254: v1(62.5,15.58) 62.33,15.41 62.33,15.37 62.04,15.08 61.26,15.08 60.53,14.35 60.53,13.42 PC8205.1 60.43,12.28 PC8204.2 60.2,11.65 PR8206.1
  IN1 w0.254: v1(171.89,35.51) 172.14,35.25 172.35,35.25 173.66,33.94 174.4,33.94 175.44,32.9 175.44,32.49 175.85,32.08 177.1,32.08 180.35,28.83 180.78,28.83 181.4,28.22 182.01,28.22 182.75,27.48 182.75,26.07 182.23,25.55 182.23,24.24 183.83,22.64 183.83,20.28 184.4,19.71 184.4,17.94 182.28,15.82 181.02,15.82 180.74,15.54 180.43,15.41 179.95,15.41 179.17,16.2 173.24,16.2 172.17,17.27 170.55,17.27 170.55,17.27 169.8,16.96 166.01,16.96 165.73,16.68 155.96,16.68 155.24,15.97 153.1,15.97 152.83,15.7 148.74,15.7 148.13,15.08 136.28,15.08 135.95,14.76 131.95,14.76 131.04,15.67 125.7,15.67 124.82,14.79 115.71,14.79 115.13,14.22 111.12,14.22 109.83,12.93 106.8,12.93 106.05,13.69 98.1,13.69 97.83,13.42 93.74,13.42 92.86,14.3 92.86,14.55 91.82,15.6 89.51,15.6 88.97,15.06 88.03,15.06 87.81,15.29 80.57,15.29 78.64,17.22 73.28,17.22 71.04,14.98 65.4,14.98 64.67,15.72 62.64,15.72 v1(62.5,15.58)
  IN2 w0.254: v1(178.23,85.95) 178.05,85.77 178.05,85.65 179.21,84.49 179.21,81.76 183.49,77.48 183.49,75.7 184.22,74.97 184.22,73.29 184.61,72.91 184.61,72.27 186.81,70.06 186.81,69.26 186.46,68.91 185.86,68.66 185.86,66.85 184.17,65.16 184.17,57.52 184,57.34 184,53.92 v1(184.35,53.57)
  BOTTOM w0.254: v1(184.35,53.57) 184.35,53.53 183.87,53.05 183.46,53.05 183.13,53.37 181.38,53.37 180.85,52.84 180.85,50.05 179.94,49.15 179.31,49.15 178.65,49.81 177.9,49.81 177.72,49.63 177.72,47.49 177.1,46.86 176.27,46.86 175.94,46.53 175.94,44.62 174.13,42.81 173,42.81 172.64,42.45 172.64,41.13 169.82,38.32 169.82,37.38 169.34,36.89 169.34,36.37 170.33,35.38 171.76,35.38 v1(171.89,35.51) ; v1(178.23,85.95) 177.77,86.41 PR8202.1
N38936238: length 2.2
  TOP w0.109: PQ8201.1 55.32,14.39 v1(54.94,14.77) 54.53,14.36 PQ8202.4
N38936239: length 0.9
  TOP w0.109: PQ8202.3 52.26,13.98 52.42,13.82 PR8203.2
N38936251: length 4.1
  TOP w0.109: PQ8202.5 PQ8202.2 51.84,15.01 51.53,14.7 v1(51.53,14.6) 51.53,13.66 PR8208.1
N38936280:
  vias: v1(63.14,12.65)
N38936318: length 2.1
  TOP w0.203: PC8212.1 64.31,5.56 v1(64.56,5.31) 64.15,4.89 PR8212.1
N38936322: length 235
  TOP w0.109: PR8213.1 56.34,12.8 v1(56.11,13.03) 55.75,13.38 v1(55.27,13.38)
  IN2 w0.089: v1(55.27,13.38) 56.5,14.62 58.63,14.62 60.62,12.62 63.73,12.62 65.35,14.25 70.17,14.25 70.86,14.93 74.95,14.93 75.4,14.48 79.27,14.48 80.25,15.46 88.31,15.46 88.74,15.89 91.91,15.89 93.01,16.99 94.22,16.99 96.28,19.04 101.15,19.04 101.79,18.4 101.79,17.46 102.36,16.88 104.07,16.88 104.51,17.32 110.97,17.32 111.58,16.71 113.94,16.71 114.45,16.2 114.45,15.97 115.59,14.83 118.05,14.83 119.44,16.23 122.33,16.23 122.93,16.84 122.93,18.31 123.64,19.02 164.56,19.02 164.63,19.09 171.06,19.09 171.55,19.58 175.31,19.58 175.99,20.27 175.99,28.57 169.83,34.73 169.83,35.29 v1(168.5,36.62) ; v1(168.55,100.91) 168.12,100.48 168.12,98.75 166.88,97.51 166.88,95.35 167.31,94.92 167.31,89.38 169.57,87.12 169.57,83.51 171.22,81.86 171.22,80.89 173.22,78.9 173.22,76.49 172.71,75.98 172.71,72.33 173.18,71.85 173.18,67.76 174.47,66.47 174.47,65.94 173.85,65.31 173.85,64.68 173.63,64.46 173.63,63.52 v1(174.5,62.66)
  BOTTOM w0.109: v1(174.5,62.66) 175.89,61.27 175.89,58.74 176,58.62 176,57.62 176.6,57.02 176.6,55.25 175.66,54.32 175.66,52.68 175.56,52.57 175.56,50.82 175.05,50.32 175.05,48.74 174.29,47.98 174.29,47.43 173.6,46.74 173.6,45.75 172.2,44.35 172.2,43.16 171.23,42.19 171.23,41.06 169.82,39.66 169.82,39.43 169.05,38.66 169.05,37.71 168.5,37.16 v1(168.5,36.62) ; v1(168.55,100.91) 168.63,100.91 169.26,101.55 169.26,103.22 168.9,103.59 168.9,104.44 169.26,104.8 169.26,105.33 169.59,105.66 171.7,105.66 172.78,104.58 PD8205.3
N38936486: length 2.3
  BOTTOM w0.203: PU8201.3 59.57,4.71 v1(59.36,4.49) 59.03,4.16 PR8238.1
N38936522: length 1.5
  TOP w0.203: PR8244.1 50.38,6.82 v1(50.17,7.03) 50.2,7.06 PR8243.2
N39054084: length 2.6
  BOTTOM w0.203: PR8214.1 169.92,102.7 170.18,102.44 170.74,102.44 171.08,102.78 PD8205.2
N39054087: length 1.2
  BOTTOM w0.203: PD8205.1 170.91,105.21 PR8216.1
N39054316: length 3
  BOTTOM w0.109: PR8219.2 PR8220.2 53.13,9.15 PD8207.2 v1(51.81,9.6)
N39166693: length 2.3
  TOP w0.109: PU9502.12 175.59,69.95 174.95,70.58 v1(174.95,70.61) 175.16,70.82 PC9537.1
N39166694: length 2
  TOP w0.109: PC9538.1 176.39,71.25 v1(176.39,70.38) PU9502.10
N39250128: length 5.1
  TOP w0.109: R3616.1 188.39,40.84 188.95,40.28 190.77,40.28 190.95,40.11 190.95,39.78 191.24,39.49 v1(191.32,39.49) 191.85,39.49 192.02,39.32 U3600.2
N39252871: length 2.2
  TOP w0.203: U3600.22 198.3,36.52 198.7,36.12 199.31,36.12 C3603.1
N39252874: length 4.5
  TOP w0.203: U3600.21 198.19,36.12 198.96,35.35 199.88,35.35 C3604.2 200.66,34.58 R3603.2
N39253153: length 3.4
  TOP w0.203: C3600.2 200.24,39.67 199.54,39.67 198.39,38.52 U3600.27
N39253381: length 4.2
  TOP w0.203: U3600.28 198.34,38.92 199.84,40.42 199.84,40.51 200.73,41.4 C3601.2
N39253577: length 3
  TOP w0.203: C3601.1 199.48,41.4 198.57,40.49 v1(198.35,40.49) 198.35,39.85 198.22,39.72 U3600.30
N39254866: length 5.1
  TOP w0.203: U3600.12 193.75,34.7 193.57,34.53 193.57,34.15 193.92,33.8 194.84,33.8 195.04,33.6 R3609.1 195.5,33.32 195.81,33.02 R3610.2 R3608.2
N39255557: length 2
  TOP w0.203: U3600.6 v1(191.36,37.72) 190.56,37.72 C3622.2
N39257337: length 2.7
  TOP w0.203: C3605.1 197.98,41.73 197.76,41.73 197.41,41.37 196.85,41.37 196.55,41.07 U3600.32
N39257899: length 2.4
  TOP w0.203: U3600.39 193.75,41.07 193.5,41.32 v1(193.5,41.48) ; U3600.34 195.75,41.69 v1(195.86,41.81)
  vias: v1(193.04,41.91) v1(196.3,42.28)
N39300434: length 2.9
  TOP w0.109: v1(182.9,45.82) 182.9,45.11 183.03,44.98 Q3600.1 183.55,44.86 184.25,44.17 R3620.1
N39300462: length 4.6
  TOP w0.109: Q3600.2 183.55,46.56 185.23,44.89 185.61,44.89 v1(186.03,44.47) 185.6,44.04 R3622.1
N39344253: length 4.7
  TOP w0.178: 195.35,34.75 U3600.16
  TOP w0.203: R3605.2 197.74,32.85 197.74,33.63 197.41,33.95 196.6,33.95 196.02,34.53 195.7,34.53 195.47,34.62 195.35,34.75
N39344256: length 2.6
  TOP w0.203: C3613.2 196.06,33.47 v1(195.45,34.08) 195.17,34.36 195.17,34.47 194.95,34.69 U3600.15
N39344262: length 2.1
  TOP w0.203: v2(198.96,37.16) 198.6,37.16 198.44,37.32 U3600.24
  BOTTOM w0.254: v2(198.96,37.16) 198.98,37.18 TP3602.1
N39518726: length 1.2
  TOP w0.508: PC9120.1 117.08,104.32 PR9110.2
N41131693: length 3.9
  BOTTOM w0.109: Q501.3 93.87,69.86 93.3,70.42 R506.2 93.08,70.15 92.96,70.03 92.96,69.44 Q500.2
N41131697: length 2.7
  BOTTOM w0.109: R512.2 95.83,66.03 96.14,66.34 v1(96.14,66.7) R513.2 95.47,67.79 Q501.2
N43333369: length 4
  TOP w0.109: R3411.1 21.38,47.84 Q3404.2 19.6,48.66 R3409.1 19.56,48.11 v1(19.71,47.95)
N45522143: length 1.3
  TOP w0.109: R5128.2 164.06,59.19 163.89,59.36 U5100.4
N45522294: length 2.7
  TOP w0.109: R5123.1 166.02,58.33 166.19,58.49 166.19,59.07 165.81,59.44 165.5,59.44 165.39,59.55 U5100.7
N45522388: length 1.2
  TOP w0.109: U5100.16 167.65,64.12 R5129.2
N45761120: length 1.6
  BOTTOM w0.109: R4730.2 191.11,16.15 191.42,15.84 C4712.1 191.97,16.18 R4731.1
N46297116: length 2.4
  TOP w0.109: PR8722.2 170.08,48.43 v1(170.47,48.03) 171.02,48.03 PD8700.1
N46753812: length 1.6
  BOTTOM w0.254: PC9109.1 112.61,103.45 PR9107.2
N46753832: length 1.4
  BOTTOM w0.254: PR9112.2 PC9119.1
N46795838: length 1.8
  BOTTOM w0.254: PU9200.8 122.89,13.49 123.01,13.21 PC9209.2
N46796205: length 11.1
  TOP w0.254: v1(129.92,17.57) 129.92,17.4 129.49,16.96 128.73,16.96 127.79,16.03 124.1,16.03 v1(123.48,15.4) PR9212.2 122.31,14.23 122.31,13.24 PC9218.1
  BOTTOM w0.254: PR9208.1 130.27,17.93 v1(129.92,17.57)
N46797162: length 9.5
  IN3 w0.089: v1(190.85,53.08) 191.41,52.52 191.41,49.88 v1(190.35,48.82)
  BOTTOM w0.109: v1(190.85,53.08) 190.52,53.42 PR8405.2 PR8404.1 191.14,54.28 PC8400.2 190.89,54.87 191.52,55.51 PQ8400.1 ; v1(190.35,48.82) 190.65,49.12 PR8406.1
N46797220: length 2.2
  BOTTOM w0.109: PR8402.2 PR8406.2 190.2,49.63 190.35,49.78 191.06,49.78 191.19,49.65 PR8407.2
N46797224: length 1.7
  BOTTOM w0.109: PQ8401.2 189.92,48.55 189.69,48.79 189.53,48.79 189.21,49.12 PR8402.1
N46797226: length 2.6
  TOP w0.109: PC8402.2 174.13,85.3 174.01,85.42 v1(174.01,85.44) 174.01,85.82 174.19,86 PR8400.2 173.9,86.21 173.86,86.17 PR8401.2
N46797272: length 4.9
  BOTTOM w0.109: PQ8402.3 189.83,50.53 190.27,50.09 191.21,50.09 191.64,49.66 PR8407.1 191.64,49.19 191.46,49.02 191.46,48.46 191.22,48.22 PQ8401.1
N46797433: length 4.8
  BOTTOM w0.109: PR8411.2 155.24,63.62 155.87,63 PQ8403.3 155.87,62.56 156.31,62.12 156.31,60.86 v1(156.39,60.78) 156.49,60.68 PR8410.2
N46797587: length 5.6
  TOP w0.109: PR8413.1 PC8408.2 48.39,8.52 v1(48.56,8.35) 49.37,7.55 PR8415.2 48.57,6.88 PQ8404.2
N46797700: length 5.3
  TOP w0.109: v1(45.11,8.86) 44.63,8.38 PQ8405.2 44.63,6.79 PR8416.2 44.91,6.5 46,6.5 PQ8404.3
N46872073: length 2.4
  BOTTOM w0.109: v1(93.57,111.86) PR8901.1
  BOTTOM w0.508: PR8901.1 PC8909.1
N46874040: length 2.7
  BOTTOM w0.109: PC8927.1 107.8,112.27 v1(108.23,112.44)
  BOTTOM w0.508: PR8908.1 106.29,112.27 106.3,112.27 PC8927.1
N46891481: length 3.2
  BOTTOM w0.203: PR8817.2 90.4,103.11 90.58,102.92 90.58,102.71 v1(90.85,102.44) 92.29,101 PR8810.2
N46891574: length 2.1
  TOP w0.109: PC8806.2 81.7,100.48 v1(81.63,100.48)
  TOP w0.203: PC8806.2 82.46,101.25 PR8818.2
N46891676: length 1.9
  TOP w0.109: v1(87.09,100.1) 87.09,100.43 87.27,100.61 PC8807.2
  TOP w0.203: PR8823.1 88.27,100.9 PC8807.2
N46891831: length 1.2
  TOP w0.203: PR8828.2 84.38,101.29 PC8812.2
N46891887: length 1
  TOP w0.203: PR8830.1 86.3,101.65 86.28,101.62 PC8813.1
N46891889: length 49.9
  TOP w0.254: PR8843.2 106.35,69.01 106.36,69 PR8832.2 106.36,68.7 106.23,68.57 v1(105.31,68.57) 105.28,68.59 102.83,68.59 101.39,70.03 99.82,70.03 99.29,70.56 99.29,71.72 99.13,72.11 99.13,73.59 98.22,74.49 98.22,75.68 97.74,76.17 96.36,76.17 94.59,77.94 94.59,78.61 93.11,80.09 92.94,80.09 92.27,80.77 91.08,80.77 86.56,85.29 86.56,88.72 87.55,89.71 87.55,90.47 87.88,90.8 87.88,91.21 88.52,91.85 88.52,95.1 87.59,96.03 87.59,97.39 87.5,97.48 87.5,98.65 87.13,99.02 PC8814.2 85.5,99.79 85.5,99.79 PC8815.2 PC8813.2 85.5,102.21 PR8834.1
N46892152: length 14.6
  TOP w0.203: PR8839.2 PR8842.1 80.51,102.46 80.51,102.36 81.18,101.7 v1(81.22,101.7) 81.64,101.7 v1(81.85,101.91)
  IN3 w0.203: v1(81.85,101.91) 82.38,101.91 82.95,102.49 87.88,102.49 88.98,103.58 91.64,103.58 v1(92.08,104.03)
  BOTTOM w0.203: PR8841.1 92.08,103.96 v1(92.08,104.03)
N47579539: length 2.3
  TOP w0.109: R7614.1 180.61,42.64 v1(180.24,42.26) 180.31,42.19 180.31,41.54 180.12,41.35 U7600.32
N47579836: length 3.8
  TOP w0.203: U7600.9 174.83,41.35
  TOP w0.305: R7607.2 173.3,43.15 v1(173.77,42.68) 173.98,42.48 173.98,41.65 174.28,41.35 174.82,41.35 174.83,41.35
N47664126: length 4.3
  BOTTOM w0.254: 146.8,10.14 v1(146.8,9.85) 146.8,9.14 146.49,8.84 CON4402.12
  BOTTOM w0.381: 146.8,10.14 147.88,11.22 148.9,11.22
N47925309: length 3.4
  TOP w0.109: v1(49.91,50.72) 49.91,50.1 R7702.1 49.07,49.91 48.64,49.48 CON7703.41
N47925473: length 3.4
  TOP w0.109: R7705.2 50.27,49.32 50.11,49.48 49.01,49.48 48.51,48.98 CON7703.39
N47925767: length 1.8
  BOTTOM w0.109: CON7702.4 210.2,11.72 209.92,11.44 R7711.2
N48061323: length 3.6
  BOTTOM w0.109: PR9121.2 127.43,105.76 127.34,105.67 127.34,105.37 126.9,104.93 126.52,104.93 126.39,104.8 126.39,104.16 126.15,103.93 PQ9100.2
N48112598: length 2.2
  BOTTOM w0.109: PU8602.9 143.2,14.24 143.05,14.09 143.05,13.77 143.16,13.66 143.23,13.49 143.23,13.27 142.8,12.83 PC8617.1
N48112603: length 3.7
  BOTTOM w0.109: PU8602.10 142.7,14.13 142.82,14 142.82,13.61 142.38,13.17 142.18,13.17 142.02,13.01 PC8617.2 142.83,11.93 PR8609.2
N48117434: length 3.4
  BOTTOM w0.254: PU9200.9 122.39,13.63 122.76,12.75 122.76,12.22 122.27,11.73 PR9204.2
N48125412:
  vias: v1(155.04,101.62)
N48131045: length 2.1
  BOTTOM w0.203: PR8029.2 169.95,100.79 v1(170.43,100.3) 170.91,100.78 PQ8010.3
N48131048: length 10.5
  BOTTOM w0.109: PR8028.2 170.12,103.68 170.64,104.19 171.47,104.19 171.65,104.01 173.07,104.01 173.35,103.73 v1(173.35,103.45) 172.9,102.99 172.74,102.99 172.1,102.35 172.1,101.15 172.31,100.94 173.38,100.94 173.48,100.84 173.48,99.72 173.83,99.37 PQ8009.3
N48234350: length 1.3
  TOP w0.109: U7500.8 22.05,40.86 R7507.1
N48973706: length 3.2
  TOP w0.109: R3422.2 26.56,50.34 v1(26.74,50.52)
  BOTTOM w0.109: v1(26.74,50.52) 27.28,49.98 C3422.2 27.63,50.25 27.63,50.7 27.83,50.89 U3404.3
N49036359: length 7.4
  BOTTOM w0.109: R4212.1 191.26,11.2 v1(190.7,11.2) 189.71,11.2 189.42,10.91 188.7,10.91 188.31,10.52 188.28,10.5 188.19,10.46 187.68,9.95 185.65,9.95 185.41,9.72 CON4202.69
N49042977: length 4.9
  TOP w0.109: R4207.2 198.42,7.33 v1(198.68,7.59)
  BOTTOM w0.109: CON4202.25 196.41,8.25 196.6,8.07 198.36,8.07 198.68,7.75 v1(198.68,7.59)
N49052226: length 1.4
  TOP w0.109: U1802.A3 24.64,34.98 24.64,34.34 TP1802.1
N49052232: length 1.5
  TOP w0.109: TP1803.1 24.64,26.12 24.64,26.63 U1803.A3
N49053509: length 1.5
  TOP w0.109: TP1801.1 194.68,4.38 194.68,3.49 194.55,3.36 U1800.A3
N49054377: length 2.4
  BOTTOM w0.109: TP1804.1 204.82,27.94 204.57,27.94 203.75,28.77 U1805.A3
N49055211: length 1.5
  BOTTOM w0.109: TP1800.1 201.55,38.66 201.19,38.66 200.65,39.2 U1801.A3
N49093093: length 1.3
  TOP w0.109: U1900.A3 145.49,11.09 144.9,11.68 TP1902.1
N49093758: length 1.2
  TOP w0.109: TP1901.1 44.85,12.9 44.41,13.33 U1902.A3
N49096987: length 2
  TOP w0.109: U1903.A3 109.28,14.14 TP1903.1
N49098515: length 1.7
  TOP w0.109: U1904.A3 170.49,99.44 TP1904.1
N49099212: length 1.3
  TOP w0.109: U1905.A3 190.97,54.67 TP1905.1
N49100645: length 1.8
  TOP w0.109: U1907.A3 167.94,71.63 167.32,71.63 167.18,71.5 166.88,71.5 TP1907.1
N49101512: length 1.6
  TOP w0.109: U1908.A3 27.84,55.17 TP1908.1
N49102198: length 1.2
  TOP w0.109: TP1909.1 24.94,67.68 U1909.A3
N49103385: length 3.2
  TOP w0.109: U1906.A3 159.74,5.97 157.91,5.97 TP1906.1
N49104740: length 1.3
  TOP w0.109: U2008.A3 23,26.6 TP2008.1
N49179710: length 2.8
  TOP w0.109: R5000.2 133.09,10.33 132.36,9.6 v1(132.36,9.56)
  BOTTOM w0.109: CON5000.1 131.64,9.67 131.75,9.78 132.14,9.78 v1(132.36,9.56)
N49254400: length 5.2
  TOP w0.109: Q5000.5 179.19,62.61 179.04,62.46 178.64,62.46 178.54,62.55 Q5000.6 178.54,63.84 v1(178.56,63.85) 178.26,63.85 177.95,63.55 R5010.1 177.8,63.11 177.48,62.79 C5000.1 177.48,62.11 177.57,62.02 R5005.2
N49470898: length 13.9
  TOP w0.109: R4405.1 211.18,9.95 211.3,9.83 v1(211.3,9.42) 210.59,9.42 210.35,9.18 U4400.6 210.35,8.34 209.65,7.64 209.65,2.13 208.89,1.37 205.81,1.37 R4406.1
N49472283: length 2.8
  TOP w0.109: R4411.2 190.07,33.22 190.52,32.77 R4412.1 191.21,32.77 191.29,32.69 C4403.2 C4404.1
N49472680: length 65.5
  TOP w0.109: Q4400.5 187.64,33.27 187.55,33.35 187.55,33.83 187.64,33.92 Q4400.6 188.57,34.22 R4410.1 188.49,34.75 v1(187.84,34.75) 187.79,34.79 187.79,35.43 187.34,35.88 187.11,35.88 186.35,36.63 v1(186.17,36.63) ; R4407.2 v1(176.17,86.26)
  IN2 w0.109: v1(176.17,86.26) 176.17,85.79 177.63,84.33 177.63,81.75 182.25,77.12 182.25,75.22 183.11,74.36 183.11,72.83 183.5,72.45 183.5,71.81 184.08,71.23 184.08,69.71 184.61,69.18 184.61,67.19 182.99,65.57 182.99,57.9 182.26,57.17 181.76,57.17 181.47,56.88 181.47,54.57 182.69,53.35 182.69,52.62 184.82,50.5 184.82,49.33 184.38,48.89 183.94,48.89 183.71,48.66 183.71,48.33 183.75,48.29 183.75,46.85 184.01,46.59 184.01,45.46 186.07,43.4 186.07,40.43 185.24,39.6 185.24,37.56 v1(186.17,36.63)
N50419052:
  vias: v1(134.92,91.64)
N50419064:
  vias: v1(136.4,98.14)
N50419270: length 3
  TOP w0.109: PU10601.3 134.12,94.57 134.8,95.24 PC10635.1 134.82,94.87 134.7,94.74 PR10614.2 PR10613.2
N50419274: length 5.7
  TOP w0.109: v1(134.8,98.37) 134.48,98.05 PC10634.1 ; PC10634.1 134.72,97.86 134.84,97.75 134.84,97.55 134.97,97.41 PR10612.1 ; PC10634.1 134.31,97.86 134.1,97.65 134.1,97.19 134.18,97.11 134.18,96.47 134.23,96.42 134.23,95.55 134.05,95.37 PU10601.5
  BOTTOM w0.109: v1(134.8,98.37) 134.95,98.52 PR10623.1
N50419307: length 1.2
  TOP w0.109: PU10601.12 130.98,94.57 PC10636.2
N50419309: length 1.2
  TOP w0.109: PU10601.10 130.94,95.37 PC10637.1
N50522912: length 5.4
  TOP w0.203: PU9800.13 35.08,101.37 35.13,101.32 35.13,100.71 35.58,100.25 v1(35.58,100.07) 35.99,100.07 36.24,100.33 37.39,100.33 37.61,100.55 PR9823.1 PR9822.1
N50522939: length 0.8
  TOP w0.109: PR9802.1 32.02,107.56 TP9801.1
N50522940: length 3.9
  TOP w0.109: PR9821.2 v1(30.58,102.49)
  TOP w0.203: PR9821.2 PR9820.2 PC9804.1 32.34,103.2 32.64,103.5 PU9800.8
N50522997: length 0.8
  TOP w0.109: PR9801.1 33.55,107.64 TP9800.1
N50635931: length 7.7
  TOP w0.109: R4112.1 199.79,72.82 197.51,75.11 U4100.2 196.83,75.11 C4114.1 196.09,74.37 v1(194.92,74.37) 194.84,74.37 194.26,73.79 C4105.1
N50636280: length 3
  TOP w0.109: R4102.1 200.15,72.06 v1(200.63,72.06) 200.65,72.04 R4155.2 201.42,72.7 201.3,72.82 R4112.2
N50901509: length 3.6
  TOP w0.109: Q1501.1 155.85,39.39 v1(156.92,40.46) 155.86,41.52 R1560.2
N50901512: length 4.6
  TOP w0.109: Q1502.1 155.6,44.04 155.6,42.85 v1(155.8,42.64) 154.9,41.74 Q1501.3
N51022503: length 3.1
  TOP w0.109: R5017.2 169.53,32.99 Q5001.2 170.18,33.07 R5016.2
N51022542: length 2.4
  TOP w0.109: R5018.2 172.46,34.32 171.32,34.32 R5019.2 170.82,33.91 Q5004.2
N51034199: length 8.7
  TOP w0.254: PR8120.2 171.57,17.97 PR8119.2 PC8106.2 173.55,17.5 175.74,17.5 176.88,16.36 176.88,15.21 177.05,15.05 PU8101.4
N51034211: length 18.6
  TOP w0.109: PR8122.2 178.8,15.16 178.65,15.01 PU8101.3 178.87,14.62 179.72,13.78 179.72,12.64 181.87,10.49 v1(182.24,10.49)
  BOTTOM w0.109: PR8121.2 189.82,14.68 188.36,13.23 188.36,10.88 188.17,10.69 188.03,10.63 187.57,10.17 185.91,10.17 185.77,10.31 183.55,10.31 PC8107.2 182.38,10.49 v1(182.24,10.49)
N51034475: length 0.9
  TOP w0.109: PR8123.1 177.05,12.92 PU8101.6
N51038375: length 1
  BOTTOM w0.109: PR8623.2 141.37,14.35 PU8602.12
N51044000: length 23.2
  TOP w0.508: v1(183.51,87.93) 183.18,87.93 182.84,88.27 PC8003.1 182.47,88.59 182.34,88.47 PC8006.1
  IN3 w0.508: 187.35,80.54 189.05,78.84 190.34,78.84 190.65,78.53 190.65,77.99 190.36,77.7 190.36,76.47 191.27,75.56 192.53,75.56 193.25,76.28 194.4,76.28 194.79,75.89 v1(199.4,75.89) ; 185.67,84.05 183.48,86.23 183.48,87.9 v1(183.51,87.93)
N51044064: length 1.8
  BOTTOM w0.109: PQ8003.3 198.78,73.05 v1(199.49,73.05) 199.69,73.25 PR8008.2
N51258459: length 1.4
  TOP w0.109: U1804.A3 140.76,13.94 140.9,13.8 140.9,13.18 TP1805.1
N51259075: length 1.1
  TOP w0.109: TP1806.1 176.24,3.9 176.33,3.99 U1806.A3
N51259634: length 1.8
  TOP w0.109: U1807.A3 16.08,17.4 TP1809.1
N51260827: length 1.2
  TOP w0.109: TP1808.1 180.32,28.92 U1809.A3
N51263568: length 1.2
  TOP w0.109: U2010.A3 83.5,111.47 83.41,111.57 82.96,111.57 TP2010.1
N51264929: length 1.4
  TOP w0.109: TP2007.1 144.18,7.73 144.18,6.84 U2007.A3
N51454542:
  vias: v1(28.78,81.18) v3(25.56,80.38) v3(26.3,81.45) v3(26.3,80.71) v3(26.3,79.97) v3(27.03,81.45) v3(27.03,80.71) v3(27.03,79.97) v3(27.77,81.45) v3(27.77,80.71) v3(27.77,79.97)
N51471480: length 18.7
  IN3 w0.089: v1(35.96,12.5) 35.99,12.48 42.96,12.48 v1(43.26,12.18)
  BOTTOM w0.109: v1(43.26,12.18) 43.38,12.06 43.38,11.45 43.1,11.17 42.64,11.17 42.45,11.37 PR8108.2 42.45,11.67 PC8100.1 41.73,12.8 41.56,12.97 41.56,16.03 41.7,16.17 PU8100.2 ; PU8100.6 36.87,14.9 35.91,13.94 PR8106.2 35.91,12.55 v1(35.96,12.5)
N51471485: length 263.1
  TOP w0.109: PR8105.1 106.86,13.46 106.32,14 106.32,15.21 104.61,16.91 v2(104.61,17.9) ; v1(199.26,47.14) 199.97,46.43 PR8103.1
  IN1 w0.079: v1(160.45,49.23) 160.75,49.23 162.55,51.03 162.55,51.6 164.87,53.91 172.02,53.91 172.36,54.24 174.13,54.24 174.43,54.54 176.04,54.54 177.04,55.53 178.87,55.53 179.01,55.67 179.81,55.67 179.98,55.5 183.65,55.5 183.88,55.72 183.88,56.83 184.17,57.12 v1(184.55,57.12) 184.55,57.07 184.17,56.69 184.17,56.33 185.65,54.86 185.65,54.48 186.51,53.62 186.51,51.67 187.25,50.93 187.25,48.66 188.33,47.58 191.58,47.58 192.11,48.11 198.29,48.11 v1(199.26,47.14)
  IN2 w0.089: v2(104.61,17.9) 104.61,17.9 102.76,19.75 94.16,19.75 92.77,18.36 92.77,17.26 92.01,16.5 89.88,16.5 88.25,18.13 83.69,18.13 83.2,17.64 72.31,17.64 69.83,15.16 65.01,15.16 63.38,13.54 60.97,13.54 58.96,15.54 48.78,15.54 46.02,18.31 37.68,18.31 37.49,18.5 v1(37.49,18.57)
  IN3 w0.089: v2(104.61,17.9) 104.76,17.75 106.95,17.75 107.69,18.5 111.02,18.5 112.27,19.75 119.67,19.75 120.22,19.19 142.02,19.19 142.03,19.18 156.64,19.18 157.53,18.29 157.53,17.78 157.87,17.44 160.57,17.44 163.27,20.14 175.31,20.14 176.2,21.02 177.21,21.02 177.61,21.43 177.61,24.47 177.49,24.59 177.49,26.94 177.04,27.39 177.04,28.69 171.12,34.62 171.12,36.37 169.71,37.78 169.71,38.17 167.55,40.34 167.55,43.4 166.77,44.17 165.2,44.17 162.66,46.71 162.66,47.09 160.53,49.23 v1(160.45,49.23)
  BOTTOM w0.109: PD8100.3 184.85,57.75 184.55,57.45 v1(184.55,57.12) ; 39.03,11.44 39.27,11.2 40.11,11.2 PR8111.1 ; 39.03,11.44 39.03,12.55 39.77,13.3 39.77,16.43 39.14,17.07 38.99,17.07 v1(37.49,18.57) ; 39.03,11.44 38.9,11.3 38.15,11.3 PR8113.1 37.92,11.22 37.56,10.87 37.56,10.35 PC8102.2 36.77,9.92 36.45,9.6 36.45,9.14 36.72,8.87 PR8100.1 PR8101.1
N51471494: length 10
  BOTTOM w0.109: PR8111.2 PR8115.1 41.45,11.2 v1(41.9,10.76) 42.58,10.08 43.76,10.08 44.37,10.69 44.37,11.78 44.25,11.9 44.25,12.9 43.89,13.27 43.89,14.59 43.58,14.9 PU8100.3
N51471496: length 220.3
  TOP w0.109: v1(178.97,6.98) 181.08,6.98 182.47,5.59 185.19,5.59 185.72,6.11 186.41,6.11 186.72,5.81 v1(186.72,5.46) ; v1(114.25,7.24) 114.25,7.84 114.16,7.92 v1(114.16,8.28) 115.04,9.16 v2(115.04,10.69) 115.25,10.9 115.25,11.11 116.33,12.19 119.4,12.19 119.89,12.68 119.89,14.01 121.98,16.1 122.74,16.1 123.34,16.7 123.34,17.45 123.43,17.54 123.71,17.54 v1(124.14,17.98)
  IN1 w0.079: v2(36.02,11.45) 36.02,8.91 37.14,7.8 39.39,7.8 40.74,9.14 52.78,9.14 54.38,10.74 55.45,10.74 56.01,11.31 57.82,11.31 58.18,11.68 73.65,11.68 74.13,12.16 79.18,12.16 80.38,13.36 83.63,13.36 84.06,12.93 91.72,12.93 92.97,11.68 100.02,11.68 100.99,10.72 102.32,10.72 103.28,9.75 104.74,9.75 105.56,8.93 109.31,8.93 109.63,9.25 112.6,9.25 113.32,9.97 114.06,9.97 114.78,10.69 v2(115.04,10.69)
  IN3 w0.089: v1(178.97,6.98) 177.42,6.98 176.71,6.27 171.64,6.27 169.72,8.19 165.37,8.19 164.89,8.67 162.69,8.67 162.17,8.15 161.38,8.15 161.09,7.87 159.69,7.87 159.62,7.79 151.56,7.79 151.17,8.18 148.31,8.18 148.26,8.13 146.74,8.13 146.53,8.33 145.51,8.33 145.36,8.18 144.28,8.18 144.15,8.06 143.53,8.06 142.15,6.67 140.78,6.67 139.69,7.77 136.93,7.77 136.12,6.96 133.25,6.96 132.56,7.65 130.61,7.65 130.14,7.18 126.68,7.18 126.13,6.63 125.34,6.63 125.16,6.81 124.95,6.9 123.55,6.9 123.32,6.67 119.43,6.67 118.33,7.77 114.78,7.77 v1(114.25,7.24) ; 191.83,4.34 187.84,4.34 v1(186.72,5.46)
  IN3 w0.102: 191.83,4.34 192.74,5.25 194.44,5.25 195.3,4.39 196.04,4.39 196.52,3.91 198.98,3.91 200.23,5.16 204.86,5.16 205.19,5.49 205.19,6.23 205.41,6.45 205.64,6.45 206.75,7.57 207.06,7.57 207.31,7.31 v1(207.31,6.6)
  BOTTOM w0.109: PR8102.2 35.74,10.95 35.86,11.07 35.86,11.3 v2(36.02,11.45) 36.18,11.3 PC8101.2 ; PR8114.1 36.18,9.71 PC8101.2 ; v1(124.14,17.98) 123.68,18.44 121.92,18.44 121.79,18.31 PR8107.1 ; PR8104.2 208.71,9.42 208.71,8.61 207.47,7.36 207.47,6.75 v1(207.31,6.6) ; PC8101.2 36.2,10.08 36.55,10.08 36.7,10.23 36.7,11.35 36.48,11.58 PR8112.2
N51471497: length 2.8
  BOTTOM w0.109: PU8100.5 36.65,13.63 36.55,13.53 36.55,12.98 36.93,12.6 PR8116.1 PR8112.1
N51471552: length 1.7
  BOTTOM w0.109: PR8109.1 182.75,57.25 182.9,57.1 PD8100.2
N51471553: length 4.4
  BOTTOM w0.109: PD8100.1 182.68,57.63 181.23,57.63 181.1,57.5 v1(180.54,57.5) 180.18,57.5 PR8110.1
N51531858: length 2.4
  TOP w0.109: R4825.2 184.96,9.37 Q4703.2 186.26,9.37 186.41,9.22 186.41,8.86 186.27,8.72 Q4703.3
N51533071: length 18.2
  TOP w0.109: Q5202.2 35.91,10.12 35.91,7.57 35.66,7.31 35.2,7.31 34.72,6.83 34.72,5.89 35.1,5.51 35.1,5.08 v1(34.82,4.8) 34.77,4.75 28.32,4.75 27.89,5.18 27.89,5.41 27.63,5.66 Q5201.3 26.26,5.92 26.52,5.92 26.9,6.3 26.9,6.54 27.42,7.06 R5217.2
N51588253: length 2.4
  TOP w0.109: CON7703.23 49.36,44.98 TP7701.1
N51999762: length 2.8
  TOP w0.109: Q800.2 156.38,52.19 156.06,52.51 156.06,53.27 155.94,53.38 R818.2 155.52,53.38 155.07,52.93 C800.2
N51999829: length 6.9
  TOP w0.109: Q801.2 157.76,49.89 Q800.3 157.89,51.51 158.4,51 158.54,51 158.66,51.12 158.83,51.19 158.95,51.3 159.07,51.6 159.07,52.03 158.12,52.98 158.03,52.98 v1(157.53,53.49) 157.38,53.64 R819.2
N52065607: length 4.2
  BOTTOM w0.109: PR10617.1 159.49,81.73 159.81,81.73 v1(160.04,81.51) 159.93,81.39 PQ10603.6 159.93,79.8 159.86,79.73 159.4,79.73 159.28,79.85 PQ10603.5
N52065643: length 3.7
  BOTTOM w0.109: PR10622.2 157.91,76.06 PR10621.2 158.11,76.26 158.11,76.5 158.35,76.74 PR10619.1 158.35,77.4 159.28,78.33 PQ10603.2
N52288680: length 5.1
  TOP w0.109: R4156.2 184.29,83.45 184.71,83.87 184.71,85.57 184.25,86.03 183.82,86.03 v1(183.45,86.4) 183.45,86.78 Q4106.2
N52420915: length 2.1
  BOTTOM w0.109: C5413.1 154.59,16 U5403.2
N52420918: length 2.1
  BOTTOM w0.109: C5413.2 154.72,16.66 U5403.3
N52477829: length 4
  BOTTOM w0.109: CON3400.10 28.93,30.25 29.21,30.53 29.94,30.53 30.17,30.76 30.83,30.76 30.93,30.86 v1(31.42,30.86) 31.7,30.86 31.72,30.83 L3403.1
N52652005: length 1.9
  TOP w0.109: TP6101.1 188.03,82.83 v2(188.52,82.34)
  BOTTOM w0.109: v2(188.52,82.34) 188.52,82.55 188.64,82.67 188.92,82.67 189.01,82.59 U6100.36
N52656375: length 1.7
  BOTTOM w0.203: 192.21,88.99 U6100.9
  BOTTOM w0.254: 192.21,88.99 192.17,89.03 192.17,89.47 192.49,89.79 C6105.1
N52664021: length 2.3
  BOTTOM w0.109: TP6102.1 188.23,81.61 188.31,81.53 189.22,81.53 189.41,81.72 U6100.35
N52907910: length 1.8
  TOP w0.109: PQ8201.3 58.8,15.34 v1(59,15.14) 59,14.83 PR8245.1
N52915346: length 1.7
  BOTTOM w0.508: PR10203.1 24.02,85.85 PC10210.1
N52915353:
  vias: v1(32.69,83.89)
N53077021: length 5.9
  TOP w0.109: PR10212.2 22.53,63.31 22.89,63.31 23.06,63.48 PQ10200.6 v1(23.06,65.06) 23.06,65.66 PR10214.1 23.57,65.56 23.57,64.21 PQ10200.5
N53077023:
  vias: v1(25.86,61.87)
N53629073: length 2.3
  BOTTOM w0.109: U6100.37 187.54,83.09 186.94,82.49 R6109.1 R6129.2
N53814485: length 6.1
  BOTTOM w0.109: CON5000.3 130.64,8.45 130.81,8.28 132.98,8.28 R5028.2
N54003618: length 5.8
  BOTTOM w0.109: Q5005.2 44.95,9.08 44.71,9.33 R5026.1 45,9.7 46.72,11.41 46.72,12.89 46.88,13.05 Q5006.3
N54131141: length 1.7
  TOP w0.109: v2(61.64,83.48) 61.47,83.65 R6708.2
  BOTTOM w0.14: v2(61.64,83.48) 61.64,83.5 U6600.F22
N54131145: length 2.3
  TOP w0.109: R6709.2 62.13,81.43 61.17,81.43 v2(60.76,81.84)
  BOTTOM w0.109: v2(60.76,81.84) U6600.J22
N54154109: length 25.3
  TOP w0.508: C6619.2 70.45,84.11 v2(69.9,83.57)
  IN3 w0.508: v2(69.9,83.57) 70.49,84.15 70.49,86.89 70.81,87.21 70.81,91.13 70.22,91.72 70.22,93.53 69.16,94.59 v1(69.16,95.28)
  BOTTOM w0.305: v2(74.13,79.34) 74.13,79.41 U6600.L6 ; U6600.F11 69.93,83.57 v2(69.9,83.57) ; v2(74.88,79.32) 74.5,78.94 U6600.M6 ; v2(74.13,78.53) 74.5,78.16 U6600.N6
  BOTTOM w0.508: v1(69.16,95.28) 67.49,95.28 66.7,94.49 v1(66.7,93.88) 66.37,93.55 64.64,93.55 64.23,93.13 L6600.2 C6623.2 63.72,92.16 62.85,93.03 C6635.2
N54169728: length 1.2
  BOTTOM w0.305: U6600.G8 72.8,83.11 v2(73.22,83.53) ; U6600.G9 71.98,83.16 v2(72.38,83.56)
  vias: v1(71.78,83.67)
N54177392: length 10.4
  TOP w0.254: 60.3,87.88 60.12,88.06 59.4,88.06 57.34,90.12 54.05,90.12 53.57,90.6 R6713.2 53.49,91.08 v1(52.91,91.08) 52.91,91.78 C6719.2
  BOTTOM w0.254: U6600.D23 60.38,85.6 v2(59.97,86.01)
N54187750: length 11
  TOP w0.254: R6965.1 69.46,93.31 68.9,92.75 C6902.1 68.9,90.95 71.23,88.62 71.23,85.46 71.56,85.13 v1(71.56,84.99) v2(71.56,84.38)
  BOTTOM w0.254: U6600.F10 71.16,83.98 v2(71.56,84.38)
N54190117: length 3.3
  BOTTOM w0.109: Q6901.6 82.85,69.2 83.12,68.93 v1(83.34,68.93) 83.44,68.82 R6947.1 84,68.98 83.5,69.48 Q6901.5
N54237676: length 1.7
  BOTTOM w0.203: PQ9801.3 40.27,101 PR9831.1
N54237726: length 4.4
  BOTTOM w0.109: PQ9802.3 37.56,100.94 38.49,101.87 PQ9801.2 38.49,103.18 38.13,103.55 PR9829.2
N54361820: length 65.4
  TOP w0.109: R7615.1 164.16,103.32 164.67,103.83 v1(164.67,104.09) ; LED7600.2 213.94,117.25 v1(213.94,116.93)
  IN3 w0.089: v1(213.94,116.93) 212.79,116.93 210.92,115.06 209.2,115.06 208.15,114.02 206.45,114.02 205.28,112.85 205.28,108.15 202.87,105.74 197.55,105.74 195.04,103.23 193.53,103.23 190.05,99.74 186.68,99.74 185.74,100.69 181.46,100.69 178.21,103.93 177.01,103.93 175.46,105.48 175.46,105.79 174.8,106.45 172.03,106.45 171.28,105.7 170.8,105.7 169.9,104.8 167.66,104.8 167.39,104.53 165.11,104.53 v1(164.67,104.09)
N54361826: length 68.1
  TOP w0.109: v1(215.47,117.55) 215.47,118.31 215.09,118.69 LED7600.1 ; v1(165.56,103.45) 165.56,103.43 v1(164.97,102.84) 164.51,102.39 R7616.1
  IN3 w0.089: v1(215.47,117.55) 214.42,116.51 212.62,116.51 210.99,114.88 209.27,114.88 208.23,113.84 206.52,113.84 205.46,112.78 205.46,108.07 202.94,105.56 197.62,105.56 195.11,103.05 193.61,103.05 190.12,99.56 186.61,99.56 185.66,100.51 181.38,100.51 178.13,103.76 176.94,103.76 175.28,105.41 175.28,105.72 174.73,106.27 172.11,106.27 171.36,105.52 170.9,105.52 169.99,104.61 167.73,104.61 167.44,104.32 166.43,104.32 v1(165.56,103.45)
N54441486: length 5.8
  BOTTOM w0.109: PR9833.2 33.22,102.54 32.26,101.57 PD9801.1 33.04,101.09 33.2,101.24 PC9805.2 34.14,101.24 34.94,100.44 PQ9802.2
N54490415: length 3.6
  TOP w0.203: PR10520.1 71.68,98.68 PR10518.2 70.99,99.31 70.89,99.41 PQ10501.5 69.92,99.41 69.79,99.55 69.79,99.91 69.94,100.06 PQ10501.6
N54490417: length 1.6
  TOP w0.254: PR10519.2 68.46,98.12 68.47,98.13 PQ10501.3
N55084151: length 27.1
  TOP w0.109: v1(6.35,18.39) 6.35,19.23 6.43,19.32 6.43,22.57 8.02,24.16 8.02,28.73 8.23,28.93 8.23,33.02 9.32,34.11 9.32,37.36 9.04,37.64 9.04,40.46 TP4300.1
  BOTTOM w0.109: v1(6.35,18.39) 6.58,18.62 6.58,18.87 6.45,19 CON4300.68
N55555920: length 2.6
  BOTTOM w0.109: R5419.2 154.05,18 154.05,17.7 154.15,17.6 154.68,17.6 154.98,17.31 U5403.4
N57313521: length 2.2
  TOP w0.109: Q3406.1 29.31,24.96 L3402.1 29.39,25.41 R3435.1
N58653005: length 3.1
  BOTTOM w0.109: Q1000.2 92.17,63.9 R1008.2 93.32,64.36 93.24,64.44 R1004.1 R1007.2
N64506943: length 1.9
  TOP w0.109: R1427.2 150.63,52.74 151.01,52.74 151.18,52.57 Y1400.2
N66149192: length 1.5
  TOP w0.109: TP2000.1 76.13,9.96 U2000.A3
N66149611: length 1.8
  TOP w0.109: TP2001.1 119.11,93.67 119.78,92.99 119.78,92.73 119.62,92.56 U2001.A3
N66154196: length 1.6
  TOP w0.109: TP2002.1 19.93,10.66 19.93,10.7 U2002.A3
N66155185: length 1.5
  TOP w0.109: U2004.A3 201.75,76.22 TP2004.1
N66156322: length 2.5
  TOP w0.109: TP2005.1 173.78,53.77 175.71,53.77 U2005.A3
N66156623: length 1.4
  BOTTOM w0.109: U2006.A3 174.11,104.72 TP2006.1
N69862011: length 1.7
  TOP w0.254: v2(137.32,79.65) 137.32,79.59 137.31,79.58 136.91,79.58 R1603.1
  BOTTOM w0.254: U400.DA15 136.97,79.93 137.26,79.65 v2(137.32,79.65) 137.32,79.58 136.97,79.23 U400.DA17
N69862027:
  vias: v2(138.52,78.76) v2(139.06,78.76)
N71200998: length 3.9
  BOTTOM w0.079: U400.AR2 115.45,86.14 115.45,86.53 115.24,86.74
  BOTTOM w0.109: 115.24,86.74 115.24,89.18 R1001.2
N71203256: length 1.2
  TOP w0.109: v2(138.72,72.4) 138.37,72.4 TP608.1
  BOTTOM w0.109: U400.DF31 138.73,72.64 138.73,72.42 v2(138.72,72.4)
N4193523427: length 5
  TOP w0.109: v1(159.55,23.86) 159.29,23.86 TP2800.1
  BOTTOM w0.109: JDIM2800.162 158.68,22.99 v1(159.55,23.86)
N4193523428: length 2.1
  TOP w0.109: TP2801.1 159.46,27.13 v1(159.43,27.1)
  BOTTOM w0.109: v1(159.43,27.1) JDIM2800.165
N4193827027: length 3.9
  TOP w0.109: v1(82.65,22.77) 83.13,23.25 TP2900.1
  BOTTOM w0.109: JDIM2900.162 81.72,21.2 82.07,21.55 82.07,22.19 v1(82.65,22.77)
N4193827028: length 2.3
  TOP w0.109: TP2901.1 82.57,27.14 v1(82.64,27.07)
  BOTTOM w0.109: v1(82.64,27.07) 82.47,27.25 JDIM2900.165

## Copper pours and planes (outline as drawn)
1V8_AON on TOP (solid shape): 71.24,83.23 72.28,83.23 72.33,83.22 72.38,83.22 72.43,83.22 72.48,83.23 72.61,83.23 72.71,83.13 72.71,82.6 72.63,82.52 70.98,82.52 70.79,82.33 70.38,82.33 70.18,82.53 70.12,82.53 70.1,82.55 69.55,82.55 69.47,82.63 69.47,83.11 69.52,83.16 70.04,83.16 70.4,83.52 70.95,83.52
1V8_AON on TOP (solid shape): outline of 201 points within 61.75,92.59 74.98,98.69
1V8_AON on TOP (solid shape): outline of 250 points within 80.86,76.62 85.9,86.69
1V8_AON on TOP (solid shape): outline of 470 points within 73.26,58.35 85.65,67.97
1V8_AON on BOTTOM (solid shape): 84.15,60.53 84.15,60.22 83.97,60.04 83.59,60.04 81.84,58.29 81.73,58.29 81.71,58.3 81.69,58.31 81.59,58.41 81.46,58.47 81.45,58.48 81.05,58.87 81.05,58.97 81.05,59 81.02,59.04 81.02,59.79 81.48,60.25 82.09,60.25 82.52,60.68 84,60.68
1V8_AON on BOTTOM (solid shape): 85.89,88.7 85.89,86.44 85.44,86 84.3,86 84.07,86.23 84.07,86.4 84.2,86.53 84.87,86.53 84.93,86.6 85.1,86.6 85.18,86.63 85.21,86.71 85.21,86.92 85.18,86.99 85.08,87.05 85.06,87.08 85.06,88.82 85.11,88.87 85.49,88.87 85.51,88.89 85.71,88.89
1V8_AON on BOTTOM (solid shape): 71.12,83.64 71.16,83.64 71.2,83.64 71.24,83.65 71.37,83.65 71.47,83.54 71.47,82.55 71.15,82.22 69.49,82.22 69.21,82.51 69.21,83.12 69.46,83.38 69.6,83.38 69.62,83.37 69.76,83.27 69.9,83.23 70.04,83.27 70.17,83.37 70.2,83.38 70.48,83.65 71.07,83.65
1V8_AON on BOTTOM (solid shape): 82.92,82.63 83,82.59 83.01,82.49 83,82.43 82.99,82.37 83.1,82.11 83.36,82 83.57,82.07 83.71,82.25 83.78,82.32 83.88,82.29 84.15,82.01 85.33,82.01 86,81.35 86,78.83 86,78.82 86,78.56 85.85,78.41 85.85,75.51 85.67,75.33 84.48,75.33 84.38,75.44 84.38,75.53 84.39,75.58 84.39,75.62 84.39,75.92 84.39,75.95 84.38,76 84.38,76.64 84.39,76.7 84.39,76.73 84.39,77.03 84.39,77.07 84.38,77.11 84.38,77.66 84.39,77.71 84.39,77.75 84.39,78.05 84.39,78.09 84.38,78.13 84.38,78.65 84.39,78.7 84.39,78.74 84.39,79.04 84.39,79.08 84.38,79.12 84.38,79.87 84.39,79.92 84.39,79.96 84.39,80.26 84.39,80.3 84.38,80.34 84.38,80.89 84.39,80.94 84.39,80.98 84.39,81.28 84.39,81.31 84.38,81.36 84.38,81.39 84.25,81.51 83.04,81.51 82.38,82.18 82.38,82.42 82.41,82.46 82.44,82.52 82.55,82.63
1V8_AON on IN2 (solid shape): outline of 664 points within 73.71,66.01 84.97,86.51
1V8_AON_EN on TOP (solid shape): 89.32,79.61 89.92,79.61 90.68,78.85 91.3,78.85 92.23,77.92 92.23,77.49 91.86,77.49 91.82,77.49 91.79,77.47 91.78,77.46 90.99,77.46 90.69,77.76 90.23,77.76 90.22,77.77 89.89,77.77 88.77,78.89 88.76,78.91 88.68,79.11 88.49,79.23 88.44,79.27 88.42,79.34 88.42,79.4 88.38,79.58 88.25,79.71 88.24,79.72 88.21,79.76 88.23,79.83 88.23,79.87 88.23,80 88.44,80.21 88.72,80.21
1V8_MAIN on TOP (solid shape): outline of 745 points within 60.83,63.61 84.71,75.93
1V8_MAIN on BOTTOM (solid shape): 73.73,72.46 73.73,72.21 73.3,71.78 73.3,71.33 73.3,71.32 73.48,71.14 73.48,70.91 73.31,70.74 73.1,70.74 73.06,70.78 73.01,70.85 72.94,70.9 72.87,70.97 68.57,70.97 68.44,71.09 68.44,71.75 68.83,72.13 72.36,72.13 72.82,72.59 73.61,72.59
1V8_MAIN on BOTTOM (solid shape): outline of 458 points within 56.79,61.9 66.8,72.12
1V8_MAIN on IN2 (solid shape): outline of 797 points within 61.01,62.23 74.28,72.6
1V8_MAIN on IN3 (solid shape): outline of 1433 points within 68.84,71.24 79.37,96.49
+1.2VSUS on TOP (solid shape): outline of 25252 points within 40.79,21.13 179.84,70.64
+1.2VSUS on BOTTOM (solid shape): outline of 428 points within 127.5,68.61 134.01,70.03
+1.2VSUS on BOTTOM (solid shape): outline of 591 points within 107.22,16.48 116.91,29.5
+1.2VSUS on BOTTOM (solid shape): outline of 546 points within 109.56,68.61 117.82,70.01
+1.2VSUS_S on TOP (solid shape): 109.5,17.14 109.5,16.38 109.42,16.3 109.42,15.75 109.34,15.67 108.86,15.67 108.38,15.19 108.38,14.35 108.11,14.08 106.93,14.08 106.87,14.14 106.87,16.24 107.16,16.53 107.92,16.53 108.58,17.19 109.45,17.19
+1.2VSUS_S on BOTTOM (solid shape): outline of 268 points within 102.56,8.35 113.28,18.23
+1.05V_GFX_S2 on BOTTOM (solid shape): 61.71,59.73 62.92,59.73 63.24,59.41 63.24,56.89 63.11,56.77 62.01,56.77 61.83,56.94 61.83,57.36 61.66,57.54 61.22,57.54 61.18,57.53 58.67,57.53 58.42,57.78 58.39,57.78 58.13,58.05 58.13,60.42 58.3,60.59 60.85,60.59
+1.8V on TOP (solid shape): 200.18,45.31 200.18,43.79 200.05,43.66 198.78,43.66 198.68,43.76 198.68,45.01 198.75,45.08 199.36,45.08 199.67,45.39 200.1,45.39
+1.8V on BOTTOM (solid shape): 200.25,41.76 200.25,41.04 200.36,40.94 200.36,40.34 200.26,40.24 199.42,40.24 199.41,40.24 199.02,39.85 199.02,39.84 198.53,39.34 198.04,39.34 197.89,39.49 197.89,39.85 197.9,39.86 197.9,39.91 199.82,41.83 200.18,41.83
+1.8V on IN1 (solid shape): outline of 88 points within 173.62,55.54 177.78,56.94
+1.8V on IN2 (solid shape): outline of 321 points within 192.02,38.61 200.78,45.16
+1.8V_AVDD on TOP (solid shape): 200.1,43.05 200.1,42.47 200.05,42.42 198.51,42.42 198.47,42.42 198.17,42.42 198.04,42.37 197.97,42.25 197.96,42.23 197.33,41.6 196.87,41.6 196.86,41.59 196.76,41.59 196.34,41.16 196.17,41.16 196.09,41.25 196.09,41.35 196.88,42.15 196.88,42.2 196.91,42.26 196.93,42.32 196.97,42.36 197.25,42.36 197.29,42.4 197.31,42.4 197.44,42.46 197.5,42.58 197.53,42.61 197.57,42.61 197.58,42.61 197.84,42.61 197.95,42.68 198.03,42.8 198.03,43.05 198.02,43.07 198.02,43.13 200.02,43.13
+1.8V_DEEP_SUS on TOP (solid shape): 68.88,45.34 68.88,43.23 68.5,42.85 63.35,42.85 62.84,43.36 62.84,44.9 63.64,45.71 68.51,45.71
+1.8V_DEEP_SUS on TOP (solid shape): 133.35,16.2 133.75,16.2 133.88,16.08 133.88,13.64 133.81,13.56 132.13,13.56 132.03,13.66 132.03,15.19 132.02,15.23 132,15.26 132,15.67 131.82,15.85 131.82,16.28 132.05,16.51 133.04,16.51
+1.8V_DEEP_SUS on TOP (solid shape): 171.37,71.88 171.37,70.33 171.09,70.05 169.5,70.05 169.21,70.34 169.21,71.09 169.28,71.15 169.39,71.15 169.42,71.18 169.48,71.21 169.53,71.25 170.17,71.89 170.39,71.89 170.61,72.11 171.14,72.11
+1.8V_DEEP_SUS on TOP (solid shape): 174.88,67.8 174.88,66.99 175.09,66.99 175.09,67.75 175.1,67.79 175.14,67.8 175.27,67.8 175.28,67.79 175.28,66.44 174.34,65.5 173.23,65.5 172.9,65.83 172.9,67.33 173,67.43 173.73,67.43 173.8,67.5 173.81,67.5 174.11,67.8 174.23,67.8 174.24,67.82 174.87,67.82
+1.8V_DEEP_SUS on TOP (solid shape): 176.83,67.8 176.87,67.79 176.88,67.75 176.88,66.99 177.09,66.99 177.09,67.75 177.1,67.79 177.14,67.8 177.26,67.8 177.51,67.55 178.27,67.55 178.81,67.01 178.81,66.11 178.61,65.91 176.88,65.91 176.84,65.96 176.84,65.97 176.77,66.12 176.65,66.23 176.65,66.96 176.69,66.99 176.69,67.75 176.7,67.79 176.74,67.8
+1.8V_DEEP_SUS on TOP (solid shape): 137.82,78.13 138.01,78.13 138.14,78.01 138.14,77.63 138.26,77.5 138.77,77.5 138.9,77.37 138.9,76.48 138.77,76.36 138.59,76.36 138.44,76.2 138.44,76.17 138.43,76.16 138.43,75.9 138.44,75.88 138.44,75.48 138.23,75.28 136.52,75.28 136.46,75.34 136.46,75.81 136.59,75.94 136.65,75.93 136.92,76.07 136.96,76.37 136.96,76.38 136.96,76.47 136.44,76.99 136.44,78 136.58,78.14 137.82,78.14
+1.8V_DEEP_SUS on TOP (solid shape): outline of 114 points within 13.04,11.66 15.87,14.35

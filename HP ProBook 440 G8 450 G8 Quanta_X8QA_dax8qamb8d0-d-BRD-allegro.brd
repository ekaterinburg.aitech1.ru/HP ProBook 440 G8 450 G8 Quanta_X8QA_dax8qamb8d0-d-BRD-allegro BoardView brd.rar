# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 169.38,97.7 170.42,97.7 172.29,95.83 172.29,95.45 172.16,95.32 171.78,95.32 170.97,96.13 170.45,96.13 170.23,96.35 170.23,96.92 169.74,97.41 169.38,97.41 169.33,97.42 169.31,97.41 169.22,97.41 169.21,97.45 169.22,97.5 169.22,97.58 169.25,97.67 169.34,97.7
GND on TOP (solid shape): 202.81,89.46 202.83,89.35 202.74,89.29 199.86,89.29 199.77,89.2 199.71,89.19 199.68,89.23 199.68,89.25 199.65,89.43 199.57,89.59 199.65,89.75 199.68,89.93 199.68,90.29 199.84,90.45 200.04,90.45 200.18,90.58 201.59,90.58 201.64,90.64
GND on TOP (solid shape): 78.51,89.57 78.55,89.49 78.55,88.58 78.77,88.37 78.75,88.3 78.76,88.18 78.78,88.11 78.78,88.01 78.69,87.96 77.64,87.96 77.1,88.5 77.1,89.21 77.21,89.32 77.9,89.32 78.16,89.57 78.21,89.56 78.27,89.56 78.35,89.56 78.41,89.58
GND on TOP (solid shape): 135.58,96.97 135.58,96.63 135.65,96.57 135.65,96.48 135.73,96.4 135.73,95.7 135.46,95.43 135.46,95.11 135.37,95.03 135.21,95.03 135.04,95.2 135.04,95.43 135.01,95.51 134.93,95.55 134.82,95.55 134.77,95.58 134.79,95.63 134.83,95.67 134.93,95.67 135.01,95.71 135.04,95.79 135.04,96.94 135.2,97.1 135.46,97.1
GND on TOP (solid shape): 188.4,13.5 188.47,13.5 188.5,13.48 188.52,13.45 188.52,12.96 188.54,12.94 188.55,12.88 188.5,12.85 187.33,12.85 187.05,13.13 186.97,13.13 186.94,13.16 186.91,13.24 186.95,13.31 187.02,13.38 187.07,13.46 187.07,13.72 187.05,13.77 187.05,13.82 187.06,13.83 188.07,13.83
GND on TOP (solid shape): 188.88,40.11 190,40.11 190.08,40.08 190.1,40 190.1,39.93 189.8,39.63 188.82,39.63 188.75,39.66 188.72,39.74 188.72,39.95 188.69,40.03 188.61,40.06 188.5,40.06 188.26,40.3 188.24,40.41 188.34,40.48 188.52,40.48
GND on TOP (solid shape): 159.26,87.63 159.34,87.56 159.91,87.56 159.91,86.5 159.45,86.04 159.03,86.04 158.14,85.15 158.14,85.03 158.11,85.01 158.06,85.01 158.03,85.05 158.03,85.35 158.17,85.48 158.22,85.67 158.2,85.8 158.13,85.91 158.11,85.98 158.14,86.05 159.18,87.1 159.18,87.61 159.22,87.65
GND on TOP (solid shape): 130.44,95.46 130.47,95.38 130.55,95.35 130.71,95.35 130.78,95.28 130.79,95.23 130.74,95.2 130.55,95.2 130.47,95.16 130.44,95.08 130.44,94.7 130.44,94.66 130.47,94.62 130.5,94.59 130.3,94.39 130.3,93.93 129.94,93.58 129.94,93.11 129.74,92.91 128.34,92.91 128.22,93.04 128.22,93.2 128.81,93.8 128.81,94.57 130.02,95.77 130.44,95.77
GND on TOP (solid shape): 185.84,8.08 185.92,8.04 185.94,7.95 185.92,7.89 185.92,7.83 185.92,7.78 185.62,7.47 185.59,7.47 185.44,7.41 185.38,7.26 185.38,6.96 185.38,6.92 185.39,6.88 185.38,6.79 185.3,6.74 184.83,6.74 184.64,6.93 183.69,6.93 183.46,7.16 183.46,7.93 183.61,8.08
GND on TOP (solid shape): 61.42,97.99 61.42,97.53 61.54,97.41 61.66,97.41 61.67,97.4 61.7,97.38 61.74,97.37 63.24,97.37 63.27,97.38 63.3,97.4 63.32,97.41 63.45,97.41 63.62,97.58 64.36,97.58 64.56,97.38 64.56,96.9 64.39,96.72 63.35,96.72 63.34,96.76 63.3,96.81 63.24,96.83 61.74,96.83 61.66,96.8 61.63,96.72 61.63,96.63 61.42,96.42 61.42,93.67 61.29,93.55 56.21,93.55 56.08,93.67 56.08,94.18 56.21,94.31 57.73,94.31 57.86,94.43 57.86,97.99 57.99,98.12 61.29,98.12
GND on TOP (solid shape): 30.91,27.99 30.91,26.97 30.8,26.86 30.62,26.86 29.88,27.61 29.87,27.63 29.74,27.82 29.52,27.9 29.26,27.8 29.15,27.54 29.15,27.52 29,27.38 28.52,27.38 28.47,27.43 28.47,27.88 28.64,28.05 28.88,28.05 28.93,28.06 28.99,28.09 29,28.09 29.16,28.09 29.55,28.49 29.65,28.5 29.74,28.54 30.36,28.54
GND on TOP (solid shape): 165.1,75.66 165.1,74.82 165.12,74.8 165.13,74.74 165.08,74.71 164.14,74.71 164.07,74.74 164.04,74.82 164.04,75.13 164,75.25 163.89,75.33 163.86,75.34 163.86,75.64 163.7,75.8 163.68,75.91 163.77,75.97 163.93,75.97 164,76 164.04,76.07 164.05,76.11 164.65,76.11
GND on TOP (solid shape): 172.97,64.74 173.07,64.55 173.26,64.46 173.33,64.41 173.34,64.33 173.34,64.28 173.34,63.98 173.36,63.89 173.41,63.82 173.45,63.75 173.42,63.67 173.36,63.61 173.36,63.37 172.98,63.37 172.89,63.34 172.86,63.26 172.86,63.23 171.52,63.23 170.95,63.79 170.95,64.29 171.42,64.29 171.93,64.79 172.92,64.79
GND on TOP (solid shape): 140.66,92.36 140.7,92.28 140.78,92.25 141.48,92.25 141.66,92.07 141.66,91.2 141.62,91.19 141.55,91.15 141.53,91.08 141.53,90.88 141.54,90.83 141.56,90.79 141.58,90.75 141.55,90.7 141.46,90.7 141.38,90.62 141.09,90.62 140.99,90.72 140.99,91.33 140.71,91.61 140.29,91.61 140.21,91.65 140.2,91.75 140.21,91.79 140.21,92.23 140.38,92.41 140.66,92.41
GND on TOP (solid shape): 142.43,79.65 142.5,79.68 142.58,79.65 142.6,79.63 143.31,79.63 145.01,77.93 145.11,77.93 145.13,77.86 145.1,77.84 145.04,77.78 145,77.7 145,77.61 144.93,77.52 144.83,77.55 143.61,78.76 141.49,78.76 141.36,78.9 141.34,79.01 141.43,79.07 142.02,79.07 142.27,79.32 142.27,79.36 142.37,79.44 142.43,79.54
GND on TOP (solid shape): 128.32,82.89 128.39,82.92 128.46,82.89 128.52,82.83 128.92,82.83 129.17,82.56 129.17,81.4 129.14,81.38 129.08,81.34 128.92,81.49 128.44,81.49 128.32,81.37 128.32,81.32 127.98,81.32 127.98,81.7 127.97,81.77 127.95,81.79 127.94,81.81 127.94,82.26 127.94,82.29 127.96,82.32 128.09,82.33 128.15,82.35 128.33,82.53 128.35,82.59 128.36,82.66 128.35,82.73 128.33,82.79 128.28,82.84
GND on TOP (solid shape): 196.8,76.61 196.91,76.63 196.98,76.54 196.98,76.05 197.35,75.68 197.37,75.56 197.28,75.5 197.01,75.5 196.93,75.47 196.9,75.39 196.9,75.28 196.76,75.28 196.3,74.82 196.04,74.82 195.91,74.78 195.84,74.67 195.82,74.64 195.16,74.64 195.08,74.7 194.98,74.73 194.98,74.77 195.01,74.81
GND on TOP (solid shape): 49.94,42.81 50.03,42.75 50.01,42.64 49.25,41.88 48.86,41.88 48.61,42.13 48.61,42.14 48.58,42.2 48.53,42.23 48.49,42.24 48.49,42.34 46.23,42.34 46.23,42.24 46.18,42.22 46.08,42.22 46.03,42.31 46.03,42.65 46.08,42.74 46.18,42.74 46.23,42.72 46.23,42.62 48.49,42.62 48.49,42.72 48.53,42.73 48.57,42.75 48.59,42.79 48.61,42.81
GND on TOP (solid shape): 176.2,52.07 175.35,51.22 175.35,50.47 175.29,50.38 175.17,50.4 174.28,51.3 174.23,51.3 174.18,51.33 174.19,51.39 174.37,51.56 175.08,51.56 175.09,51.55 175.12,51.53 175.16,51.52 175.36,51.52 175.44,51.55 175.47,51.62 175.47,51.68 175.47,51.69 175.5,51.78 175.5,51.87 175.49,51.9 175.68,52.09 176.01,52.09 176.04,52.12 176.14,52.13
GND on TOP (solid shape): 195.91,15.1 195.95,15.02 195.95,14.57 196.17,14.35 196.28,14.31 196.3,14.29 196.33,14.29 196.36,14.27 196.38,14.28 196.43,14.21 196.41,14.2 196.41,13.83 196.37,13.79 196.35,13.79 196.26,13.77 196.17,13.73 196.14,13.71 195.96,13.89 195.96,13.89 195.58,14.27 195.58,14.98 195.71,15.12 195.79,15.12 195.82,15.12
GND on TOP (solid shape): 157.46,67.77 157.52,67.77 157.54,67.75 157.58,67.73 157.62,67.72 158,67.72 158.01,67.72 158.09,67.7 158.13,67.62 158.13,67.39 158.31,67.2 158.31,67.13 158.31,67.06 158.31,66.95 158.13,66.76 158.13,66.29 158.04,66.2 157.86,66.2 157.47,66.59 157.47,66.8 157.44,66.86 157.38,66.9 157.33,66.9 157.33,67.08 157.36,67.13 157.36,67.16 157.36,67.36 157.33,67.43 157.26,67.46 156.94,67.46 156.89,67.51 156.89,67.81 156.91,67.82 157.41,67.82
GND on TOP (solid shape): 200.32,79.79 200.32,79.17 199.82,78.67 199.75,78.68 199.71,78.68 199.56,78.65 199.44,78.57 199.36,78.54 199.28,78.58 199.15,78.7 198.98,78.74 198.78,78.68 198.64,78.52 198.57,78.46 198.48,78.49 198.44,78.52 198.42,78.52 198.39,78.58 199.3,79.49 199.3,80.02 199.38,80.1 200.01,80.1
GND on TOP (solid shape): 49.67,41.27 49.68,41.24 49.72,41.2 49.72,41.15 50.07,40.8 52.21,40.8 52.26,40.76 52.25,40.71 52.19,40.65 48.61,40.65 48.59,40.68 48.57,40.71 48.53,40.73 48.49,40.74 48.49,40.84 46.23,40.84 46.23,40.74 46.18,40.72 46.08,40.73 46.03,40.81 46.03,41.15 46.08,41.24 46.18,41.24 46.23,41.22 46.23,41.12 48.49,41.12 48.49,41.22 48.53,41.23 48.57,41.25 48.59,41.29 48.61,41.31 49.66,41.31
GND on TOP (solid shape): 178.1,6.4 178.1,5.69 177.69,5.27 177.13,5.27 177.09,5.27 177,5.3 176.97,5.39 176.97,5.47 176.99,5.55 177.07,5.59 177.13,5.59 177.37,5.83 177.13,6.07 176.97,6.07 176.97,6.16 177,6.17 177.09,6.24 177.16,6.33 177.41,6.58 177.92,6.58
GND on TOP (solid shape): 14.34,47.23 14.45,47.25 14.52,47.15 14.52,44 13.63,43.12 13.63,42.69 13.49,42.56 13.43,42.37 13.44,42.29 13.47,42.22 13.46,42.12 13.37,42.08 12.69,42.08 12.37,41.76 12.33,41.78 12.32,41.78 12.21,41.84 12.09,41.87 12.02,41.86 11.96,41.84 11.86,41.85 11.82,41.94 11.82,43.33 12.3,43.81 12.3,44.64 12.87,45.21 12.87,45.75
GND on TOP (solid shape): 39.83,83.51 39.83,82.67 38.68,81.53 38.45,81.53 38.37,81.61 38.33,81.64 38.3,81.69 38.28,81.71 38.28,82.11 38.25,82.21 38.18,82.29 38.16,82.31 38.17,82.35 38.19,82.43 38.2,82.51 38.1,82.75 37.86,82.85 37.77,82.84 37.69,82.8 37.66,82.8 37.63,82.82 37.55,82.88 37.45,82.9 37.11,82.9 36.91,83.1 36.91,83.49 37.01,83.59 39.75,83.59
GND on TOP (solid shape): 211.97,12.73 212.08,12.75 212.14,12.66 212.14,11.92 212.76,11.3 212.76,10.93 212.77,10.91 212.79,10.85 212.79,10.59 212.76,10.55 212.75,10.5 212.75,10.12 212.76,10.08 212.79,10.03 212.79,9.69 212.77,9.67 212.77,9.36 212.7,9.3 212.64,9.3 212.61,9.25 212.57,9.21 212.52,9.2 212.24,9.2 212.19,9.21 212.16,9.25 212.13,9.3 211.85,9.3 211.83,9.32 211.83,9.96 211.84,9.99 211.84,10.37 211.83,10.4 211.83,12.6
GND on TOP (solid shape): 27.44,28.37 27.44,27.96 27.3,27.82 26.72,27.82 26.64,27.84 26.56,27.85 26.32,27.76 26.2,27.54 26.2,27.52 26.15,27.47 26.07,27.55 25.71,27.55 25.67,27.54 25.58,27.57 25.55,27.66 25.56,27.71 25.55,27.76 25.53,27.81 25.53,27.87 25.65,27.87 25.68,27.87 25.71,27.86 25.75,27.87 25.78,27.87 25.88,27.87 26.26,28.25 26.27,28.27 26.31,28.32 26.36,28.36 26.38,28.37 26.42,28.41 27.41,28.41
GND on TOP (solid shape): 169,66.39 169.04,66.39 170.04,65.39 170.04,65.18 170,65.1 169.92,65.08 169.9,65.08 169.6,65.08 169.44,65.02 169.38,64.87 169.38,64.76 169.05,64.76 169.04,64.8 169.03,64.83 169,64.87 169,65.07 169,65.07 169,65.29 169.01,65.33 169.02,65.36 169.02,65.77 168.98,65.85 168.9,65.88 168.78,65.88 168.68,65.94 168.71,66.05 168.91,66.26 168.91,66.34
GND on TOP (solid shape): 53.57,75.67 53.66,75.7 53.74,75.63 53.78,75.54 53.84,75.46 53.89,75.42 53.89,73.84 53.76,73.71 53.17,73.71 53.07,73.81 53.07,73.89 53.11,73.96 53.19,73.99 53.23,73.98 53.58,74.33 53.23,74.67 53.19,74.67 53.11,74.69 53.07,74.77 53.07,75.17
GND on TOP (solid shape): 175.4,105.95 175.44,105.89 175.48,105.83 175.51,105.72 175.41,105.66 175.18,105.66 174.5,104.98 174.37,104.98 174.24,104.85 174.19,104.89 174.16,104.96 174.19,105.03 174.24,105.12 174.25,105.21 174.25,105.26 174.24,105.3 174.24,105.34 174.27,105.37 174.44,105.5 174.51,105.71 174.5,105.78 174.49,105.84 174.5,105.94 174.58,105.98 175.39,105.98
GND on TOP (solid shape): 16.44,43.01 16.48,43.05 16.53,43.04 16.94,42.63 18.65,42.63 18.74,42.57 18.72,42.46 18.69,42.43 18.62,42.44 18.58,42.45 18.32,42.34 18.21,42.08 18.23,41.98 18.27,41.88 18.27,41.78 18.18,41.73 17.59,41.73 17.38,41.52 15.28,41.52 15.19,41.58 15.21,41.69 16.44,42.93
GND on TOP (solid shape): 148.49,72.55 149,72.55 149,72.22 149,72.2 148.97,72.16 147.63,72.16 147.13,71.66 146.88,71.66 146.82,71.68 146.79,71.74 146.81,71.79 146.81,72.04 146.73,72.15 146.62,72.23 146.37,72.23 146.29,72.19 146.23,72.13 146.2,72.11 146.16,72.12 146.14,72.14 146.12,72.19 146.35,72.42 147.81,72.42 147.98,72.6 148.31,72.6 148.35,72.6 148.38,72.61 148.41,72.64
GND on TOP (solid shape): 176.64,58.53 176.67,58.45 176.75,58.42 177.09,58.42 177.62,57.9 177.86,57.9 177.94,57.82 177.94,56.95 177.93,56.93 177.22,56.93 177.22,57.82 177.19,57.9 177.11,57.94 176.75,57.94 176.67,57.9 176.64,57.82 176.64,57.55 176.1,57.55 176.07,57.58 176.05,57.61 176.02,57.64 176.02,57.69 176.04,57.71 176.06,57.73 176.07,57.76 176.12,57.83 176.14,57.92 176.14,58.2 176.13,58.28 176.09,58.34 176.08,58.35 176.06,58.4 176.47,58.81 176.64,58.81
GND on TOP (solid shape): 188.44,18.37 188.44,17.74 188.63,17.55 189.05,17.55 189.14,17.48 189.12,17.38 189.08,17.34 188.82,17.34 188.67,17.28 188.62,17.14 188.62,16.87 188.39,16.64 188.39,16.58 187.94,16.58 187.94,16.88 187.86,16.99 187.75,17.06 187.5,17.06 187.39,16.99 187.31,16.88 187.31,16.58 186.62,16.58 186.52,16.64 186.54,16.76 186.89,17.1 186.89,18.29 186.97,18.36 187.4,18.36 187.45,18.41 187.45,18.57 187.47,18.59 187.49,18.63 187.63,18.77 188.04,18.77
GND on TOP (solid shape): 195.89,95.77 195.89,93.78 195.27,93.16 195.04,93.16 194.85,93.36 194.85,93.76 195.06,94.01 195.2,94.3 195.2,94.59 195.23,94.67 195.31,94.69 195.36,94.69 195.62,94.79 195.73,95.05 195.62,95.31 195.36,95.41 195.32,95.41 195.22,95.4 195.22,95.48 195.23,95.62 195.24,95.75 195.32,95.83 195.83,95.83
GND on TOP (solid shape): 58.14,87.1 58.11,87.06 58.04,86.95 58.01,86.83 58.1,86.61 58.31,86.5 58.33,86.5 58.38,86.45 58.27,86.34 58.26,86.34 58.18,86.31 58.12,86.27 58.08,86.24 57.89,86.43 57.89,86.61 57.05,87.45 57.08,87.48 57.16,87.59 57.18,87.72 57.08,87.97 56.84,88.07 56.71,88.04 56.6,87.97 56.56,87.93 56.21,88.29 56.18,88.4 56.28,88.46 56.77,88.46
GND on TOP (solid shape): 120.23,91.93 120.29,91.94 120.33,91.92 120.36,91.91 120.42,91.87 120.44,91.8 120.43,91.75 120.55,91.48 120.82,91.37 121.01,91.37 121.01,91.16 121.01,90.99 121.01,90.97 120.59,90.55 120.56,90.47 120.53,90.41 120.47,90.37 120.39,90.35 120.39,90.35 120.34,90.35 120.23,90.46 120.23,90.5 120.23,91.64 120.25,91.7 120.26,91.75 120.25,91.81 120.23,91.87
GND on TOP (solid shape): 7.5,6.1 7.61,6.12 7.68,6.02 7.68,5.61 8.38,4.91 8.4,4.8 8.3,4.74 7.72,4.74 7.57,4.74 7.45,4.74 7.37,4.78 7.36,4.87 7.37,4.93 7.38,5 7.27,5.26 7.01,5.37 6.94,5.36 6.88,5.34 6.79,5.36 6.74,5.44 6.74,5.89 6.83,5.98 7.39,5.98
GND on TOP (solid shape): 53.86,9.75 53.86,9.55 53.93,9.4 54.08,9.34 54.28,9.34 54.95,8.66 54.95,8.66 55.04,8.57 55.04,8.33 54.75,8.04 54.75,7.99 54.68,7.99 54.62,8.03 54.57,8.06 54.25,8.38 54.25,8.48 54.22,8.56 54.14,8.59 54.03,8.59 53.49,8.59 53.49,8.86 53.49,8.93 53.45,9.01 53.38,9.04 53.14,9.04 52.93,9.26 52.93,9.77 53.12,9.96 53.39,9.96 53.46,9.98 53.53,10.02 53.56,10.05
GND on TOP (solid shape): 76.57,89.56 76.57,88.56 76.76,88.37 76.76,88.36 77.21,87.91 77.23,87.8 77.14,87.74 76.59,87.74 75.79,86.94 75.8,86.93 75.08,86.22 75.05,86.25 74.94,86.31 74.83,86.33 74.59,86.23 74.49,85.99 74.5,85.9 74.53,85.82 74.54,85.79 74.53,85.76 74.49,85.74 74.45,85.74 74.37,85.78 74.35,85.88 74.37,85.93 74.37,85.99 74.33,86.16 74.2,86.29 74.2,87.47 76.36,89.63 76.5,89.63
GND on TOP (solid shape): 161.57,74.6 161.6,74.54 161.65,74.51 161.68,74.5 161.68,74.41 161.55,74.41 161.23,74.09 161.23,73.73 161.49,73.48 161.85,73.48 162.13,73.76 162.53,73.76 162.66,73.63 162.66,73.35 162.65,73.26 162.56,73.22 162.11,73.22 162.05,73.27 160.77,73.27 160.76,73.27 160.71,73.25 160.68,73.3 160.68,73.36 160.7,73.37 160.74,73.41 160.75,73.47 160.75,73.55 160.98,73.78 160.98,74.19 161.01,74.27 161.09,74.29 161.11,74.29 161.34,74.38 161.46,74.6 161.47,74.64 161.57,74.64
GND on TOP (solid shape): 143.27,58.95 143.38,58.98 143.44,58.88 143.44,58.42 143.36,58.33 143.36,57.8 143.59,57.57 143.59,57.49 143.62,57.41 143.7,57.37 143.75,57.37 143.85,57.31 143.82,57.2 143.71,57.09 143.38,57.09 143.3,57.06 143.26,56.99 143.26,56.95 143.02,56.95 142.54,57.44 142.54,57.6 142.55,57.62 142.58,57.65 142.58,57.69 142.58,58.07 142.55,58.16 142.47,58.19 142.26,58.19 142.25,58.21 142.25,58.32 142.92,58.32 143,58.35 143.04,58.43 143.04,58.5 143.24,58.7 143.24,58.93
GND on TOP (solid shape): 162.77,74.56 163.18,74.56 163.35,74.38 165.21,74.38 166.61,72.98 166.61,72.92 166.57,72.84 166.47,72.83 166.41,72.85 166.34,72.85 166.12,72.78 165.99,72.58 165.99,72.57 165.95,72.53 165.33,72.53 165.33,72.88 164.69,73.51 164.45,73.51 164.45,73.63 164.42,73.7 164.35,73.73 163.97,73.73 163.94,73.73 163.92,73.72 163.89,73.7 163.63,73.96 163.3,73.96 163.04,74.22 162.85,74.41 162.05,74.41 161.97,74.46 161.97,74.56 161.97,74.59 161.98,74.61 161.98,74.95 161.98,75.02 162.04,75.07 162.26,75.07
GND on TOP (solid shape): 169.65,36.32 169.74,36.28 169.85,36.26 169.95,36.28 170.05,36.32 171.65,36.32 171.71,36.26 171.71,35.82 171.57,35.69 171.52,35.51 171.56,35.34 171.68,35.21 171.72,35.12 171.68,35.04 171.57,34.92 171.52,34.77 171.52,34.72 168.65,34.72 168.64,34.71 168.59,34.68 168.56,34.63 168.55,34.62 168.55,32.87 168.7,32.71 169.11,32.71 169.62,32.2 170.03,32.2 170.18,32.05 170.18,31.6 170.09,31.51 169.13,31.51 167.64,32.99 167.64,34.57 168.63,35.56 169.11,35.56 169.24,35.68 169.24,36.17 169.39,36.32
GND on TOP (solid shape): 19.21,28.26 19.27,28.27 19.32,28.24 19.48,28.08 20.74,28.08 20.77,28.09 20.83,28.12 20.9,28.13 21.37,28.13 21.64,27.86 21.64,27.31 21.68,27.27 21.62,27.21 21.59,27.22 21.55,27.24 21.5,27.24 21.46,27.24 21.38,27.26 21.34,27.34 21.34,27.4 21.1,27.64 20.86,27.4 20.86,27.3 20.83,27.26 20.77,27.27 20.49,27.55 19.89,27.55 19.8,27.65 19.43,27.65 19.43,27.82 19.4,27.9 19.31,27.93 19.21,27.93
GND on TOP (solid shape): 112.51,86.66 112.59,86.69 112.66,86.64 112.66,86.59 112.72,86.49 112.81,86.42 112.81,86.36 112.77,86.31 112.74,86.27 112.7,86.23 112.65,86.18 112.63,86.12 112.63,86.05 112.63,85.99 112.65,85.93 112.61,85.88 112.55,85.86 112.12,85.86 111.72,85.47 111.72,84.82 111.72,84.73 111.72,84.22 111.72,84.13 111.72,84.02 111.44,83.73 111.32,83.71 111.26,83.81 111.26,85.41
GND on TOP (solid shape): 148.9,74.11 148.97,74.08 149,73.62 149.01,73.58 149.01,73.52 148.4,73.52 148.39,73.54 148.35,73.56 148.31,73.57 147.93,73.57 147.85,73.53 147.81,73.45 147.81,73.29 147.59,73.07 147.4,73.07 147.32,73.1 147.3,73.18 147.32,73.22 147.34,73.26 147.35,73.34 147.36,73.39 147.35,73.44 147.34,73.52 147.27,73.62 147.16,73.7 147.15,73.76 147.17,73.82 147.26,73.91 148.56,73.91 148.61,73.95 148.63,73.96 148.77,74.11
GND on TOP (solid shape): 193.19,33.93 193.57,33.55 193.57,33.11 193.37,32.91 193.15,32.78 193.06,32.54 193.06,32.52 193.03,32.45 192.96,32.41 192.01,32.41 191.94,32.45 191.91,32.52 191.91,32.54 191.91,32.8 192.28,33.17 192.34,33.16 192.59,33.27 192.7,33.53 192.7,33.57 192.69,33.63 192.69,33.8 192.65,33.93 192.54,34 192.51,34.01 192.51,34.25 192.54,34.26 192.63,34.32 192.68,34.41 192.69,34.45 193.19,34.45
GND on TOP (solid shape): 146.52,89.54 147.54,89.54 147.79,89.28 147.79,88.18 147.73,88.08 147.62,88.1 147.28,88.45 146.96,88.45 146.93,88.5 146.91,88.58 146.96,88.65 147.11,88.78 147.17,88.98 147.06,89.24 146.8,89.35 146.64,89.31 146.51,89.21 146.43,89.17 146.36,89.2 146.24,89.28 146.09,89.31 146.03,89.3 145.98,89.36 146.16,89.54 146.52,89.54
GND on TOP (solid shape): 122.71,18.55 122.8,18.49 122.78,18.38 122.76,18.36 122.76,18.13 122.7,18.04 122.59,18.06 122.54,18.11 121.63,18.11 121.5,18.25 121.31,18.3 120.94,17.93 121.31,17.57 121.5,17.62 121.63,17.76 122.4,17.76 122.53,17.63 122.53,17.18 122.33,16.97 121.68,16.97 119.61,14.9 119.39,15.13 119.39,18.34 119.48,18.42 121.25,18.42 121.38,18.55
GND on TOP (solid shape): 142,97.09 142.54,97.09 142.84,96.78 142.85,96.78 143.13,96.51 143.57,96.51 143.9,96.18 143.9,93.85 143.67,93.62 142.98,93.62 142.92,93.56 142.48,93.56 142.4,93.53 142.36,93.45 142.36,93.15 142.3,93.05 142.19,93.07 141.79,93.48 140.21,93.48 140.21,93.53 140.17,93.61 140.09,93.64 139.86,93.64 139.61,93.89 139.61,94.39 139.69,94.39 139.77,94.43 139.81,94.51 139.81,94.94 139.77,95.02 139.69,95.06 139.63,95.06 139.63,95.12 139.64,95.14 139.69,95.23 139.7,95.33 139.71,95.35 140.04,95.69 140.04,96.37 140.92,97.25 141.83,97.25
GND on TOP (solid shape): 201.26,85.71 201.28,85.6 201.19,85.53 201.01,85.47 200.89,85.34 200.6,85.34 199.93,84.67 199.87,84.64 199.8,84.66 199.77,84.68 199.73,84.68 199.36,84.68 199.27,84.74 199.27,84.84 199.33,84.98 199.34,85.13 199.34,85.14 199.37,85.19 199.44,85.21 200.08,85.29 200.23,85.92 200.41,86.1 200.86,86.1
GND on TOP (solid shape): 45.78,15.08 45.78,14.02 45.83,13.97 45.77,13.92 45.7,13.93 45.66,13.93 45.62,13.93 45.55,13.92 44.95,14.52 44.64,14.52 44.63,14.55 44.54,14.65 44.41,14.69 44.37,14.68 44.29,14.7 44.25,14.78 44.25,14.82 44.34,14.91 44.43,14.94 44.51,14.88 44.64,14.73 44.84,14.67 45.1,14.78 45.21,15.04 45.2,15.1 45.19,15.16 45.2,15.25 45.28,15.3 45.56,15.3
GND on TOP (solid shape): 165.63,68.48 165.59,68.43 165.57,68.43 165.37,68.3 165.3,68.07 165.3,68.03 165.31,67.96 165.3,67.94 165.3,67.6 165.2,67.6 164.9,67.6 164.82,67.59 164.75,67.54 164.65,67.52 164.58,67.58 164.47,67.75 164.29,67.83 164.25,67.84 164.24,67.88 164.23,67.94 164.21,68 164.19,68.26 164.4,68.4 164.49,68.43 164.55,68.52 164.56,68.55 165.56,68.55
GND on TOP (solid shape): 52.75,11.28 52.86,11.3 52.92,11.21 52.92,10.8 52.95,10.77 52.97,10.73 52.98,10.69 52.9,10.61 52.88,10.51 52.87,10.46 52.87,10.2 52.58,9.91 52.58,9.86 52.58,9.85 52.58,8.94 52.51,8.88 52.48,8.88 52.45,8.88 52.4,8.88 52.36,8.87 52.12,8.72 52.07,8.43 51.81,8.18 51.64,8.18 51.39,8.43 51.39,8.71 50.79,9.31 50.78,9.37 50.83,9.4 50.86,9.4 50.91,9.45 50.93,9.45 51.19,9.55 51.3,9.81 51.3,9.83
GND on TOP (solid shape): 149.28,76.36 149.32,76.34 149.36,76.33 149.74,76.33 149.79,76.34 149.82,76.36 149.84,76.38 149.98,76.38 149.98,76.26 150.01,76.18 150.09,76.15 150.3,76.15 150.3,76.02 150.09,76.02 150.02,75.99 149.98,75.93 149.97,75.89 149.54,75.89 149.48,75.94 149.13,75.94 149.11,75.95 149.07,75.98 149.03,75.99 148.65,75.99 148.58,75.96 148.54,75.89 148.54,75.87 148.42,75.75 148.2,75.75 148.08,75.84 147.93,75.87 147.86,75.87 147.79,75.85 147.73,75.85 147.73,76.12 147.77,76.16 147.82,76.18 148.28,76.18 148.48,76.38 149.27,76.38
GND on TOP (solid shape): 200.78,21.3 200.75,21.3 200.35,20.9 200.35,20.82 200.28,20.76 200.23,20.68 200.21,20.61 200.2,20.55 200.2,20.53 200.27,20.36 200.41,20.24 200.47,20.24 200.52,20.2 200.53,20.14 200.33,20.03 200.23,19.82 200.23,19.8 200.17,19.74 198.77,19.74 198.73,19.78 198.7,19.88 198.77,19.95 198.8,19.96 198.97,20.13 198.99,20.19 198.99,20.24 198.99,20.28 199.02,20.3 199.06,20.32 199.15,20.35 199.21,20.41 199.25,20.41 200.24,21.4 200.77,21.4
GND on TOP (solid shape): 209.33,104.97 209.33,104.69 209.11,104.47 208.88,104.17 208.74,103.83 208.74,103.53 208.68,103.48 208.38,103.48 208.25,103.6 208.24,103.6 207.95,103.75 207.62,103.72 207.35,103.76 207.09,103.67 206.88,103.76 206.67,103.81 206.65,103.81 206.49,103.97 205.47,103.97 205.46,103.96 204.44,103.96 204.37,104.03 204.37,104.11 205.37,105.1 205.59,105.1 205.65,105.03 206.48,105.03 206.48,105.04 206.66,105.04 206.68,105.03 207.11,104.93 207.5,105.19 207.56,105.19 207.59,105.19 207.61,105.2 209.09,105.2
GND on TOP (solid shape): 166.53,58.6 166.58,58.59 166.73,58.59 166.78,58.54 166.78,58.31 167.23,57.86 167.23,57.81 166.89,57.47 166.87,57.47 166.65,57.4 166.52,57.22 166.47,57.16 166.4,57.15 166.36,57.16 166.32,57.16 166.06,57.05 165.95,56.79 165.95,56.77 165.91,56.73 164.95,56.73 164.53,57.14 164.53,57.24 164.58,57.29 164.66,57.29 164.81,57.14 165.07,57.14 165.09,57.13 165.12,57.11 165.17,57.1 165.55,57.1 165.63,57.13 165.66,57.21 165.66,57.38 165.73,57.45 165.73,57.66 165.77,57.67 165.84,57.71 165.87,57.78 165.87,58.06 165.96,58.16 166.09,58.16 166.36,58.42 166.36,58.62 166.47,58.62
GND on TOP (solid shape): 208.72,13.05 208.78,13.14 208.89,13.12 209.25,12.76 209.27,12.65 209.18,12.59 208.71,12.59 208.46,12.34 208.46,11.56 208.78,11.24 208.78,10.54 208.69,10.45 208.41,10.45 208.39,10.46 208.36,10.48 208.32,10.49 208.15,10.49 208.15,10.64 208.16,10.65 208.19,10.69 208.19,10.73 208.19,11.11 208.16,11.19 208.08,11.23 207.88,11.23 207.84,11.22 207.78,11.22 207.73,11.26 207.73,11.32 207.65,11.43 207.54,11.5 207.33,11.5 207.28,11.53 207.29,11.59 208.72,13.01
GND on TOP (solid shape): 187.37,22.83 187.58,22.83 187.63,22.77 187.84,22.77 187.96,22.69 188.11,22.65 188.26,22.69 188.38,22.77 188.83,22.77 188.83,22.68 188.76,22.67 188.72,22.65 188.63,22.65 188.56,22.62 188.53,22.55 188.53,22.35 188.55,22.28 188.57,22.22 188.55,22.16 188.53,22.1 188.53,21.9 188.18,21.9 188.17,21.91 188.14,21.93 188.1,21.94 187.81,21.94 187.54,22.22 187.52,22.23 187.47,22.27 187.28,22.27 187.19,22.33 187.21,22.44 187.26,22.49 187.29,22.54 187.31,22.61 187.31,22.83 187.37,22.83
GND on TOP (solid shape): 188.98,42.63 189.05,42.52 189.18,42.48 189.48,42.48 189.61,42.52 189.68,42.63 189.7,42.67 190.1,42.67 190.23,42.53 190.42,42.47 190.5,42.48 190.58,42.51 190.61,42.53 190.85,42.29 190.85,41.52 190.8,41.47 190.75,41.47 190.64,41.46 190.59,41.45 190.55,41.45 190.52,41.45 190.47,41.46 190.36,41.47 189.55,41.47 189.51,41.46 189.45,41.46 189.4,41.47 189.33,41.47 189.31,41.48 189.26,41.5 189.23,41.55 189.22,41.6 188.71,42.11 188.71,42.57 188.73,42.63 188.8,42.63 188.84,42.67 188.96,42.67
GND on TOP (solid shape): 107.58,18.39 109.73,18.39 109.83,18.29 109.83,17.5 109.64,17.31 108.54,17.31 107.88,16.65 107.11,16.65 106.68,16.21 106.68,15.79 106.61,15.69 106.5,15.71 105.24,16.98 105.24,17.84 105.62,17.84 105.67,17.85 105.7,17.87 105.72,17.88 105.86,17.88 105.89,17.83 105.88,17.79 105.85,17.75 105.84,17.71 105.84,17.5 105.87,17.42 105.95,17.39 106.02,17.39 106.2,17.21 106.6,17.21 106.62,17.19 106.66,17.15 106.71,17.14 107.36,17.14 107.44,17.18 107.48,17.26 107.48,17.64 107.47,17.68 107.44,17.72 107.43,17.73 107.43,17.85 107.4,17.88 107.42,17.92 107.43,17.94 107.43,17.97 107.43,18.35 107.42,18.39 107.41,18.42 107.39,18.45 107.39,18.46 107.45,18.52
GND on TOP (solid shape): 108.06,10.73 108.16,10.73 108.28,10.59 108.46,10.53 108.5,10.51 108.55,10.49 108.59,10.48 108.59,9.57 108.23,9.21 108.23,8.91 108.19,8.86 107.46,8.86 107.4,8.84 107.36,8.79 107.33,8.79 107.25,8.76 107.22,8.68 107.22,8.59 106.91,8.59 106.91,8.86 106.87,8.94 106.79,8.97 106.69,8.97 106.58,9.08 106.58,9.36 106.76,9.53 107.12,9.53 107.19,9.54 107.26,9.57 107.3,9.65 107.3,9.87 107.28,9.93 107.25,9.97 107.24,9.97 107.24,10.14 107.31,10.22 107.44,10.22 107.52,10.25 107.56,10.33 107.56,10.79 107.63,10.87 107.92,10.87
GND on TOP (solid shape): 157.63,69.38 157.85,69.38 157.97,69.44 158.08,69.55 158.19,69.57 158.25,69.48 158.25,69.1 158.13,68.97 158.13,68.26 158.11,68.2 158.06,68.16 158.03,68.17 158,68.18 157.97,68.18 157.72,68.42 157.71,68.48 157.7,68.52 157.52,68.69 157.39,68.72 157.27,68.69 157.09,68.52 157.07,68.45 157.06,68.39 157.07,68.31 157.1,68.24 157.06,68.19 157.01,68.17 156.77,68.17 156.56,67.96 156.44,68 156.44,68.36 156.36,68.45 156.36,68.72 156.3,68.86 156.15,68.92 156.14,68.92 156.09,68.95 156.1,69.01 156.81,69.71 156.99,69.71 157.07,69.79 157.22,69.79
GND on TOP (solid shape): 38.91,52.23 38.91,51.97 38.97,51.82 39.12,51.76 39.39,51.76 39.76,51.38 39.78,51.32 39.73,51.29 39.62,51.29 39.61,51.33 39.54,51.45 39.4,51.5 39.12,51.5 39.03,51.47 38.95,51.41 38.87,51.37 38.79,51.41 38.72,51.47 38.62,51.5 38.34,51.5 38.19,51.43 38.13,51.28 38.13,50.98 38.14,50.93 38.15,50.89 38.17,50.85 37.96,50.65 37.89,50.66 37.85,50.66 37.74,50.64 37.63,50.59 37.53,50.58 37.47,50.67 37.47,52.26 37.58,52.38 38.76,52.38
GND on TOP (solid shape): 195.15,39.96 195.18,39.95 195.21,39.93 195.24,39.92 195.45,39.92 195.48,39.93 195.51,39.95 195.55,39.96 195.58,39.95 195.61,39.93 195.64,39.92 195.84,39.92 196.01,39.75 196.87,39.75 196.97,39.65 196.97,36.24 196.87,36.14 193.42,36.14 193.34,36.22 193.34,39.86 193.39,39.91 193.45,39.91 193.49,39.92 193.52,39.94 193.55,39.95 193.59,39.94 193.61,39.93 193.64,39.92 193.85,39.92 193.88,39.93 193.91,39.95 193.95,39.96 193.98,39.95 194.01,39.93 194.04,39.92 194.25,39.92 194.28,39.93 194.31,39.95 194.35,39.96 194.38,39.95 194.41,39.93 194.44,39.92 194.65,39.92 194.68,39.93 194.71,39.95 194.75,39.96 194.78,39.95 194.81,39.93 194.84,39.92 195.05,39.92 195.08,39.93 195.11,39.95
GND on TOP (solid shape): 81.21,24.81 81.22,24.78 81.22,24.75 81.2,24.68 81.19,24.6 81.3,24.34 81.56,24.23 81.67,24.25 81.78,24.3 81.81,24.31 81.85,24.3 81.92,24.25 82,24.23 82.07,24.23 82.19,24.1 82.19,23.75 82.04,23.59 81.51,23.59 80.9,22.98 80.41,22.98 80.31,23.09 80.31,23.45 80.32,23.48 80.34,23.53 80.36,23.55 80.39,23.56 80.44,23.56 80.7,23.66 80.81,23.92 80.76,24.11 80.62,24.25 80.6,24.27 80.6,24.31 80.61,24.35 80.62,24.39 80.62,24.81 80.69,24.89 81.13,24.89
GND on TOP (solid shape): 49.37,38.92 49.37,38.66 49.43,38.51 49.58,38.44 49.86,38.44 50.01,38.51 50.08,38.66 50.08,38.92 50.38,39.22 52.21,39.22 52.3,39.16 52.28,39.05 50.75,37.52 49,37.52 48.91,37.57 48.9,37.66 48.92,37.73 48.93,37.81 48.82,38.07 48.56,38.17 48.37,38.12 48.24,37.98 47.04,37.98 46.03,38.98 46.03,39.15 46.08,39.24 46.18,39.24 46.21,39.23 46.23,39.23 48.49,39.23 48.55,39.24 48.59,39.29 48.61,39.31 48.98,39.31
GND on TOP (solid shape): 89.91,105.78 89.97,105.75 90.09,105.69 90.21,105.67 90.31,105.68 90.41,105.72 90.47,105.74 90.53,105.71 90.57,105.69 90.61,105.68 90.94,105.68 90.94,105.45 90.83,105.34 90.83,105.02 90.79,104.99 90.77,104.94 90.75,104.91 90.5,104.91 90.48,104.94 90.41,105.03 90.29,105.06 90.01,105.06 89.92,105.04 89.84,104.98 89.76,104.94 89.68,104.98 89.61,105.04 89.51,105.06 89.31,105.06 89.16,105.22 89.1,105.22 89,105.28 89.02,105.39 89.08,105.48 89.11,105.6 89.11,105.61 89.22,105.73 89.78,105.73 89.81,105.74 89.85,105.75
GND on TOP (solid shape): 143.59,91.24 143.57,91.17 143.58,91.06 143.59,91 143.6,91 143.61,90.97 143.94,90.76 144.27,90.97 144.28,91 144.62,91 144.87,90.75 144.87,89.44 144.8,89.35 144.69,89.37 144.64,89.42 144.59,89.45 144.59,89.5 144.21,89.88 143.69,90.4 143.68,90.41 143.55,90.61 143.33,90.68 143.14,90.63 143.01,90.48 142.87,90.48 142.87,90.84 142.87,90.88 142.87,91.08 142.85,91.15 142.78,91.19 142.74,91.2 142.74,91.59 142.75,91.6 143.19,91.6 143.22,91.6
GND on TOP (solid shape): 155.9,76.03 155.92,75.96 155.89,75.89 155.75,75.75 155.75,75.47 155.74,75.44 155.7,75.42 155.56,75.39 155.44,75.29 155.42,75.27 155.39,75.25 155.33,75.3 155.27,75.33 155.02,75.33 154.95,75.29 154.89,75.24 154.85,75.25 154.82,75.26 154.43,75.26 154.41,75.29 153.47,75.29 153.32,75.44 153.35,75.48 153.37,75.52 153.4,75.56 153.4,75.64 153.43,75.63 153.45,75.63 153.83,75.63 153.91,75.66 153.94,75.74 153.95,75.82 153.98,75.87 154.03,75.86 154.29,75.61 154.36,75.55 154.81,75.55 154.87,75.58 154.9,75.61 155.38,76.08 155.87,76.08
GND on TOP (solid shape): 205.55,12.44 206.03,12.44 206.12,12.38 206.1,12.27 206.07,12.24 206.07,11.96 206.04,11.88 205.96,11.86 205.9,11.86 205.84,11.86 205.77,11.84 205.59,11.66 205.57,11.59 205.57,11.52 205.57,11.46 205.59,11.39 205.78,11.21 205.71,11.14 204.94,11.14 204.86,11.17 204.84,11.25 204.84,11.28 204.83,11.32 204.82,11.4 204.75,11.51 204.63,11.59 204.38,11.59 204.28,11.53 204.21,11.45 203.79,11.45 203.53,11.7 203.4,11.7 203.3,11.77 203.32,11.88 203.64,12.19 203.64,12.56 203.71,12.63 205.36,12.63
GND on TOP (solid shape): 109.32,83.49 109.31,83.46 109.31,83.26 109.05,83 109.05,82.51 109.02,82.44 108.95,82.4 108.93,82.43 108.86,82.45 108.8,82.46 108.73,82.45 108.67,82.43 108.54,82.3 108.47,82.3 108.47,82.38 108.12,82.73 107.15,82.73 106.71,83.17 106.71,83.24 106.75,83.31 106.83,83.33 106.9,83.32 106.96,83.32 107.18,83.37 107.36,83.49 107.43,83.52 107.5,83.5 107.66,83.41 107.85,83.38 108.05,83.42 108.23,83.53 108.3,83.56 108.37,83.52 108.56,83.39 108.78,83.35 109,83.39 109.18,83.51 109.23,83.56
GND on TOP (solid shape): 209.58,11.89 210.04,11.89 210.34,11.58 210.35,11.53 210.31,11.5 210.2,11.5 210.12,11.46 210.08,11.38 210.08,10.19 210.08,10.17 210.06,10.13 210.02,10.12 209.95,10.14 209.88,10.15 209.62,10.04 209.51,9.78 209.51,9.75 209.46,9.69 209.46,9.36 209.44,9.31 209.43,9.28 209.43,8.67 209.4,8.62 209.35,8.63 209.32,8.66 209.32,9.28 209.3,9.35 209.24,9.39 209.21,9.41 209.21,9.61 208.86,9.96 208.97,10.07 209.2,10.07 209.28,10.11 209.32,10.19 209.32,11.38 209.28,11.46 209.2,11.5 209.01,11.5 208.81,11.7 208.81,12.19 208.86,12.25 209.22,12.25
GND on TOP (solid shape): 149.05,80.22 149.05,79.97 149.09,79.89 149.17,79.85 149.37,79.85 149.44,79.88 149.48,79.95 149.49,79.99 149.61,79.99 149.62,79.95 149.66,79.88 149.73,79.85 149.96,79.85 149.96,79.73 149.73,79.73 149.66,79.7 149.62,79.64 149.61,79.6 149.49,79.6 149.48,79.64 149.44,79.7 149.37,79.73 149.17,79.73 149.09,79.7 149.05,79.61 149.05,79.22 149.05,79.21 148.21,79.21 148.11,79.31 148.15,79.39 148.15,79.65 148.08,79.76 147.97,79.84 147.81,79.84 147.71,79.84 147.69,79.83 147.65,79.83 147.62,79.85 147.57,79.94 147.49,80.01 147.45,80.09 147.48,80.17 147.66,80.35 148.92,80.35
GND on TOP (solid shape): 139,72.18 139.06,72.15 139.1,72.13 139.14,72.11 139.25,72.11 139.27,72.07 139.27,72.02 139.27,71.96 139.3,71.81 139.39,71.69 139.44,71.64 139.5,71.6 139.5,71.1 139.31,70.91 139.25,70.92 139.22,70.92 139.15,70.91 139.09,70.9 139.01,70.82 138.89,70.82 138.88,70.81 138.81,70.89 138.81,71.01 138.75,71.16 138.6,71.21 138.33,71.21 138.16,71.38 138.16,71.41 138.09,71.51 137.98,71.59 137.87,71.59 137.87,71.73 137.91,71.81 138,71.82 138.06,71.81 138.12,71.8 138.35,71.88 138.47,72.08 138.49,72.12 138.52,72.14 138.55,72.12 138.59,72.1 138.85,72.1 138.89,72.12 138.94,72.15
GND on TOP (solid shape): 163.72,59.29 163.88,59.12 163.88,58.94 163.84,58.93 163.78,58.89 163.75,58.82 163.75,58.62 163.76,58.58 163.77,58.55 163.79,58.49 163.77,58.44 163.76,58.4 163.75,58.37 163.75,58.17 163.78,58.09 163.84,58.05 163.88,58.05 163.88,57.95 163.84,57.94 163.78,57.9 163.75,57.83 163.72,57.55 163.65,57.52 163.55,57.52 163.32,57.3 162.98,57.3 162.05,58.23 162.28,58.46 162.76,58.46 162.92,58.61 162.97,58.62 163,58.58 163,58.48 163.03,58.41 163.1,58.38 163.49,58.38 163.56,58.41 163.59,58.48 163.59,58.82 163.56,58.88 163.51,58.92 163.47,58.93 163.47,59.1 163.24,59.32 163.22,59.44 163.31,59.5 163.72,59.5
GND on TOP (solid shape): 194.35,11.09 194.2,10.96 194.15,10.7 194.17,10.64 194.18,10.61 193.61,10.04 193.47,10.04 193.41,9.98 193.23,9.98 193.15,10.03 193.14,10.13 193.17,10.2 193.18,10.29 193.07,10.54 192.82,10.65 192.65,10.61 192.53,10.51 192.45,10.47 192.36,10.5 192.26,10.59 192.14,10.64 192.06,10.71 192.08,10.81 192.22,10.95 192.55,10.95 192.56,10.96 192.6,10.96 192.99,11.35 193.03,11.35 193.09,11.31 193.13,11.3 193.51,11.3 193.57,11.32 193.6,11.37 193.61,11.38 193.87,11.65 194.02,11.65 194.13,11.75 194.35,11.75
GND on TOP (solid shape): 191.01,38.11 191.04,38 190.94,37.94 190.9,37.94 190.89,37.96 190.81,38.05 190.7,38.08 190.42,38.08 190.27,38.02 190.2,37.87 190.2,37.57 190.27,37.41 190.42,37.35 190.7,37.35 190.81,37.39 190.89,37.47 190.91,37.5 191.07,37.5 191.1,37.46 191.14,37.43 191.18,37.36 191.15,37.28 190.81,36.93 190.6,36.93 190.6,36.97 190.56,37.04 190.49,37.06 190.05,37.06 189.99,37.08 189.94,37.08 189.46,37.08 189.34,37.21 189.05,37.21 189.04,37.22 188.98,37.24 188.92,37.25 188.85,37.25 188.85,37.25 187.72,37.25 187.01,37.97 187,37.97 186.97,38.01 186.97,38.17 187.12,38.32 187.24,38.32 187.62,37.94 188.2,37.94 188.45,38.2 188.79,38.2 188.8,38.21 190.2,38.21 190.44,38.44 190.68,38.44
GND on TOP (solid shape): 75.49,13.81 75.58,13.84 75.65,13.78 75.69,13.7 75.75,13.64 75.75,13.39 74.84,12.47 74.77,12.47 74.69,12.44 74.66,12.35 74.66,12.27 74.64,12.21 74.63,12.16 74.63,11.42 74.2,10.99 74.2,10.76 74.2,10.72 74.18,10.63 74.09,10.6 74,10.6 73.92,10.62 73.88,10.7 73.88,10.76 73.64,11 73.4,10.76 73.4,10.68 73.37,10.63 73.31,10.64 73.13,10.83 73.12,10.83 72.76,11.19 72.76,11.6 72.8,11.64 73.04,11.64 73.1,11.65 73.14,11.69 73.15,11.7 73.56,11.7 73.68,11.82 73.69,11.82 74.35,12.48 74.35,13.62 75.3,13.62
GND on TOP (solid shape): 42.59,70.16 42.64,70.18 42.68,70.13 42.68,69.9 42.41,69.63 42.31,69.48 42.27,69.31 42.41,68.98 42.73,68.85 42.78,68.85 42.86,68.83 42.89,68.75 42.89,68.59 42.91,68.53 42.91,68.5 42.9,68.43 42.87,68.36 42.85,68.33 42.85,68.09 42.82,68.02 42.75,67.99 42.63,67.97 42.52,67.9 42.48,67.87 42.29,68.06 41.36,68.06 41.18,67.88 41.07,67.86 41.01,67.95 41.01,69.51 41.54,69.51 41.86,69.64 42,69.96 42,70 42.02,70.08 42.1,70.11 42.53,70.11
GND on TOP (solid shape): 42.86,65.5 42.94,65.42 42.97,65.3 42.96,65.26 42.97,65 43.15,64.91 43.22,64.91 43.31,64.85 43.29,64.74 43.23,64.63 43.21,64.51 43.21,64.44 43.08,64.44 43.08,64.5 42.74,64.84 42.4,64.5 42.4,64.44 41.66,64.44 41.01,65.09 41.01,65.23 41.07,65.33 41.18,65.31 41.54,64.95 41.88,64.95 41.9,64.95 41.97,64.95 42.04,64.99 42.54,65.49 42.61,65.49 42.79,65.55
GND on TOP (solid shape): 27.02,39.72 27.24,39.63 27.48,39.71 27.51,39.72 27.54,39.71 27.82,39.57 28.13,39.6 28.16,39.61 28.22,39.55 28.18,39.51 28.18,38.59 27.55,38.59 27.5,38.58 27.47,38.56 27.4,38.53 27.34,38.55 26.97,38.58 26.76,38.28 26.75,38.23 24.73,38.23 24.61,38.35 24.61,39.05 24.65,39.14 24.75,39.15 24.97,39.15 25.15,39.28 25.22,39.32 25.3,39.29 25.68,39.18 26.04,39.34 26.25,39.55 26.77,39.55 26.79,39.55 26.98,39.75
GND on TOP (solid shape): 104.53,8.74 104.49,8.73 104.37,8.66 104.33,8.53 104.33,8.25 104.39,8.11 104.53,8.05 104.96,8.05 105.06,8.07 105.13,8.15 105.15,8.17 105.29,8.17 105.31,8.15 105.33,8.11 105.37,8.08 105.41,7.99 105.37,7.91 105.31,7.84 105.29,7.75 105.29,7.47 105.35,7.33 105.49,7.27 105.92,7.27 105.95,7.27 105.98,7.28 106.23,7.28 106.41,7.1 106.41,6.75 106.35,6.68 104.94,6.68 103.63,8 101.07,8 100.91,8.15 100.91,8.63 101.02,8.75 103.05,8.75 103.43,8.37 103.54,8.37 103.54,8.32 103.58,8.26 103.65,8.24 104.03,8.24 104.1,8.27 104.13,8.34 104.13,8.59 104.43,8.89 104.47,8.91 104.53,8.91
GND on TOP (solid shape): 154.46,101.6 154.46,100.84 154.58,100.71 155.45,100.71 160.5,95.65 160.5,95.11 160.45,95.06 157.99,95.06 157.74,94.81 157.74,94.31 157.96,94.09 157.99,94 157.92,93.92 157.86,93.9 157.8,93.87 157.77,93.85 157.28,94.34 157.28,94.35 157.14,94.55 156.92,94.63 156.88,94.62 156.84,94.62 156.76,94.63 156.72,94.69 156.58,94.88 156.36,94.96 156.21,94.92 156.08,94.83 155.64,94.83 155.61,94.83 155.59,94.84 152.36,94.84 152.34,94.83 152.31,94.83 150.93,94.83 150.66,95.1 149.36,95.1 148.58,95.88 147.61,95.88 147.26,96.23 147.26,96.78 147.26,96.8 147.27,96.82 147.27,97.18 147.34,97.25 147.7,97.25 147.75,97.31 148.03,97.31 148.29,97.56 151.6,97.56 151.68,97.48 152.93,97.48 153.64,98.19 153.64,100.1 152.96,100.78 150.95,100.78 150.44,101.29 150.44,102.05 150.57,102.18 152.09,102.18 152.22,102.31 152.22,102.82 152.47,103.07 152.98,103.07
GND on TOP (solid shape): 110.75,83.97 110.86,83.99 110.92,83.9 110.92,83.73 110.69,83.5 110.49,83.5 110.38,83.43 110.3,83.31 110.3,83.06 110.27,83.02 110.23,83 109.96,82.72 109.96,82.52 109.92,82.44 109.84,82.42 109.81,82.45 109.75,82.47 109.68,82.47 109.61,82.47 109.55,82.45 109.51,82.41 109.43,82.43 109.39,82.51 109.39,82.86 109.55,83.02 109.68,83.02 109.75,83.02 109.86,83.1 109.94,83.21 109.94,83.28 109.94,83.39 109.94,83.46 110.01,83.51 110.06,83.55 110.33,83.55
GND on TOP (solid shape): 201.63,82.56 201.66,82.61 201.72,82.59 201.75,82.56 203.68,82.56 203.68,82.4 203.67,82.35 203.67,82.31 203.67,82.27 203.68,82.22 203.68,81.69 203.67,81.64 203.67,81.6 203.67,81.56 203.68,81.51 203.68,81.4 203.59,81.41 202.4,81.41 202.32,81.37 202.28,81.29 202.28,80.78 202.32,80.7 202.4,80.67 203.42,80.67 203.47,80.64 203.46,80.58 203.43,80.56 203.41,80.52 203.07,80.18 203,80.13 202.95,80.06 202.85,79.96 202.78,79.88 202.68,79.9 202.23,80.35 202.24,80.42 202.24,80.46 202.13,80.73 201.87,80.83 201.78,80.82 201.7,80.79 201.67,80.77 200.98,81.46 200.98,81.7 201.63,82.36
GND on TOP (solid shape): 200.42,27.3 200.42,27.17 200.31,27.02 200.28,26.85 200.4,26.54 200.71,26.41 200.74,26.39 200.77,26.36 200.76,26.3 200.75,26.25 200.75,26.21 200.76,26.15 200.65,26.03 200.64,25.98 200.61,25.94 200.54,25.97 200.46,25.98 200.42,26 200.41,26.03 200.41,26.2 200.34,26.31 200.23,26.38 199.98,26.38 199.87,26.31 199.8,26.2 199.8,25.99 199.64,25.84 199.53,25.84 199.49,25.88 199.3,25.88 199.27,25.88 199.05,25.88 199.04,25.91 199.04,25.95 199.04,25.97 198.58,26.42 198.51,26.45 198.47,26.53 198.47,26.89 198.48,26.89 198.48,27.31 198.55,27.38 198.85,27.38 198.97,27.26 198.97,27.22 199.22,26.96 199.28,26.96 199.28,26.96 199.71,26.96 199.71,26.96 199.85,26.96 200.28,27.39 200.33,27.39
GND on TOP (solid shape): 155.53,82.55 155.53,82.54 155.53,82.15 155.56,82.07 155.65,82.04 155.85,82.04 155.92,82.07 155.96,82.13 155.97,82.17 156.09,82.17 156.1,82.13 156.11,82.1 156.13,82.08 156.15,81.99 156.1,81.91 155.91,81.7 155.93,81.41 155.95,81.38 154.81,80.24 154.7,80.22 154.63,80.31 154.63,80.37 154.6,80.45 154.52,80.48 154.14,80.48 154.11,80.48 154.08,80.46 154.04,80.44 153.98,80.51 154.01,80.54 154.01,81.03 153.9,81.15 153.9,81.44 153.99,81.66 153.92,81.89 153.92,81.91 154.05,82.04 154.05,82.3 154.04,82.34 154.01,82.38 153.99,82.42 154.03,82.47 154.22,82.47 154.24,82.46 154.27,82.44 154.32,82.43 154.7,82.43 154.78,82.46 154.81,82.54 154.81,82.75 155.33,82.75
GND on TOP (solid shape): outline of 96 points within 141.14,66.22 146.93,68.61
GND on TOP (solid shape): 142.26,67.98 142.31,67.96 142.35,67.92 142.34,67.89 142.34,67.64 142.41,67.53 142.53,67.46 142.56,67.41 142.57,67.35 142.56,67.34 142.54,67.29 142.5,67.26 142.28,67.26 142.17,67.19 142.1,67.08 142.1,66.83 142.15,66.75 142.22,66.68 142.19,66.6 142.12,66.57 141.74,66.57 141.43,66.87 141.44,66.95 141.43,67.01 141.41,67.06 141.41,67.07 141.35,67.15 141.27,67.21 141.26,67.21 141.23,67.24 141.17,67.26 141.11,67.26 141.05,67.26 140.99,67.24 140.96,67.23 140.9,67.29 141.05,67.44 141.13,67.43 141.19,67.44 141.25,67.46 141.44,67.65 141.51,67.64 141.56,67.6 141.59,67.56 141.65,67.5 141.72,67.46 141.98,67.46 142.09,67.53 142.16,67.64 142.16,67.89 142.13,67.94 142.17,67.97 142.21,67.98
GND on TOP (solid shape): 154.69,11.94 155.16,11.94 155.2,11.94 155.42,11.94 155.46,11.94 155.58,11.94 155.62,11.97 155.77,11.97 155.81,11.96 156.01,11.96 156.04,11.97 156.11,12 156.17,11.97 156.21,11.96 156.41,11.96 156.44,11.97 156.51,12 156.57,11.97 156.61,11.96 156.81,11.96 156.85,11.97 157.01,11.97 157.03,11.95 157.16,11.95 157.2,11.96 157.42,11.96 157.43,11.95 157.55,11.83 157.55,11.04 157.4,10.89 156.85,10.89 156.81,10.9 156.61,10.9 156.53,10.86 156.5,10.79 156.41,10.79 156.41,10.76 156.41,10.08 156.36,10.03 156.26,10.03 156.21,10.08 156.21,10.76 156.21,10.79 156.12,10.79 156.09,10.86 156.01,10.9 155.81,10.9 155.77,10.89 154.9,10.89 154.9,10.76 154.43,10.3 153.59,10.3 153.33,10.04 153.33,9.84 152.39,9.84 152.07,10.16 152.38,10.47 153.11,10.47 153.28,10.64 153.28,11.88 153.64,12.24 154.38,12.24
GND on TOP (solid shape): 160.87,60.45 160.9,60.5 160.96,60.49 161,60.45 161.27,60.45 161.3,60.41 161.33,60.34 161.3,60.27 160.97,59.94 160.97,58.32 160.99,58.25 160.96,58.18 160.87,58.06 160.84,57.91 160.95,57.65 161.21,57.54 161.25,57.54 161.29,57.55 161.38,57.52 161.4,57.42 161.39,57.36 161.38,57.31 161.39,57.25 161.37,57.17 161.31,57.13 161.13,57.05 161.02,56.89 160.95,56.82 160.85,56.85 160.69,57.01 160.69,57.8 159.9,58.59 159.9,60.09 160.17,60.36 160.24,60.39 160.31,60.36 160.35,60.34 160.39,60.33 160.77,60.33 160.84,60.36 160.87,60.43
GND on TOP (solid shape): 129.09,80.8 129.18,80.75 129.27,80.72 129.32,80.71 129.36,80.71 129.44,80.72 129.51,80.74 129.56,80.75 129.6,80.74 129.61,80.7 129.63,80.68 129.69,80.59 129.78,80.52 129.78,78.69 129.21,78.11 129.21,77.54 129.33,77.42 131.04,77.42 131.16,77.29 131.16,74.88 131.04,74.75 130.4,74.75 130.15,75 130.15,75.26 129.63,75.78 127.21,75.78 126.08,76.91 125.32,76.91 125.19,76.78 125.19,74.37 125.32,74.24 125.57,74.24 125.7,74.11 125.7,73.92 125.27,73.5 125.27,71.86 125.27,71.52 125.27,70.59 125.27,70.14 124.78,70.14 124.55,70.36 124.55,70.7 124.4,70.85 122.26,70.85 121.95,70.54 121.95,70.25 121.8,70.1 121.05,70.1 120.94,70.21 120.94,71.86 121.11,72.03 121.42,72.03 121.49,72.01 121.58,72.01 121.64,72.03 121.71,72.03 121.78,71.96 121.83,71.92 121.89,71.91 122.87,71.91 123.06,72.1 123.06,72.98 122.47,73.57 122.47,77.13 122.7,77.36 122.72,77.36 122.74,77.38 127.81,77.38 128.15,77.71 128.15,80.45 128.23,80.52 128.6,80.52 128.63,80.55 128.78,80.55 129.06,80.84
GND on TOP (solid shape): 20.07,48.48 20.18,48.48 20.19,48.44 20.23,48.38 20.3,48.35 20.63,48.35 21.21,47.77 21.21,46.95 21.17,46.94 21.11,46.9 21.08,46.83 21.08,46.51 21.03,46.45 19.51,46.45 18.84,47.12 18.86,47.17 18.86,47.18 18.93,47.29 18.95,47.42 18.85,47.68 18.59,47.78 18.47,47.78 18.35,47.89 18.35,48.29 18.45,48.39 18.7,48.39 18.92,48.18 19.09,48.18 19.1,48.14 19.17,48.04 19.28,48 19.3,48 19.34,47.95 19.35,47.93 19.46,47.69 19.71,47.59 19.97,47.7 20.07,47.95 20.01,48.15 19.85,48.29 19.82,48.3 19.82,48.43 19.86,48.49 20.06,48.49
GND on TOP (solid shape): 56.06,12.56 56.05,12.52 56.03,12.5 56.03,12.47 56.03,12.26 56.04,12.23 56.05,12.2 56.07,12.14 56.05,12.08 56.04,12.05 56.03,12.02 56.03,11.81 56.05,11.75 56.09,11.71 56.12,11.7 56.12,11.11 56.37,10.86 56.37,10.38 56.33,10.36 56.14,10.23 56.07,10.01 56.11,9.84 56.22,9.71 56.22,9.5 56.24,9.43 56.27,9.36 56.27,9.18 56.21,9.16 55.71,9.66 55.71,9.86 55.65,10.01 55.49,10.07 55.3,10.07 54.95,10.42 54.95,11.44 55.21,11.7 55.45,11.7 55.48,11.7 55.52,11.71 55.64,11.71 55.71,11.74 55.74,11.81 55.74,12.47 55.71,12.54 55.64,12.57 55.49,12.57 55.21,12.84 55.19,12.95 55.28,13.01 55.38,13.03 55.48,13.08 55.52,13.11
GND on TOP (solid shape): 108.06,82.35 107.99,82.28 107.95,82.31 107.69,82.31 107.58,82.24 107.51,82.13 107.51,81.88 107.54,81.83 107.57,81.79 107.59,81.72 107.57,81.66 107.54,81.62 107.52,81.57 107.52,81.32 107.55,81.25 107.61,81.19 107.65,81.11 107.6,81.03 107.54,80.97 107.49,80.89 107.49,80.84 107.09,80.84 107.02,80.81 106.99,80.74 106.99,80.58 106.91,80.58 106.88,80.64 106.82,80.71 106.85,80.79 106.85,80.99 106.82,81.06 106.74,81.09 106.66,81.09 106.66,81.76 106.7,81.84 106.8,81.85 106.86,81.79 106.92,81.77 107.05,81.77 107.12,81.79 107.29,81.97 107.31,82.03 107.32,82.1 107.31,82.16 107.29,82.22 107.24,82.28 107.25,82.37 107.33,82.42 107.99,82.42
GND on TOP (solid shape): outline of 103 points within 158.3,13.16 163.17,16.71
GND on TOP (solid shape): outline of 93 points within 68.53,72.29 77.68,82.85
GND on TOP (solid shape): 144.19,68.71 145.25,68.71 145.3,68.69 145.33,68.65 145.3,68.61 145.27,68.56 145.27,68.3 145.35,68.19 145.46,68.12 145.64,68.11 145.9,67.85 147.25,67.85 148.01,67.09 148.44,67.09 148.51,67.06 148.55,66.99 148.52,66.96 148.5,66.92 148.5,66.66 148.52,66.63 148.48,66.58 148.42,66.56 147.52,66.56 147.5,66.58 147.49,66.63 147.54,66.66 147.57,66.66 147.68,66.74 147.76,66.85 147.76,67.11 147.68,67.22 147.57,67.29 147.32,67.29 147.21,67.22 147.13,67.11 147.13,67.08 147.06,67.06 146.99,67.09 146.35,67.73 144.3,67.73 143.3,68.74 143.27,68.85 143.37,68.91 143.99,68.91
GND on TOP (solid shape): 204.58,87.88 204.61,87.83 204.87,87.31 205.42,87.09 205.62,87.12 205.81,87.19 205.85,87.15 205.86,87.1 205.86,84.65 206.61,83.68 207.74,84.14 211.08,84.14 211.48,84.54 214.83,84.54 214.83,79.76 211.48,79.76 211.08,80.16 207.74,80.16 207.34,80.54 206.81,80.66 206.73,80.69 206.7,80.77 206.71,80.78 206.71,81.29 206.7,81.33 206.7,81.39 207.87,81.39 208.16,81.69 208.16,83.23 207.97,83.42 204.93,83.42 204.29,84.06 203.9,84.06 203.87,84.03 203.81,84.02 203.78,84.07 203.78,84.56 203.1,85.25 203.35,85.5 203.35,85.94 204.45,87.04 204.45,87.79 204.49,87.83 204.53,87.86
GND on TOP (solid shape): 37.48,77.47 37.52,77.44 37.57,77.42 37.6,77.4 37.6,77.36 37.6,77.3 37.7,77.06 37.94,76.96 38.14,77.03 38.27,77.2 38.29,77.23 38.33,77.24 38.43,77.25 38.51,77.3 38.61,77.39 39.06,77.39 39.16,77.29 39.16,76.86 39.06,76.76 38.66,76.76 38.17,76.27 38.17,75.55 38.49,75.23 38.84,75.23 38.93,75.14 38.93,74.77 38.83,74.68 37.98,74.68 37.94,74.67 37.9,74.68 37.78,74.68 37.59,74.87 37.59,75.27 37.37,75.49 37.23,75.49 37.21,75.48 36.91,75.7 37.21,75.92 37.4,75.95 37.49,76.13 37.49,76.58 36.89,77.17 36.84,77.21 36.78,77.23 36.75,77.25 36.74,77.29 36.74,77.34 36.73,77.38 36.74,77.41 36.76,77.43 36.81,77.45 36.84,77.48 36.95,77.59 37.36,77.59
GND on TOP (solid shape): 73.99,95.34 73.99,94.23 74.27,93.95 75.1,93.95 75.21,93.84 75.21,93.83 75.35,93.65 75.56,93.58 75.64,93.59 75.71,93.61 75.81,93.61 75.85,93.52 75.85,93.04 75.39,92.58 75.39,92.56 75.3,92.47 75.3,92.27 75.16,92.14 75.11,91.96 75.22,91.7 75.48,91.59 75.53,91.6 75.61,91.57 75.64,91.49 75.64,91.48 75.67,91.33 75.76,91.2 75.79,91.13 75.76,91.06 75.36,90.66 75.26,90.63 75.19,90.72 75.07,90.95 74.83,91.04 74.78,91.04 74.71,91.02 74.67,91.07 74.55,91.07 74.55,91.07 73.67,91.07 73.48,91.26 73.48,91.82 73.48,91.83 73.51,91.97 73.48,92.11 73.48,92.12 73.48,93.29 73,93.77 73,94.31 72.85,94.46 72.29,94.46 72.27,94.45 72.12,94.45 71.85,94.18 71.4,94.18 71.24,94.33 71.24,94.51 72.51,95.77 73.56,95.77
GND on TOP (solid shape): 140.86,87.89 140.93,87.88 140.97,87.89 141.03,87.9 141.26,87.67 144.05,87.67 144.14,87.6 144.12,87.49 141.08,84.46 140.97,84.44 140.91,84.53 140.91,86.05 140.55,86.41 140.55,86.49 140.58,86.56 140.65,86.59 140.69,86.57 140.73,86.55 140.98,86.55 141.09,86.62 141.17,86.73 141.17,86.82 141.2,86.88 141.27,86.9 141.43,86.91 141.54,86.98 141.61,87.09 141.61,87.35 141.54,87.46 141.43,87.53 141.17,87.53 141.09,87.49 141.02,87.42 140.98,87.35 140.96,87.27 140.92,87.2 140.86,87.18 140.73,87.17 140.67,87.14 140.61,87.1 140.55,87.12 140.55,87.23 140.73,87.41 140.73,87.81 140.75,87.87 140.8,87.91
GND on TOP (solid shape): 10.58,9.69 10.63,9.75 10.71,9.76 10.85,9.62 10.93,9.62 10.99,9.56 10.99,9.49 10.97,9.42 10.96,9.34 11.06,9.09 11.31,8.98 11.48,9.03 11.61,9.14 11.69,9.18 11.77,9.13 12.21,9 12.44,9.39 12.46,9.47 12.54,9.51 14.69,9.51 14.87,9.33 14.87,8.1 14.78,8.01 13.01,8.01 12.63,7.63 11.28,7.63 11.06,7.41 11.06,6.36 11.08,6.33 11.08,6.26 11.07,6.21 11.03,6.17 10.93,6.22 10.83,6.23 10.75,6.23 10.68,6.2 10.64,6.23 10.61,6.27 10.61,7.36 10.57,7.39 10.57,7.5 10.58,7.53 10.58,7.83 10.57,7.86 10.57,8 10.58,8.03 10.58,8.33 10.57,8.36 10.57,8.5 10.58,8.53 10.58,8.83 10.57,8.86 10.57,9 10.58,9.03 10.58,9.33 10.57,9.36 10.57,9.5 10.58,9.53
GND on TOP (solid shape): 157.35,90.42 157.35,87.5 154.35,84.5 151,84.5 150.84,84.67 150.71,84.67 148.73,86.65 148.72,86.65 148.13,87.23 148.13,89.43 147.68,89.88 146.52,89.88 146.52,89.87 146.03,89.87 145.37,89.21 145.26,89.19 145.2,89.29 145.2,90.83 145.3,90.9 145.37,91 145.44,91.06 145.53,91.03 145.69,90.87 146.74,90.87 146.75,90.83 146.87,90.58 147.13,90.49 147.45,90.71 147.4,91.1 147.37,91.17 147.4,91.24 147.53,91.36 147.62,91.39 147.69,91.33 147.99,91.09 148.34,91.24 148.42,91.28 148.5,91.24 148.62,91.14 148.77,91.09 148.8,91.09 149.06,91.2 149.17,91.46 149.16,91.48 150.82,93.14 154.63,93.14
GND on TOP (solid shape): outline of 114 points within 169.5,37.31 172.08,41.96

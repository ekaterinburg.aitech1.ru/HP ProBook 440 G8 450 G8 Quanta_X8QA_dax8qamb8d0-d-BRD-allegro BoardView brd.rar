# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO9: length 81.5
  TOP w0.076: v2(192.84,20.89) U4700.C10
  IN1 w0.079: v1(144.83,12.94) 143.66,11.77 143.5,11.77 142.56,11.38 140,11.38 139.21,12.17 135.82,12.17 135.31,12.68 133.88,12.68 133.33,12.13 129.01,12.13 128.83,11.95 124.06,11.95 v2(123.85,11.75)
  IN3 w0.089: v1(144.83,12.94) 145.35,13.47 147.77,13.47 148.1,13.14 152.95,13.14 153.4,12.68 157.57,12.68 157.91,12.34 158.81,12.34 159.01,12.43 159.24,12.66 159.24,12.96 159.67,13.39 163.99,13.39 164.87,12.5 167.64,12.5 168.93,11.21 170.83,11.21 172.26,12.65 177.82,12.65 177.91,12.56 178.58,12.56 179.07,13.05 179.07,15.58 180.85,17.36 182.21,17.36 183.77,18.93 186.59,18.93 187.25,19.58 189.15,19.58 189.27,19.7 190.2,19.7 191.4,20.89 v2(192.84,20.89)
  BOTTOM w0.109: CON5000.16 124.14,9.84 123.77,10.21 123.77,11.66 v2(123.85,11.75)
KSO10: length 88.5
  TOP w0.076: U4700.B11 192.19,21.54 191.78,21.54 191.52,21.28 190.95,21.28 190.36,21.87 190.36,21.95
  TOP w0.109: 190.36,21.95 190.36,22.16 189.08,23.44 187.78,23.44 187.73,23.49 187.32,23.49 187.14,23.32 187.14,22.61 186.26,21.72 186.26,20.5 186.72,20.03 186.72,17.18 185.08,15.54 184.14,15.54 v1(183.95,15.34) 183.77,15.16 v2(183.36,15.16)
  IN2 w0.089: v1(120.27,10.84) 121.29,9.82 130.25,9.82 131.45,11.02 134.74,11.02 135.18,10.59 136.26,10.59 136.95,11.28 138.01,11.28 138.63,11.89 139.13,11.89 139.87,11.15 142.31,11.15 142.66,11.5 145.42,11.5 145.73,11.19 147.1,11.19 148.35,12.44 152.95,12.44 153.38,12 157.28,12 157.67,11.61 159.34,11.61 159.45,11.72 161.68,11.72 162.18,11.23 164.04,11.23 164.19,11.38 167.97,11.38 168.89,10.46 170.48,10.46 172.59,12.57 176.53,12.57 177.62,13.66 179.28,13.66 181.11,15.49 183.03,15.49 v2(183.36,15.16)
  BOTTOM w0.109: v1(120.27,10.84) 120.27,10.42 120.14,10.28 CON5000.24
KSO11: length 95
  TOP w0.076: v2(189.76,21.8) 189.97,21.8 190.8,20.98 191.66,20.98 191.72,20.93 192.16,20.93 U4700.B10
  IN3 w0.089: v2(189.76,21.8) 189.79,21.83 189.79,22.4 189.64,22.56 189.5,22.62 188.76,22.62 188.37,22.22 187.46,22.22 187.28,22.26 187.24,22.28 186.11,23.4 184.59,23.4 184.53,23.34 184.4,23.34 183,21.95 183,21.33 181.52,19.84 180.62,19.84 179.63,18.85 179.63,17.98 178.08,16.43 173.83,16.43 172.55,17.71 169.18,17.71 168.53,18.36 166.1,18.36 164.1,16.36 163.6,16.36 162.54,15.3 160.17,15.3 159.56,14.69 159.56,14.45 159.33,14.22 157.02,14.22 156.69,13.89 156.24,13.89 155.87,13.52 153.34,13.52 153.19,13.67 148.33,13.67 147.99,14 144.77,14 144.09,13.33 143.08,13.33 142.96,13.45 140.83,13.45 140.59,13.21 138.32,13.21 137.98,13.56 135.89,13.56 135.68,13.76 134.32,13.76 133.47,12.92 133.47,12.86 133.12,12.51 128.08,12.51 127.72,12.87 126.68,12.87 126.36,12.55 123.57,12.55 122.96,11.94 121.85,11.94 121.4,12.39 117.28,12.39 115.95,11.06 115.95,10.54 115.74,10.33 114.89,10.33 114.65,10.57 114.61,10.67 114.32,10.96 114.06,11.07 113.92,11.07 113.54,11.23 112.55,11.23 111.54,10.22 v2(111.3,10.22)
  BOTTOM w0.109: v2(111.3,10.22) 111.14,10.06 CON5000.42
KSO12: length 87.5
  TOP w0.076: U4700.C11 192.84,21.54 192.84,21.96 192.7,22.09 192.6,22.16 192.2,22.16 192.03,22.33 191.63,22.33 v2(191.54,22.43)
  TOP w0.109: R5014.1 124.19,10.81 v2(124.21,10.79)
  IN1 w0.079: v2(124.21,10.79) 124.31,10.79 124.84,11.32 128.82,11.32 129.08,11.06 130.49,11.06 130.97,11.54 134.87,11.54 135.25,11.7 139.01,11.7 139.8,10.91 142.66,10.91 143.6,11.3 147.14,11.3 147.42,11.58 148.86,11.58 149.89,10.89 150.07,10.72 158.96,10.72 159.55,11.31 163.3,11.31 164.55,12.57 168.68,12.57 171.76,9.49 172.75,9.49 172.8,9.44 178.43,9.44 180.32,11.33 182.88,11.33 183.37,11.82 183.37,12.47 183.62,12.72 185.35,12.72 186.78,14.16 187.23,14.16 187.93,14.86 187.93,15.56 185.97,17.52 185.97,19.51 v2(186.31,19.84)
  IN3 w0.089: v2(191.54,22.43) 191.54,21.56 190.07,20.09 189,20.09 188.87,19.96 186.43,19.96 v2(186.31,19.84)
  BOTTOM w0.109: CON5000.15 124.64,10.36 v2(124.21,10.79)
KSO13: length 86.1
  TOP w0.076: U4700.D11 193.47,21.56 193.47,22.05 193.02,22.51 v2(193.01,22.51)
  IN1 w0.079: v2(186.32,19.29) 186.92,18.7 186.92,16.94 188.11,15.75 188.11,13.78 187.55,13.22 186.15,13.22 184.82,11.88 183.89,11.88 183.02,11.02 180.45,11.02 178.56,9.12 172.62,9.12 172.57,9.17 171.26,9.17 169.49,10.95 169.11,10.95 167.96,12.09 164.54,12.09 163.61,11.16 159.62,11.16 159.02,10.56 150,10.56 149.79,10.77 148.81,11.42 147.49,11.42 147.21,11.14 143.63,11.14 142.69,10.75 139.31,10.75 139.11,10.95 137.02,10.95 136.43,11.54 135.28,11.54 134.86,11.36 131.03,11.36 130.56,10.9 129.02,10.9 128.75,11.17 125.21,11.17 v2(124.84,10.79)
  IN3 w0.089: v2(186.32,19.29) 186.8,19.78 189,19.78 189.12,19.9 190.13,19.9 192.74,22.51 v2(193.01,22.51)
  BOTTOM w0.109: v2(124.84,10.79) 125.14,10.49 CON5000.14
L_SPK+: length 113.2
  TOP w0.178: 195.35,41.2 U3600.35
  TOP w0.203: 195.35,41.96 195.35,41.2 ; v1(195.73,43.14) v1(195.73,42.52)
  IN3 w0.762: 198.65,59.56 199.62,61.91 199.62,63.68 199.39,64.86 198.9,66.05 196.96,67.99 195.05,68.78 193.57,68.78 192.58,69.77 ; 151.74,106.21 151.08,106.88 143.63,106.88 143.58,106.83 ; 185.19,78.26 185.19,78.03 186.08,77.14 186.08,76.06 187.42,74.71 187.42,74.11 189,72.54 189.56,72.54
  IN3 w1.016: 189.56,72.54 190.4,72.54 191.97,70.97 191.97,70.38 192.58,69.77 ; 185.19,78.26 183.34,80.11 183.34,80.9 182.41,81.83 181.34,82.27 180.62,82.27 178.89,84 178.89,84.71 179.78,85.6 179.78,86.81 179.3,87.3 175.59,87.3 172.9,89.99 172.44,89.99 159.38,103.05 159.38,105.18 158.35,106.21 151.74,106.21 ; 136.22,100.99 136.22,101.65 141.4,106.83 143.58,106.83 ; 198.65,59.56 198.65,55.11 198.16,54.63 198.16,46.52 197.15,45.51 197.15,44.78 196.67,44.3
  vias: v1(135.79,100.34) v1(136.35,100.06)
L_SPK-: length 105
  TOP w0.203: v1(195.1,43.14) v1(195.1,42.52) 195.1,42.35 194.95,42.2 U3600.36
  IN3 w0.762: 187.23,72.68 186.41,73.51 186.41,74.29 184.71,76 184.71,76.88 ; 192.68,67.87 192.89,67.66 194.87,67.66 196.54,66.97 198.03,65.48 198.41,64.56 198.61,63.56 198.61,62.16 197.96,60.6 197.02,59.66 197.02,47.01 195.88,45.87 195.88,45.18 195.32,44.63 ; 143.62,105.56 143.71,105.56 144.45,105.86 148.16,105.86 148.33,105.69
  IN3 w1.016: 148.33,105.69 150.42,105.69 151.18,104.93 155.71,104.93 172.17,88.47 172.62,88.47 176.58,84.5 176.58,83.86 179.2,81.23 179.79,80.99 180.8,79.97 181.46,79.7 181.89,79.7 184.71,76.88 ; 187.23,72.68 190.55,69.37 191.18,69.37 192.68,67.87 ; 143.62,105.56 141.93,105.56 138.15,101.78 138.15,100.94
  vias: v1(137.8,100.13) v1(138.43,100.12)
LAN_DIS#: length 296.6
  TOP w0.109: v1(9.45,6.52) 9.45,7.95 9.69,8.18 CON7602.38
  IN1 w0.079: v1(161.45,42.47) 161.45,42.34 163.15,40.64 165.06,40.64 165.42,41 165.42,41.4 166.69,42.67 171.7,42.67 171.91,42.87 173.23,42.87 173.91,42.19 173.91,41.16 175.07,40 175.07,38.83 176.08,37.82 176.2,37.71 179.6,37.71 180.57,36.74 180.57,36.24 181.6,35.21 181.6,32.67 182.89,31.38 182.89,30.24 185.31,27.83 185.31,27.38 185.71,26.42 187.66,24.47 188.18,24.47 188.52,24.13 188.52,21.74 189.13,21.13 189.13,18.08 189.48,17.73 190.07,17.73 190.27,17.52 190.35,17.32 190.35,13.1 191.46,11.99 191.46,11.02 191.16,10.72 191.16,9.8 190.5,9.15 185.68,9.15 185.5,8.96 183.05,8.96 182.75,8.66 181.73,8.66 181.33,8.26 181.33,7.95 180.96,7.57 177.12,7.57 176.73,7.19 171.01,7.19 168.93,9.26 160.9,9.26 160.35,8.71 158.71,8.71 158.26,8.25 151.43,8.25 151.12,8.57 147.07,8.57 146.89,8.74 145.79,8.74 145.62,8.57 143.42,8.57 143.07,8.21 141.26,8.21 140.96,8.52 136.06,8.52 135.76,8.81 134.86,8.81 134.66,9.01 126.21,9.01 126.05,8.85 115.13,8.85 114.42,8.14 114.06,8.14 113.3,7.38 112.82,7.38 112.55,7.1 112.55,6.7 112.3,6.46 105.03,6.46 104.05,7.43 102.67,7.43 102.24,7.86 99.86,7.86 98.78,8.94 96.88,8.94 96.36,9.46 94.16,9.46 93.5,10.11 92.2,10.11 91.71,10.6 88.81,10.6 88.65,10.76 86.38,10.76 85.04,9.42 80.79,9.42 80.75,9.46 59.65,9.46 59.19,9 58.9,9 58.24,8.34 56.33,8.34 54.12,6.13 52.42,6.13 51.57,5.27 50.86,5.27 50.62,5.04 42.76,5.04 42.18,5.61 35.8,5.61 35.2,5.02 31.79,5.02 30.12,6.68 26.57,6.68 26.24,7.01 22.47,7.01 21.13,8.36 17.31,8.36 17.08,8.13 17.08,7.84 14.48,5.23 10.74,5.23 v1(9.45,6.52)
  IN2 w0.089: v2(147.33,65.88) 147.33,65.39 147.65,65.08 147.73,64.88 147.73,63.96 147.45,63.68 146.39,63.68 145.6,62.89 145.6,61.52 146.67,60.45 146.67,57.7 149.68,54.68 150.11,54.68 151.05,53.74 152.7,53.74 153.19,53.26 153.19,52.05 153.49,51.76 153.49,50.58 153.1,50.19 153.1,48.9 153.35,48.65 153.91,48.65 154.18,48.38 156.81,48.38 158.19,47.01 158.19,46.41 158.91,45.69 158.91,44.64 161.08,42.47 v1(161.45,42.47)
  BOTTOM w0.079: U400.DT41 143.91,67.85 144.85,67.85 144.95,67.75 146.31,67.75 146.45,67.61
  BOTTOM w0.109: R1539.2 149.46,66.45 147.88,66.45 147.33,65.9 v2(147.33,65.88) 147.32,65.89 147.32,66.39 147.09,66.62 147.09,66.97 146.45,67.61
LAN_PWR_ON: length 3.9
  TOP w0.109: R4750.1 R4751.1 23.49,7.92 23.75,8.18 PC9514.1 24.16,8.57 v1(24.57,8.99) 24.57,9.56 24.72,9.71 PU9501.3
LAN_PWR_ON_EC: length 194.9
  TOP w0.076: U4700.D10 v2(194.14,20.24)
  TOP w0.109: R4753.2 133.64,8.07 v1(133.72,7.99) 134.03,8.3 R4752.1 ; v1(25.48,6.55) 25.24,6.55 24.79,7.01 24.49,7.01 R4750.2
  IN3 w0.076: v2(194.14,20.24) 194.56,19.82 194.56,19.72 195.17,19.11 195.17,18.45 196.43,17.19 196.43,16.17 196.15,15.88 194.86,15.35 194,15.35 193.54,15.8
  IN3 w0.089: v1(25.48,6.55) 26.2,5.82 29.84,5.82 30.16,5.5 33.69,5.5 34.77,6.58 39.8,6.58 40.17,6.95 42.41,6.95 42.87,6.49 47.3,6.49 48.07,7.26 49.93,7.26 50.46,7.79 51.52,7.79 51.77,7.68 53.7,7.68 54.46,6.93 59.68,6.93 60.91,8.15 60.91,8.88 61.55,9.52 74.54,9.52 74.75,9.73 85.92,9.73 86.58,10.39 93.49,10.39 94.15,9.73 98.47,9.73 99.42,8.78 101.99,8.78 102.81,7.96 103.32,7.74 104.26,7.74 104.47,7.95 105.43,7.95 105.69,7.69 108.68,7.69 108.86,7.87 112.56,7.87 113.13,8.44 118.61,8.44 119.83,7.21 123.1,7.21 123.33,7.43 125.06,7.43 125.53,7.24 125.88,7.24 126.08,7.44 126.08,8.13 126.54,8.58 132.74,8.58 133.33,7.99 v1(133.72,7.99) 134.13,8.39 135.03,8.39 135.23,8.58 136.04,8.58 136.45,8.99 139.47,8.99 139.75,9.27 139.75,9.74 139.99,9.98 140.3,9.98 140.49,9.78 143.49,9.78 144.13,10.42 147.23,10.42 147.61,10.05 149.02,10.05 149.18,9.88 160.24,9.88 160.87,10.51 163.76,10.51 164.22,10.05 165.27,10.05 165.88,9.44 171.26,9.44 171.65,9.05 172.42,9.05 172.45,9.08 178.06,9.08 180.87,11.89 180.87,14.02 181.73,14.88 182.4,14.88 183.82,16.3 186.78,16.3 187.12,15.97 187.89,15.97 188.46,15.39 189.23,15.39 190,16.16 190.58,16.4 192,16.4 192.6,15.8 193.54,15.8
LAN_WAKE#: length 263.7
  TOP w0.109: v1(9.42,9.5) 9.6,9.68 CON7602.35 ; R1531.2 152.71,66.45 150.68,66.45 150.5,66.63 149.35,66.63 149.1,66.39 147.45,66.39 146.28,67.56 144.21,67.56 143.01,68.76 v2(141.81,68.76)
  IN1 w0.079: v1(11.33,40.71) 11.33,41.57 12.83,43.07 13.3,43.07 15.51,45.28 15.51,47.82 18.54,50.85 18.54,51.59 18.86,51.91 21.88,51.91 22.13,51.65 23.03,51.65 25.4,54.02 25.4,54.27 28.3,57.18 28.69,57.18 29.07,56.79 29.9,56.79 30.64,57.54 34.71,57.54 36.4,55.85 36.4,53.67 v1(36.83,53.24)
  IN2 w0.089: v1(157.47,42.29) 156.57,42.29 154.23,44.63 154.23,44.97 153.31,45.89 149.97,45.89 146.83,49.04 146.15,49.04 140.69,54.5 140.69,56.21 141.88,57.41 141.88,57.91 140.5,59.3 140.5,63.36 140.06,63.79 140.06,66.25 140.18,66.36 140.18,67.07 140.35,67.25 140.91,67.25 140.99,67.33 141.32,67.33 141.49,67.5 141.49,68.44 v2(141.81,68.76) ; v1(9.42,9.5) 8.84,10.08 8.84,10.67 6.44,13.07 6.44,16.6 7.16,17.32 7.16,19.76 6.46,20.46 6.46,22.54 7.8,23.87 7.8,27.91 7.33,28.37 7.33,31.41 8.12,32.2 8.12,37.45 10.33,39.66 11.37,39.66 11.58,39.87 11.58,40.45 v1(11.33,40.71)
  BOTTOM w0.109: v1(36.83,53.24) 36.6,53.01 36.6,49.52 40.13,46 40.59,46 41.32,45.26 41.32,44.8 43.48,42.64 43.96,42.64 45.7,40.9 45.7,38.74 49.32,35.12 103.55,35.12 104.83,33.84 118.15,33.84 123.83,39.52 154.09,39.52 156.86,42.29 v1(157.47,42.29) ; U400.DM41 141.81,68.57 v2(141.81,68.76)
LANLINK_STATUS: length 276.5
  TOP w0.109: R814.1 155.11,74.95 155.14,74.99 v2(155.14,75.02) ; CON7602.34 9.38,10.18 v1(9.38,10.18)
  IN1 w0.079: v1(10.33,38.93) 10.33,41.02 12.7,43.39 13.13,43.39 15.11,45.37 15.11,48.15 18.11,51.15 18.11,51.61 18.72,52.22 22.02,52.22 22.27,51.97 22.82,51.97 25.08,54.23 25.08,54.4 28.17,57.49 28.82,57.49 29.16,57.15 29.8,57.15 30.51,57.86 34.87,57.86 37.21,55.52 37.21,54.33 v1(36.78,53.9) ; v2(155.14,75.02) 155.14,74.99 155.1,74.95 154.89,74.95 154.24,75.6 153.96,75.6 152.78,76.78 151.76,76.78 150.72,77.82 148.89,77.82 148.46,78.26 146.33,78.26 146,77.92 143.28,77.92 143.01,78.2 140.5,78.2 140.32,78.02 140.32,77.59 140.16,77.43 139.1,77.43 138.71,77.82 v2(138.68,77.82)
  IN2 w0.089: v1(9.38,10.18) 9.38,10.39 6.62,13.14 6.62,16.53 7.34,17.25 7.34,19.84 6.64,20.53 6.64,22.46 7.97,23.79 7.97,28.18 8.3,28.51 8.3,37.38 9.85,38.93 v1(10.33,38.93) ; v2(155.14,75.02) 155.14,74.94 154.99,74.78 154.99,74.32 154.34,73.67 154.34,73.41 154.01,73.07 153.87,73.07 152.93,72.12 152.93,71.55 152.21,70.84 151.64,70.84 151.03,70.23 151.03,68.2 151.54,67.68 151.54,65.62 152.14,65.02 152.14,64.55 149.34,61.75 149.34,58.79 149.76,58.38 149.76,58.11 151.25,56.61 152.88,56.61 154.79,54.7 156.56,54.7 156.77,54.48 156.77,53.75 156.36,53.33 156.36,53.21 158.56,51.02 158.56,49.55 159.24,48.87 159.24,48.17 v1(160.03,47.38)
  BOTTOM w0.109: v2(138.68,77.82) 138.92,77.58 U400.DF21 ; v1(36.78,53.9) 36.37,53.49 36.37,49.43 40.03,45.77 40.49,45.77 41.1,45.16 41.1,44.7 43.39,42.41 43.87,42.41 45.47,40.81 45.47,38.64 49.22,34.89 103.47,34.89 104.74,33.62 118.25,33.62 123.93,39.29 154.19,39.29 155.68,40.78 157.07,40.78 158.56,42.26 158.56,43.86 159.48,44.79 159.48,46.84 v1(160.03,47.38)
LCD_P:
  vias: v1(25.07,37.72) v1(32,35.33) v1(32.64,35.3)
LED_PWRSTBY#: length 11.9
  TOP w0.109: U4701.6 176.4,58.98 175.89,58.47 175.89,58.01 R4746.2 175.61,58.06 175.61,58.22 175.31,58.52 R4735.1 174.62,58.52 174.34,58.8 174.34,59.59 175.59,60.83 177.82,60.83 178.05,60.61 178.05,60.05 v1(178.16,59.94) 178.2,59.89 178.86,59.89 R5013.1 179.19,60.23 Q5000.2
LED_PWRSTBY#_CNTR: length 127.8
  TOP w0.109: R5000.1 133.37,11.88 v1(133.41,11.92) 134.7,13.21 134.7,17.92 v1(134.39,18.23) ; Q5000.3 179.84,60.59 179.89,60.54 R5013.2 180.92,60.14 v1(181.4,59.66)
  IN1 w0.079: v1(160.48,50.98) 161.61,50.98 161.92,51.29 161.92,52.17 164.3,54.55 171.77,54.55 172.09,54.87 173.87,54.87 174.16,55.17 175.14,55.17 176.15,56.18 178.63,56.18 178.75,56.3 180.07,56.3 180.18,56.18 182.9,56.18 183.04,56.32 183.04,56.77 182.48,57.33 181.96,57.33 181.25,58.04 181.25,59.52 v1(181.4,59.66)
  IN3 w0.089: v1(160.48,50.98) 163.38,48.08 164.44,48.08 165.4,47.11 165.65,47.11 166.77,45.99 166.77,45.59 168.56,43.8 168.56,41.61 170.13,40.05 170.95,40.05 172.44,38.55 172.44,37.02 175.17,34.3 175.17,31.91 177.97,29.11 177.97,27.72 179.02,26.68 179.02,24.08 179.26,23.84 179.26,21.45 178.79,20.98 178.42,20.98 177.57,20.14 176.59,20.14 175.71,19.25 165.73,19.25 163.73,17.25 163.22,17.25 162.41,16.44 157.12,16.44 155.45,18.11 148.8,18.11 147.78,17.09 144.57,17.09 144.24,17.42 142.95,17.42 142.86,17.51 140.6,17.51 140.54,17.57 135.94,17.57 135.86,17.49 135.07,17.49 134.39,18.17 v1(134.39,18.23)
LID_OFF_CN: length 6.4
  TOP w0.109: Q3403.2 22.16,47.95 Q3404.3 21.71,48.39 21.71,49.17 21.89,49.35 21.89,50 22.09,50.2 22.09,50.52 v1(22.4,50.82) 22.09,51.13 22.09,51.27 C3401.2 21.65,51.56 R3407.1
LID_SW#_3: length 45.1
  TOP w0.109: v1(12.09,41.5) 12.36,41.5 12.76,41.91 14.16,41.91 14.92,42.66 14.92,46.9 v1(15.18,47.16) 15.34,47.32 16.18,47.32 16.44,47.06 R7508.2 16.92,47.06 Q7502.3 17.78,47.55 19.28,46.05 20.78,46.05 21.41,45.42 R7505.2 ; v1(8.62,17.91) 8.62,18.91 9.39,19.68 CON7602.15
  IN3 w0.089: v1(8.62,17.91) 8.62,18.86 10.23,20.47 10.23,34.54 11.29,35.6 11.29,39.31 10.75,39.86 10.75,40.91 11.33,41.5 v1(12.09,41.5)
LID_SW#_EC: length 270.7
  TOP w0.076: 197,14.13 197,14.35 196.74,14.61 196.74,16.34 196.74,16.34 U4700.H4
  TOP w0.109: R3411.2 19.45,46.28 18.54,47.19 v1(18.54,47.42) 18.18,47.78 18.18,48.22 18.05,48.36 17.7,48.36 17.28,48.78 Q7502.1 17.02,49.04 17.02,47.78 v1(16.81,47.57) ; v1(22.71,5.53) 23.29,6.12 24.61,6.12 24.86,5.87 24.86,5.38 25.11,5.14 26.8,5.14 26.83,5.16 Q5201.2 ; 197,14.13 197,12.81 v2(197.11,12.7)
  IN1 w0.079: v1(195.07,7.42) 195.07,7.49 194.68,7.89 194.68,10.24 197.11,12.67 v2(197.11,12.7)
  IN3 w0.089: v1(181.73,3.33) 181.73,3.12 181.22,2.6 180.27,2.6 179.57,1.9 171.88,1.9 168.37,5.41 163.85,5.41 163.58,5.15 133.31,5.15 133.12,4.95 133.02,4.85 105.07,4.85 101.3,6.41 101.01,6.7 97.76,6.7 96.59,7.88 77.01,7.88 75.99,6.86 75.99,3.57 74.51,2.1 67.88,2.1 67.51,2.46 54.58,2.46 53.17,3.87 53.17,3.87 52.79,4.25 52.52,4.25 51.81,4.96 51.1,4.96 50.22,4.07 32.17,4.07 32.05,3.95 23.7,3.95 23.24,4.42 23.24,5 v1(22.71,5.53) 22.5,5.74 21.92,5.74 21.32,6.33 16.42,6.33 16.05,6.7 10.14,6.7 7.63,9.21 7.63,19.55 6.75,20.43 6.75,23.03 7.7,23.99 7.7,28.81 7.32,29.2 7.32,33.43 10.76,36.87 10.76,39.09 10.19,39.65 10.19,41.2 11.79,42.8 12.93,42.8 16.76,46.63 16.76,47.52 v1(16.81,47.57)
  BOTTOM w0.109: R4803.1 197.47,13.05 v2(197.11,12.7) ; v1(181.73,3.33) 181.73,4.24 182.57,5.08 185.14,5.08 185.25,4.97 186.99,4.97 187.87,5.85 189.47,5.85 190.17,6.55 193.47,6.55 193.72,6.8 194.46,6.8 v1(195.07,7.42)
LIMIT_SIGNAL: length 79.4
  TOP w0.109: v1(163.93,102.18) 163.93,101.97 EC4.1
  IN1 w0.079: v2(154.8,101.04) 154.93,101.17 162.91,101.17 v1(163.93,102.18)
  IN3 w0.089: v1(193.53,57.57) 193.53,57.69 190.59,60.64 189.91,62.27 185.32,66.86 185.32,68.4 184.15,69.57 184.15,70.46 182.01,72.59 182.01,73.53 181.49,74.05 181.49,74.65 178.62,77.52 178.34,77.64 177.64,77.64 173.34,81.93 172.65,81.93 171.6,82.98 171.6,83.28 171.03,83.85 171.03,84.18 168.83,86.38 168.83,86.56 166.8,88.59 164.51,88.59 163.45,89.66 163.45,91.23 159.03,95.65 159.03,95.81 154.8,100.04 v2(154.8,101.04)
  BOTTOM w0.109: v1(163.93,102.18) 163.84,102.09 PCN8000.4 ; v1(193.53,57.57) 192.35,56.39 192.35,55.4 192.73,55.01 192.73,54.13 192.28,53.67 PR8404.2
LP#: length 97.7
  TOP w0.109: Q801.3 159.56,49.27 v1(159.85,49.56) 160.04,49.76 160.04,51.22 v1(160.79,51.97)
  IN3 w0.089: v1(139.81,13.62) 140.41,14.22 142.45,14.22 143.17,13.5 144.02,13.5 144.69,14.18 148.07,14.18 148.4,13.85 153.27,13.85 153.41,13.7 155.79,13.7 156.18,14.09 156.46,14.09 156.79,14.42 156.79,14.86 157.05,15.11 159.73,15.11 160.09,15.48 162.47,15.48 163.53,16.54 164.03,16.54 166.03,18.54 168.63,18.54 169.28,17.89 172.62,17.89 173.91,16.6 178.01,16.6 179.46,18.05 179.46,18.93 180.55,20.02 181.45,20.02 182.77,21.34 182.77,23.12 182.34,23.54 182.34,28.55 182.19,28.7 182.19,29.44 180.92,30.71 180.92,30.94 178.49,33.37 178.49,34.49 176.1,36.88 176.1,37.33 175.65,37.78 175.65,40.1 174.09,41.65 174.09,42.59 173.19,43.49 173.19,43.79 172.38,44.6 170.25,44.6 169.11,45.73 169.11,47.84 168.44,48.51 165.85,48.51 162.99,51.37 161.39,51.37 v1(160.79,51.97)
  BOTTOM w0.109: PR8623.1 140.36,14.17 v1(139.81,13.62)
LPC_ESPI_CLK_R_R: length 3.2
  BOTTOM w0.109: CON7702.11 210.37,15.22 209.92,15.68 209.41,15.68 208.98,16.11 208.84,16.11 R7717.1
LPC_ESPI_RESET#_R_R: length 5.1
  BOTTOM w0.109: CON7702.12 210.36,15.72 209.94,16.14 209.37,16.14 209.19,16.32 209.19,16.74 v1(209.12,16.81) 209.01,16.91 208.71,16.91 208.56,17.06 207.07,17.06 R7718.1
M_0_DQ_0<0>: length 68.3
  IN3 w0.089: v2(135.66,62.13) 135.71,62.18 136.35,62.18 137.13,61.39 137.13,60.45 138.12,59.46 138.12,55.23 145.48,47.87 145.48,47.74 145.4,47.66 145.4,47.53 145.53,47.41 145.65,47.41 145.74,47.49 145.86,47.49 145.99,47.36 145.99,47.24 145.9,47.15 145.9,47.03 146.03,46.9 146.15,46.9 146.24,46.99 146.36,46.99 146.49,46.86 146.49,46.74 146.41,46.65 146.41,46.53 146.53,46.4 146.66,46.4 146.74,46.48 146.87,46.48 146.99,46.36 146.99,46.23 146.91,46.15 146.91,46.02 147.03,45.9 147.16,45.9 147.24,45.98 147.37,45.98 147.5,45.85 147.5,45.73 147.41,45.65 147.41,45.52 147.54,45.39 147.66,45.39 147.75,45.48 147.87,45.48 148.47,44.88 151.53,44.88 158.53,37.88 165.92,37.88 174.93,28.86 174.93,28.51 175.02,28.42 175.29,28.42 175.38,28.33 175.38,28.13 175.29,28.04 175.07,28.04 174.98,27.95 174.98,27.76 175.07,27.67 175.51,27.67 175.63,27.55 175.63,26.17 v1(175.25,25.78)
  BOTTOM w0.079: U400.CU49 134.91,64.47 135.24,64.14 135.24,63.61 135.29,63.56 135.29,62.39 135.56,62.13 v2(135.66,62.13)
  BOTTOM w0.109: v1(175.25,25.78) 174.43,26.6 JDIM2800.225
M_0_DQ_0<1>: length 67.8
  IN3 w0.089: v1(175.25,27.05) 174.64,27.66 174.64,28.74 165.79,37.59 158.41,37.59 151.41,44.59 147.89,44.59 144.94,47.54 144.94,47.67 144.99,47.71 144.99,47.84 144.86,47.97 144.74,47.97 144.69,47.92 144.56,47.92 144.44,48.04 144.44,48.17 144.54,48.27 144.54,48.4 144.41,48.52 144.29,48.52 144.19,48.42 144.06,48.42 143.93,48.55 143.93,48.67 144.04,48.77 144.04,48.9 143.91,49.03 143.79,49.03 143.68,48.92 143.56,48.92 143.43,49.05 143.43,49.18 143.53,49.28 143.53,49.4 143.41,49.53 143.28,49.53 143.18,49.43 143.05,49.43 142.93,49.55 142.93,49.68 143.03,49.78 143.03,49.91 142.9,50.03 142.78,50.03 142.68,49.93 142.55,49.93 142.43,50.06 142.43,50.18 142.53,50.28 142.53,50.41 142.4,50.54 142.28,50.54 142.17,50.43 142.05,50.43 141.92,50.56 141.92,50.68 142.02,50.79 142.02,50.91 141.9,51.04 141.77,51.04 141.67,50.94 141.55,50.94 141.42,51.06 141.42,51.19 141.52,51.29 141.52,51.41 141.4,51.54 141.27,51.54 141.17,51.44 141.04,51.44 140.92,51.57 140.92,51.69 141.02,51.79 141.02,51.92 140.89,52.04 140.77,52.04 140.67,51.94 140.54,51.94 140.41,52.07 140.41,52.19 140.52,52.3 140.52,52.42 140.39,52.55 140.26,52.55 140.16,52.44 140.04,52.44 139.91,52.57 139.91,52.7 140.01,52.8 140.01,52.92 139.89,53.05 139.76,53.05 139.66,52.95 139.53,52.95 139.41,53.07 139.41,53.2 139.51,53.3 139.51,53.43 139.38,53.55 139.26,53.55 139.16,53.45 139.03,53.45 138.91,53.58 138.91,53.7 139.01,53.8 139.01,53.93 138.88,54.06 138.76,54.06 138.65,53.95 138.53,53.95 138.4,54.08 138.4,54.21 138.5,54.31 138.5,54.43 138.38,54.56 138.25,54.56 138.15,54.46 138.03,54.46 137.82,54.66 137.82,59.33 136.83,60.32 136.83,61.03 136.45,61.41 135.81,61.41 v2(135.66,61.57)
  BOTTOM w0.079: U400.CU50 134.91,63.7 135.13,63.48 135.13,62.02 135.58,61.57 v2(135.66,61.57)
  BOTTOM w0.109: JDIM2800.229 175.43,27.23 v1(175.25,27.05)
M_0_DQ_0<2>: length 67.7
  IN3 w0.089: v2(135.66,60.42) 135.95,60.13 136.15,60.13 137.21,59.08 137.21,54.45 147.65,44 151.17,44 158.17,37.01 165.55,37.01 174.06,28.5 174.06,27 174.51,26.55 174.51,24.84 174.01,24.34 174.01,22.66 174.1,22.58 174.29,22.58 174.37,22.49 174.37,22.31 174.29,22.22 174.2,22.22 174.11,22.13 174.11,21.78 174.2,21.69 174.91,21.69 v1(175.02,21.59)
  BOTTOM w0.079: v2(135.66,60.42) 134.79,61.29 134.79,62.39 134.68,62.51 134.68,63.05 U400.CU52
  BOTTOM w0.109: v1(175.02,21.59) 175.18,21.43 JDIM2800.228
M_0_DQ_0<3>: length 66.6
  IN3 w0.089: v2(135.66,61.01) 135.76,61.11 136.29,61.11 136.52,60.88 136.52,60.2 137.51,59.2 137.51,54.56 147.77,44.3 151.29,44.3 158.29,37.3 165.67,37.3 174.35,28.62 174.35,27.13 174.81,26.66 174.81,24.73 174.51,24.43 174.51,23.36 v1(175.02,22.86)
  BOTTOM w0.079: U400.CU53 134.95,62.6 134.95,61.67 135.61,61.01 v2(135.66,61.01)
  BOTTOM w0.109: JDIM2800.224 174.18,22.01 v1(175.02,22.86)
M_0_DQ_0<4>: length 69.5
  IN3 w0.089: v2(134.44,57.78) 134.92,57.3 134.92,57.03 134.83,56.94 134.72,56.94 134.63,56.85 134.63,56.68 134.72,56.59 134.83,56.59 134.92,56.5 134.92,56.32 134.83,56.23 134.72,56.23 134.63,56.14 134.63,55.96 134.72,55.87 134.83,55.87 134.92,55.79 134.92,55.61 134.83,55.52 134.72,55.52 134.63,55.43 134.63,55.25 134.72,55.16 134.83,55.16 134.92,55.07 134.92,54.9 134.83,54.81 134.72,54.81 134.63,54.72 134.63,54.54 134.72,54.45 134.83,54.45 134.92,54.36 134.92,53.39 146.59,41.72 149.19,41.72 156.19,34.72 164.6,34.72 171.51,27.82 171.51,24.64 172.58,23.57 172.58,23.19 v1(172.18,22.79)
  BOTTOM w0.079: v2(134.44,57.78) 133.28,58.94 133.28,62.23 133.14,62.38 133.14,62.9 133.29,63.05 133.29,64.11 133.7,64.52 U400.CP49
  BOTTOM w0.109: JDIM2800.212 171.18,21.09 171.39,21.3 171.39,22 v1(172.18,22.79)
M_0_DQ_0<5>: length 68.9
  IN3 w0.089: v1(171.92,27.12) 171.92,27.81 164.73,35.01 156.31,35.01 156.07,35.25 156.07,35.38 156.24,35.55 156.24,35.67 156.12,35.8 155.99,35.8 155.82,35.63 155.7,35.63 155.57,35.75 155.57,35.88 155.74,36.05 155.74,36.17 155.61,36.3 155.49,36.3 155.32,36.13 155.19,36.13 155.07,36.26 155.07,36.38 155.24,36.55 155.24,36.68 155.11,36.8 154.99,36.8 154.82,36.63 154.69,36.63 154.56,36.76 154.56,36.88 154.73,37.05 154.73,37.18 154.61,37.31 154.48,37.31 154.31,37.14 154.19,37.14 154.06,37.26 154.06,37.39 154.23,37.56 154.23,37.68 154.11,37.81 153.98,37.81 153.81,37.64 153.68,37.64 153.56,37.76 153.56,37.89 153.73,38.06 153.73,38.19 153.6,38.31 153.48,38.31 153.31,38.14 153.18,38.14 153.06,38.27 153.06,38.39 153.23,38.56 153.23,38.69 153.1,38.82 152.97,38.82 152.8,38.64 152.68,38.64 152.55,38.77 152.55,38.9 152.72,39.07 152.72,39.19 152.6,39.32 152.47,39.32 152.3,39.15 152.18,39.15 152.05,39.27 152.05,39.4 152.22,39.57 152.22,39.69 152.09,39.82 151.97,39.82 151.8,39.65 151.67,39.65 151.55,39.78 151.55,39.9 151.72,40.07 151.72,40.2 151.59,40.32 151.47,40.32 151.29,40.15 151.17,40.15 151.04,40.28 151.04,40.4 151.21,40.58 151.21,40.7 151.09,40.83 150.96,40.83 150.79,40.66 150.67,40.66 150.54,40.78 150.54,40.91 150.71,41.08 150.71,41.2 150.59,41.33 150.46,41.33 150.29,41.16 150.16,41.16 150.04,41.28 150.04,41.41 150.21,41.58 150.21,41.71 150.08,41.83 149.96,41.83 149.79,41.66 149.66,41.66 149.31,42.01 146.71,42.01 135.21,53.51 135.21,57.57 v2(134.44,58.34)
  BOTTOM w0.079: v2(134.44,58.34) 133.44,59.34 133.44,62.29 133.29,62.44 133.29,62.83 133.46,63 133.46,63.7 U400.CP50
  BOTTOM w0.109: v1(171.92,27.12) JDIM2800.215
M_0_DQ_0<6>: length 68.4
  IN3 w0.089: v1(171.92,25.85) 172.35,26.28 172.35,27.8 164.85,35.3 157.03,35.3 156.66,35.67 156.66,35.8 156.7,35.84 156.7,35.97 156.58,36.09 156.45,36.09 156.41,36.05 156.28,36.05 156.15,36.17 156.15,36.3 156.25,36.39 156.25,36.52 156.12,36.64 156,36.64 155.9,36.55 155.78,36.55 155.65,36.68 155.65,36.8 155.74,36.89 155.74,37.02 155.62,37.15 155.49,37.15 155.4,37.05 155.27,37.05 155.15,37.18 155.15,37.31 155.24,37.4 155.24,37.52 155.12,37.65 154.99,37.65 154.9,37.56 154.77,37.56 154.65,37.68 154.65,37.81 154.74,37.9 154.74,38.03 154.61,38.15 154.49,38.15 154.39,38.06 154.27,38.06 154.14,38.19 154.14,38.31 154.24,38.4 154.24,38.53 154.11,38.65 153.98,38.65 153.89,38.56 153.77,38.56 153.64,38.69 153.64,38.81 153.73,38.91 153.73,39.03 153.61,39.16 153.48,39.16 153.39,39.07 153.26,39.07 153.14,39.19 153.14,39.32 153.23,39.41 153.23,39.53 153.1,39.66 152.98,39.66 152.89,39.57 152.76,39.57 152.63,39.69 152.63,39.82 152.73,39.91 152.73,40.04 152.6,40.16 152.47,40.16 152.38,40.07 152.26,40.07 152.13,40.2 152.13,40.32 152.22,40.41 152.22,40.54 152.1,40.67 151.97,40.67 151.88,40.57 151.75,40.57 151.63,40.7 151.63,40.83 151.72,40.92 151.72,41.04 151.59,41.17 151.47,41.17 151.38,41.08 151.25,41.08 151.13,41.2 151.13,41.33 151.22,41.42 151.22,41.55 151.09,41.67 150.97,41.67 150.87,41.58 150.75,41.58 150.62,41.71 150.62,41.83 150.71,41.92 150.71,42.05 150.59,42.18 150.46,42.18 150.37,42.08 150.25,42.08 150.03,42.3 146.83,42.3 135.51,53.63 135.51,57.86 134.85,58.52 134.85,59.05 v2(134.44,59.46)
  BOTTOM w0.079: v2(134.44,59.46) 133.6,60.3 133.6,62.36 133.45,62.51 133.45,62.75 133.65,62.95 133.65,63.23 U400.CP52
  BOTTOM w0.109: JDIM2800.211 170.92,26.85 v1(171.92,25.85)
M_0_DQ_0<7>: length 67.7
  IN3 w0.089: v2(134.45,60.02) 134.83,59.65 134.83,59.5 135.15,59.18 135.15,58.65 135.8,58 135.8,53.75 146.96,42.59 150.58,42.59 157.58,35.6 164.97,35.6 172.65,27.92 172.65,24.92 172.56,24.83 172.13,24.83 172.03,24.73 172.03,24.57 172.12,24.48 172.56,24.48 172.65,24.39 172.65,23.97 172.87,23.75 172.87,23.46 172.96,23.37 173.5,23.37 173.59,23.28 173.59,23.1 173.5,23.01 172.81,23.01 172.64,22.84 172.64,21.98 v1(172.18,21.52)
  BOTTOM w0.079: U400.CP53 133.75,62.58 133.75,60.72 v2(134.45,60.02)
  BOTTOM w0.109: v1(172.18,21.52) JDIM2800.216
M_0_DQ_1<0>: length 68
  IN3 w0.089: v1(169.95,21.58) 170.25,21.88 170.25,22.36 170.91,23.01 170.91,23.41 171,23.49 171.3,23.49 171.39,23.58 171.39,23.76 171.3,23.85 171,23.85 170.91,23.94 170.91,27.57 164.36,34.12 155.94,34.12 148.94,41.12 146.34,41.12 134.03,53.43 134.03,60.25 v2(132.89,61.39)
  BOTTOM w0.079: v2(132.89,61.39) 132.74,61.54 132.74,63.61 132.69,63.66 132.69,64.11 132.36,64.43 U400.CL49
  BOTTOM w0.109: v1(169.95,21.58) 169.95,21.38 170.18,21.16 JDIM2800.208
M_0_DQ_1<1>: length 67.7
  IN3 w0.089: v2(132.89,60.83) 133.73,59.99 133.73,53.32 146.22,40.83 148.82,40.83 155.82,33.83 164.24,33.83 170.6,27.46 170.6,24.75 170.52,24.66 170.17,24.66 170.07,24.55 170.07,24.39 170.15,24.3 170.52,24.3 170.6,24.21 170.6,23.2 170.25,22.85 v1(169.89,22.85)
  BOTTOM w0.079: v2(132.89,60.83) 132.57,61.15 132.57,62.34 132.58,62.35 132.58,63.5 132.36,63.72 U400.CL50
  BOTTOM w0.109: v1(169.89,22.85) 169.18,22.13 JDIM2800.204
M_0_DQ_1<2>: length 66.9
  IN3 w0.089: v1(169.87,27.12) 169.87,27.37 163.99,33.25 154.68,33.25 154.36,33.56 154.36,33.69 154.51,33.83 154.51,33.96 154.38,34.08 154.26,34.08 154.11,33.94 153.99,33.94 153.86,34.07 153.86,34.19 154,34.33 154,34.46 153.88,34.59 153.75,34.59 153.61,34.44 153.48,34.44 153.36,34.57 153.36,34.69 153.5,34.84 153.5,34.96 153.38,35.09 153.25,35.09 153.11,34.95 152.98,34.95 152.86,35.07 152.86,35.2 153,35.34 153,35.47 152.87,35.59 152.75,35.59 152.6,35.45 152.48,35.45 152.35,35.57 152.35,35.7 152.5,35.84 152.5,35.97 152.37,36.09 152.24,36.09 152.1,35.95 151.98,35.95 151.85,36.08 151.85,36.2 151.99,36.35 151.99,36.47 151.87,36.6 151.74,36.6 151.6,36.45 151.47,36.45 151.35,36.58 151.35,36.71 151.49,36.85 151.49,36.97 151.36,37.1 151.24,37.1 151.09,36.96 150.97,36.96 150.84,37.08 150.84,37.21 150.99,37.35 150.99,37.48 150.86,37.6 150.74,37.6 150.59,37.46 150.47,37.46 150.34,37.59 150.34,37.71 150.48,37.85 150.48,37.98 150.36,38.11 150.23,38.11 150.09,37.96 149.96,37.96 149.84,38.09 149.84,38.21 149.98,38.36 149.98,38.48 149.85,38.61 149.73,38.61 149.59,38.47 149.46,38.47 149.33,38.59 149.33,38.72 149.48,38.86 149.48,38.99 149.35,39.11 149.23,39.11 149.08,38.97 148.96,38.97 148.83,39.1 148.83,39.22 148.97,39.36 148.97,39.49 148.85,39.61 148.72,39.61 148.58,39.47 148.45,39.47 148.33,39.6 148.33,39.72 148.47,39.87 148.47,39.99 148.35,40.12 148.22,40.12 148.08,39.98 147.95,39.98 147.68,40.24 145.98,40.24 133.12,53.11 133.12,58.19 133.27,58.34 133.27,58.77 v2(132.89,59.15)
  BOTTOM w0.079: v2(132.89,59.15) 132.24,59.8 132.24,62.37 132.18,62.43 132.13,62.56 132.13,62.77 132.36,63 U400.CL52
  BOTTOM w0.109: JDIM2800.207 169.92,27.17 v1(169.87,27.12)
M_0_DQ_1<3>: length 67.2
  IN3 w0.089: v1(169.87,25.85) 170.17,25.85 170.3,25.98 170.3,27.35 164.11,33.54 155.34,33.54 154.98,33.89 154.98,34.02 155.04,34.07 155.04,34.2 154.91,34.33 154.79,34.33 154.73,34.27 154.61,34.27 154.48,34.4 154.48,34.52 154.54,34.58 154.54,34.7 154.41,34.83 154.28,34.83 154.23,34.77 154.1,34.77 153.98,34.9 153.98,35.02 154.03,35.08 154.03,35.2 153.91,35.33 153.78,35.33 153.73,35.28 153.6,35.28 153.48,35.4 153.48,35.53 153.53,35.58 153.53,35.71 153.4,35.83 153.28,35.83 153.22,35.78 153.1,35.78 152.97,35.9 152.97,36.03 153.03,36.09 153.03,36.21 152.9,36.34 152.78,36.34 152.72,36.28 152.6,36.28 152.47,36.41 152.47,36.53 152.52,36.59 152.52,36.71 152.4,36.84 152.27,36.84 152.22,36.78 152.09,36.78 151.97,36.91 151.97,37.04 152.02,37.09 152.02,37.22 151.9,37.34 151.77,37.34 151.72,37.29 151.59,37.29 151.46,37.41 151.46,37.54 151.52,37.59 151.52,37.72 151.39,37.85 151.27,37.85 151.21,37.79 151.09,37.79 150.96,37.92 150.96,38.04 151.02,38.1 151.02,38.22 150.89,38.35 150.76,38.35 150.71,38.29 150.58,38.29 150.46,38.42 150.46,38.54 150.51,38.6 150.51,38.73 150.39,38.85 150.26,38.85 150.21,38.8 150.08,38.8 149.95,38.92 149.95,39.05 150.01,39.1 150.01,39.23 149.88,39.35 149.76,39.35 149.7,39.3 149.58,39.3 149.45,39.43 149.45,39.55 149.51,39.61 149.51,39.73 149.38,39.86 149.26,39.86 149.2,39.8 149.08,39.8 148.95,39.93 148.95,40.05 149,40.11 149,40.23 148.88,40.36 148.75,40.36 148.7,40.3 148.57,40.3 148.34,40.54 146.1,40.54 133.42,53.21 133.42,57.99 133.53,58.09 133.53,59.71 133.37,59.87 133.04,59.87 v2(132.89,59.71)
  BOTTOM w0.079: v2(132.89,59.71) 132.4,60.2 132.4,62.59 U400.CL53
  BOTTOM w0.109: v1(169.87,25.85) 169.13,25.85 168.92,26.05 JDIM2800.203
M_0_DQ_1<4>: length 69.3
  IN3 w0.089: v2(131.86,57.76) 131.47,57.37 131.47,52.75 145.38,38.83 147.1,38.83 154.1,31.84 163.25,31.84 167.69,27.4 167.69,25.88 167.78,25.79 168.07,25.79 168.17,25.7 168.17,25.53 168.08,25.44 167.78,25.44 167.69,25.35 167.69,25.17 167.78,25.08 168.09,25.08 168.18,24.99 168.18,24.82 168.09,24.73 167.78,24.73 167.69,24.64 167.69,24.46 167.78,24.37 168.03,24.37 168.12,24.28 168.12,24.11 168.03,24.02 167.78,24.02 167.69,23.93 167.69,22.56 v1(166.68,21.55)
  BOTTOM w0.079: U400.CH49 131.14,64.52 130.73,64.11 130.73,63.07 130.49,62.83 130.49,59.13 v2(131.86,57.76)
  BOTTOM w0.109: v1(166.68,21.55) JDIM2800.194
M_0_DQ_1<5>: length 69.6
  IN3 w0.089: v2(131.86,58.32) 131.19,57.65 131.19,52.61 145.26,38.54 146.98,38.54 153.59,31.93 153.59,31.7 153.74,31.54 163.13,31.54 167.38,27.29 167.38,24.71 167.29,24.61 166.39,24.61 166.29,24.52 166.29,24.35 166.38,24.26 167.29,24.26 167.38,24.16 167.38,22.7 167.23,22.54 166.95,22.54 v1(166.68,22.82)
  BOTTOM w0.079: U400.CH50 130.91,63.7 130.91,63.02 130.65,62.76 130.65,59.53 v2(131.86,58.32)
  BOTTOM w0.109: JDIM2800.190 165.68,21.82 v1(166.68,22.82)
M_0_DQ_1<6>: length 67.9
  IN3 w0.089: v2(131.86,59.44) 131.47,59.05 131.47,58.44 130.88,57.85 130.88,52.51 145.14,38.25 146.28,38.25 146.57,37.96 146.69,37.96 146.86,38.12 146.98,38.12 147.11,38 147.11,37.87 146.94,37.71 146.94,37.58 147.07,37.46 147.2,37.46 147.29,37.55 147.36,37.62 147.48,37.62 147.61,37.49 147.61,37.37 147.45,37.21 147.45,37.08 147.57,36.95 147.7,36.95 147.86,37.12 147.99,37.12 148.11,36.99 148.11,36.87 147.95,36.7 147.95,36.58 148.08,36.45 148.2,36.45 148.37,36.62 148.49,36.62 148.62,36.49 148.62,36.36 148.45,36.2 148.45,36.08 148.58,35.95 148.7,35.95 148.87,36.11 148.99,36.11 149.12,35.99 149.12,35.86 148.96,35.7 148.96,35.57 149.08,35.45 149.21,35.45 149.37,35.61 149.5,35.61 149.62,35.48 149.62,35.36 149.46,35.19 149.46,35.07 149.59,34.94 149.71,34.94 149.87,35.11 150,35.11 150.13,34.98 150.13,34.85 149.96,34.69 149.96,34.57 150.09,34.44 150.21,34.44 150.38,34.6 150.5,34.6 150.63,34.48 150.63,34.35 150.47,34.19 150.47,34.06 150.59,33.94 150.72,33.94 150.88,34.1 151.01,34.1 151.13,33.97 151.13,33.85 150.97,33.69 150.97,33.56 151.09,33.43 151.22,33.43 151.38,33.6 151.51,33.6 151.63,33.47 151.63,33.35 151.47,33.18 151.47,33.06 151.6,32.93 151.72,32.93 151.89,33.09 152.01,33.09 152.14,32.97 152.14,32.84 151.97,32.68 151.97,32.55 152.1,32.43 152.23,32.43 152.39,32.59 152.51,32.59 152.64,32.47 152.64,32.34 152.48,32.18 152.48,32.05 152.6,31.93 152.73,31.93 152.89,32.09 153.02,32.09 153.14,31.96 153.14,31.84 152.98,31.67 152.98,31.49 153.22,31.25 163.01,31.25 166.34,27.92 166.57,27.69 166.57,27.18 166.66,27.09 v1(166.92,27.09)
  BOTTOM w0.079: v2(131.86,59.44) 130.84,60.46 130.84,62.7 131.14,63 U400.CH52
  BOTTOM w0.109: v1(166.92,27.09) JDIM2800.195
M_0_DQ_1<7>: length 67.5
  IN3 w0.089: v2(131.86,60) 131.27,59.4 131.27,58.6 130.58,57.91 130.58,52.4 145.02,37.96 145.73,37.96 145.98,37.71 146.1,37.71 146.19,37.8 146.32,37.8 146.44,37.67 146.44,37.55 146.35,37.46 146.35,37.33 146.48,37.21 146.61,37.21 146.69,37.3 146.82,37.3 146.95,37.17 146.95,37.04 146.86,36.96 146.86,36.83 146.98,36.7 147.11,36.7 147.2,36.79 147.32,36.79 147.45,36.67 147.45,36.54 147.36,36.45 147.36,36.33 147.49,36.2 147.61,36.2 147.7,36.29 147.83,36.29 147.95,36.16 147.95,36.04 147.86,35.95 147.86,35.82 147.99,35.7 148.11,35.7 148.2,35.79 148.33,35.79 148.45,35.66 148.45,35.54 148.37,35.45 148.37,35.32 148.49,35.2 148.62,35.2 148.71,35.28 148.83,35.28 148.96,35.16 148.96,35.03 148.87,34.94 148.87,34.82 148.99,34.69 149.12,34.69 149.21,34.78 149.33,34.78 149.46,34.65 149.46,34.53 149.37,34.44 149.37,34.32 149.5,34.19 149.62,34.19 149.71,34.28 149.84,34.28 149.96,34.15 149.96,34.03 149.87,33.94 149.87,33.81 150,33.69 150.13,33.69 150.21,33.78 150.34,33.78 150.47,33.65 150.47,33.52 150.38,33.44 150.38,33.31 150.5,33.18 150.63,33.18 150.72,33.27 150.84,33.27 150.97,33.15 150.97,33.02 150.88,32.93 150.88,32.81 151.01,32.68 151.13,32.68 151.22,32.77 151.35,32.77 151.47,32.64 151.47,32.52 151.38,32.43 151.38,32.3 151.51,32.18 151.63,32.18 151.72,32.27 151.85,32.27 151.97,32.14 151.97,32.01 151.89,31.93 151.89,31.8 152.01,31.68 152.14,31.68 152.23,31.76 152.35,31.76 152.48,31.64 152.48,31.51 152.39,31.42 152.39,31.3 152.73,30.96 162.89,30.96 166.28,27.57 166.28,26.1 166.56,25.82 v1(166.92,25.82)
  BOTTOM w0.079: v2(131.86,60) 131.05,60.81 131.05,62.54 U400.CH53
  BOTTOM w0.109: JDIM2800.191 165.92,26.82 v1(166.92,25.82)
M_0_DQ_2<0>: length 73.4
  IN1 w0.079: v2(135.08,67.97) 135.64,67.42 135.64,65.92 136.25,65.31 136.41,65.31 139.1,62.62 139.1,59.45 138.9,59.24 138.9,56.98 163.9,31.98 168.91,31.98 169.05,31.83 169.05,31.5 169.13,31.42 169.29,31.42 169.37,31.5 169.37,31.95 169.45,32.03 169.61,32.03 169.68,31.95 169.68,31.5 169.76,31.42 169.92,31.42 170,31.5 170,31.95 170.08,32.03 170.24,32.03 170.31,31.95 170.31,31.5 170.39,31.42 170.55,31.42 170.63,31.5 170.63,31.95 170.71,32.03 170.87,32.03 170.94,31.95 170.94,31.5 171.02,31.42 171.18,31.42 171.26,31.5 171.26,31.95 171.34,32.03 171.49,32.03 171.57,31.95 171.57,31.5 171.65,31.42 173.07,31.42 174.71,29.78 176.32,29.78 179.54,26.56 v1(179.8,26.56)
  BOTTOM w0.109: U400.CV41 135.37,68.26 v2(135.08,67.97) ; JDIM2800.249 180.43,27.28 179.8,26.66 v1(179.8,26.56)
M_0_DQ_2<1>: length 74.5
  IN1 w0.079: v2(134.17,67.97) 133.61,67.41 133.61,65.93 133.23,65.56 133.23,64.75 133.44,64.54 133.44,63.92 134.82,62.53 134.82,60.02 135.05,59.79 135.05,56.47 163.69,27.82 163.92,27.82 163.99,27.9 163.99,28.24 164.07,28.32 164.23,28.32 164.31,28.24 164.31,27.9 164.39,27.82 164.55,27.82 164.62,27.9 164.62,28.24 164.7,28.32 164.86,28.32 164.94,28.24 164.94,27.9 165.02,27.82 165.17,27.82 165.25,27.9 165.25,28.24 165.33,28.32 165.49,28.32 165.57,28.24 165.57,27.9 165.65,27.82 172.3,27.82 174.22,25.91 174.22,24.64 174.84,24.01 175.15,24.01 176.45,22.7 176.45,22.11 v1(176.97,21.59)
  BOTTOM w0.109: JDIM2800.236 177.18,21.39 v1(176.97,21.59) ; U400.CT41 134.45,68.26 v2(134.17,67.97)
M_0_DQ_2<2>: length 73.2
  IN1 w0.079: v2(135.08,67.32) 135.44,66.97 135.44,65.86 138.81,62.49 138.81,59.57 138.61,59.36 138.61,56.88 163.78,31.7 166.14,31.7 166.7,31.13 166.91,31.13 166.99,31.21 166.99,31.52 167.07,31.6 167.23,31.6 167.31,31.52 167.31,31.21 167.39,31.13 167.54,31.13 167.62,31.21 167.62,31.52 167.7,31.6 167.86,31.6 167.94,31.52 167.94,31.21 168.02,31.13 168.17,31.13 168.25,31.21 168.25,31.52 168.33,31.6 168.49,31.6 168.57,31.52 168.57,31.21 168.65,31.13 172.95,31.13 174.59,29.5 176.2,29.5 179.41,26.29 179.41,25.68 v1(179.8,25.3)
  BOTTOM w0.109: v1(179.8,25.3) 178.9,26.19 178.9,26.86 179.43,27.38 JDIM2800.245 ; U400.CV42 135.37,67.61 v2(135.08,67.32)
M_0_DQ_2<3>: length 74.4
  IN1 w0.079: v2(134.17,67.32) 133.93,67.32 133.81,67.21 133.81,65.87 133.51,65.56 133.51,64.82 133.67,64.67 133.67,63.99 135.02,62.63 135.02,60.14 135.34,59.83 135.34,56.57 163.3,28.61 165.77,28.61 165.89,28.5 165.89,28.19 165.96,28.12 166.12,28.12 166.2,28.19 166.2,28.54 166.28,28.61 166.44,28.61 166.52,28.54 166.52,28.19 166.6,28.12 166.75,28.12 166.83,28.19 166.83,28.54 166.91,28.61 167.07,28.61 167.15,28.54 167.15,28.19 167.23,28.12 167.38,28.12 167.46,28.19 167.46,28.54 167.54,28.61 167.7,28.61 167.78,28.54 167.78,28.19 167.86,28.11 172.42,28.11 172.65,27.87 174.51,26.01 174.51,24.75 174.96,24.29 175.56,24.29 176.97,22.88 v1(176.97,22.86)
  BOTTOM w0.109: v1(176.97,22.86) 176.18,22.06 JDIM2800.232 ; v2(134.17,67.32) 134.45,67.61 U400.CT42
M_0_DQ_2<4>: length 71.8
  IN1 w0.079: v2(135.08,66.02) 135.08,65.9 136.35,64.63 136.35,64.46 138.52,62.29 138.52,59.69 138.31,59.48 138.31,56.77 163.67,31.41 166.02,31.41 166.59,30.85 172.84,30.85 174.48,29.21 176.09,29.21 179.12,26.18 179.12,24.48 179.78,23.82 179.78,23.39 v1(180.13,23.04)
  BOTTOM w0.109: v2(135.08,66.02) 135.37,66.31 U400.CV45 ; JDIM2800.246 179.68,21.08 179.27,21.49 179.27,22.4 179.91,23.04 v1(180.13,23.04)
M_0_DQ_2<5>: length 72.9
  IN1 w0.079: v1(176.93,24.75) 176.88,24.75 176.79,24.65 175.09,24.65 174.8,24.94 174.8,26.12 172.53,28.39 170.12,28.39 170.03,28.47 170.03,28.82 169.95,28.9 169.79,28.9 169.71,28.82 169.71,28.47 169.64,28.39 169.48,28.39 169.4,28.47 169.4,28.82 169.32,28.9 169.16,28.9 169.08,28.82 169.08,28.47 169.01,28.39 168.85,28.39 168.77,28.47 168.77,28.82 168.69,28.9 168.53,28.9 168.45,28.82 168.45,28.47 168.38,28.39 168.22,28.39 168.14,28.47 168.14,28.76 168,28.9 163.42,28.9 135.63,56.68 135.63,59.87 135.28,60.22 135.28,62.68 133.93,64.02 133.93,64.89 133.76,65.05 133.76,65.51 134.17,65.92 v2(134.17,66.02)
  BOTTOM w0.109: JDIM2800.233 176.43,27.48 176.13,27.19 176.13,25.45 176.83,24.75 v1(176.93,24.75) ; U400.CT45 134.45,66.31 v2(134.17,66.02)
M_0_DQ_2<6>: length 70.8
  IN1 w0.079: v2(135.08,65.37) 135.88,64.58 135.88,64.42 138.22,62.08 138.22,59.94 138.02,59.74 138.02,56.66 163.55,31.13 165.91,31.13 166.47,30.57 172.72,30.57 174.36,28.93 175.97,28.93 178.83,26.07 178.83,24.36 179.47,23.71 179.47,22.52 v1(180.21,21.78)
  BOTTOM w0.109: v2(135.08,65.37) 135.37,65.66 U400.CV47 ; JDIM2800.250 180.68,21.32 v1(180.21,21.78)
M_0_DQ_2<7>: length 72.3
  IN1 w0.079: v2(134.17,65.4) 134.17,64.38 135.35,63.19 135.71,63.19 136.05,62.85 136.05,62.44 136.55,61.95 136.55,60.37 135.96,59.79 135.96,56.75 163.54,29.18 163.76,29.18 163.83,29.26 163.83,29.66 163.91,29.74 164.07,29.74 164.15,29.66 164.15,29.26 164.23,29.18 164.39,29.18 164.46,29.26 164.46,29.66 164.54,29.74 164.7,29.74 164.78,29.66 164.78,29.26 164.86,29.18 165.02,29.18 165.09,29.26 165.09,29.66 165.17,29.74 165.33,29.74 165.41,29.66 165.41,29.26 165.49,29.18 170.31,29.18 170.39,29.1 170.39,28.75 170.47,28.67 170.63,28.67 170.7,28.75 170.7,29.1 170.78,29.18 170.94,29.18 171.02,29.1 171.02,28.75 171.1,28.67 171.26,28.67 171.33,28.75 171.33,29.1 171.41,29.18 171.57,29.18 171.65,29.1 171.65,28.75 171.73,28.67 171.89,28.67 171.96,28.75 171.96,29 172.06,29.1 172.23,29.1 172.3,29.02 172.3,28.76 172.39,28.67 172.65,28.67 173.78,27.54 175.41,27.54 v1(176.93,26.02)
  BOTTOM w0.109: v1(176.93,26.02) 176.93,26.94 177.43,27.44 JDIM2800.237 ; v2(134.17,65.4) 134.43,65.66 U400.CT47
M_0_DQ_3<0>: length 72.6
  IN3 w0.089: v2(131.42,67.97) 130.93,67.49 130.93,67.18 130.86,67.1 130.86,65.89 129.45,64.48 129.45,64.24 126.85,61.64 126.85,50.72 137.84,39.72 137.84,38.52 149.19,27.18 151.74,27.18 152.71,26.2 153.01,26.2 153.1,26.11 153.1,25.82 153.2,25.72 153.36,25.72 153.46,25.81 153.46,26.11 153.54,26.2 153.72,26.2 153.81,26.11 153.81,25.73 153.91,25.63 154.08,25.63 154.17,25.72 154.17,26.11 154.26,26.2 154.43,26.2 154.52,26.11 154.52,25.7 154.62,25.6 154.79,25.6 154.88,25.69 154.88,26.11 154.97,26.2 157.31,26.2 157.65,25.86 157.65,24.8 158.17,24.28 159.98,24.28 161.16,23.09 161.16,22.01 v1(161.68,21.5)
  BOTTOM w0.109: U400.CK41 131.71,68.26 v2(131.42,67.97) ; v1(161.68,21.5) JDIM2800.174
M_0_DQ_3<1>: length 72.3
  IN3 w0.089: v2(132.34,67.97) 132.87,67.44 132.87,65.92 133.22,65.57 133.22,65.07 133.63,64.66 133.63,63.77 132.8,62.94 132.01,62.94 131.37,62.29 131.37,59.97 131.06,59.66 131.06,58.7 130.07,57.71 130.07,52.06 144.77,37.36 145.48,37.36 152.48,30.36 162.64,30.36 165.68,27.32 165.68,22.5 v1(164.68,21.49)
  BOTTOM w0.109: v2(132.34,67.97) 132.62,68.26 U400.CM41 ; v1(164.68,21.49) JDIM2800.186
M_0_DQ_3<2>: length 71.8
  IN3 w0.089: v1(164.68,22.76) 165.38,23.47 165.38,27.22 162.52,30.07 152.36,30.07 145.36,37.07 144.65,37.07 129.77,51.95 129.77,57.71 130.81,58.75 130.81,59.74 131.16,60.09 131.16,62.41 132,63.24 132.66,63.24 133.38,63.96 133.38,64.58 132.94,65.02 132.94,65.59 132.69,65.84 132.69,66.97 v2(132.34,67.32)
  BOTTOM w0.109: JDIM2800.182 163.68,21.76 v1(164.68,22.76) ; v2(132.34,67.32) 132.62,67.61 U400.CM42
M_0_DQ_3<3>: length 72.4
  IN3 w0.089: v2(131.42,67.32) 131.07,66.97 131.07,65.81 129.74,64.48 129.74,64.16 127.15,61.57 127.15,50.83 138.14,39.84 138.14,38.64 149.31,27.47 151.86,27.47 152.83,26.49 154.24,26.49 154.33,26.58 154.33,26.88 154.43,26.98 154.59,26.98 154.68,26.89 154.68,26.58 154.77,26.49 156.32,26.49 156.41,26.58 156.41,26.92 156.5,27.01 156.67,27.01 156.77,26.91 156.77,26.58 156.86,26.49 157.43,26.49 157.95,25.97 157.95,24.93 158.3,24.58 161.8,24.58 162.2,24.18 162.2,23.29 v1(161.68,22.77)
  BOTTOM w0.109: U400.CK42 131.71,67.61 v2(131.42,67.32) ; v1(161.68,22.77) 160.79,21.88 160.79,21.27 160.68,21.16 JDIM2800.170
M_0_DQ_3<4>: length 70.5
  IN3 w0.089: v1(164.92,27.12) 164.92,27.25 162.4,29.78 152.24,29.78 151.21,30.8 150.98,31.03 150.12,31.03 150.03,31.12 150.03,31.33 150.27,31.56 150.27,31.68 150.14,31.81 150.01,31.81 149.63,31.43 149.48,31.43 149.37,31.55 149.37,31.67 149.79,32.1 149.79,32.22 149.67,32.35 149.54,32.35 149.13,31.94 149.01,31.94 148.88,32.06 148.88,32.19 149.29,32.6 149.29,32.73 149.16,32.85 149.04,32.85 148.63,32.44 148.5,32.44 148.38,32.57 148.38,32.69 148.79,33.1 148.79,33.23 148.66,33.36 148.54,33.36 148.13,32.94 148,32.94 147.87,33.07 147.87,33.2 148.28,33.61 148.28,33.73 148.16,33.86 148.03,33.86 147.62,33.45 147.5,33.45 147.37,33.57 147.37,33.7 147.78,34.11 147.78,34.23 145.24,36.78 144.53,36.78 129.46,51.84 129.46,57.71 130.58,58.82 130.58,59.87 130.91,60.2 130.91,62.48 132.62,64.19 132.62,64.7 132.72,64.8 132.72,65.52 132.34,65.91 v2(132.34,66.02)
  BOTTOM w0.109: U400.CM45 132.62,66.31 v2(132.34,66.02) ; v1(164.92,27.12) JDIM2800.187
M_0_DQ_3<5>: length 71.7
  IN3 w0.089: v1(161.43,25.83) 160.7,25.83 160.07,26.46 160.07,27.17 159.46,27.78 154.34,27.78 153.59,27.03 152.71,27.03 151.98,27.76 149.45,27.76 140.57,36.64 140.57,36.77 140.68,36.88 140.68,37.01 140.56,37.14 140.43,37.14 140.31,37.02 140.19,37.02 140.06,37.15 140.06,37.27 140.53,37.74 140.53,37.86 140.4,37.99 140.28,37.99 139.81,37.52 139.69,37.52 139.56,37.65 139.56,37.77 140.03,38.24 140.03,38.37 139.9,38.49 139.77,38.49 139.31,38.03 139.18,38.03 139.06,38.15 139.06,38.28 139.52,38.74 139.52,38.87 139.4,38.99 139.27,38.99 138.81,38.53 138.68,38.53 138.55,38.65 138.55,38.78 139.02,39.25 139.02,39.37 127.46,50.94 127.46,61.44 130.06,64.05 130.06,64.52 131.42,65.88 v2(131.42,66.02)
  BOTTOM w0.109: v1(161.43,25.83) 160.43,26.83 JDIM2800.169 ; v2(131.42,66.02) 131.71,66.31 U400.CK45
M_0_DQ_3<6>: length 70.1
  IN3 w0.089: v2(132.34,65.37) 132.34,64.29 130.1,62.05 130.1,58.7 129.16,57.76 129.16,51.64 144.64,36.16 144.77,36.16 144.92,36.31 145.05,36.31 145.17,36.19 145.17,36.06 145.02,35.91 145.02,35.78 145.14,35.66 145.27,35.66 145.42,35.81 145.55,35.81 145.67,35.68 145.67,35.56 145.52,35.41 145.52,35.28 145.65,35.15 145.77,35.15 145.93,35.31 146.05,35.31 146.18,35.18 146.18,35.06 145.7,34.58 145.7,34.43 145.81,34.32 145.94,34.32 146.43,34.8 146.55,34.8 146.68,34.68 146.68,34.55 146.33,34.21 146.33,34.08 146.46,33.95 146.58,33.95 146.86,34.23 147.02,34.23 147.13,34.12 147.13,33.99 146.88,33.75 146.88,33.62 149.76,30.74 150.86,30.74 152.12,29.49 162.28,29.49 164.54,27.23 164.54,26.24 v1(164.92,25.85)
  BOTTOM w0.109: JDIM2800.183 163.92,26.85 v1(164.92,25.85) ; U400.CM47 132.62,65.66 v2(132.34,65.37)
M_0_DQ_3<7>: length 71
  IN3 w0.089: v1(161.43,27.1) 160.56,27.1 159.58,28.08 154.22,28.08 153.46,27.32 152.83,27.32 152.1,28.05 149.57,28.05 144.15,33.47 144.15,33.68 144.29,33.82 144.29,33.95 144.17,34.07 144.04,34.07 143.87,33.9 143.74,33.9 143.61,34.02 143.61,34.14 144.04,34.57 144.04,34.7 143.92,34.82 143.79,34.82 143.36,34.39 143.23,34.39 143.11,34.52 143.11,34.64 143.57,35.11 143.57,35.23 143.45,35.36 143.32,35.36 142.86,34.89 142.73,34.89 142.6,35.02 142.6,35.14 143.07,35.61 143.07,35.74 142.94,35.86 142.82,35.86 142.35,35.4 142.23,35.4 142.1,35.52 142.1,35.65 142.57,36.11 142.57,36.24 142.44,36.36 142.31,36.36 141.85,35.9 141.72,35.9 141.6,36.03 141.6,36.15 142.06,36.62 142.06,36.74 141.94,36.87 141.81,36.87 141.35,36.4 141.22,36.4 141.09,36.53 141.09,36.65 141.56,37.12 141.56,37.24 127.76,51.05 127.76,61.39 128.57,62.2 128.88,62.2 131.42,64.74 v2(131.42,65.37)
  BOTTOM w0.109: v2(131.42,65.37) 131.71,65.66 U400.CK47 ; v1(161.43,27.1) JDIM2800.173
M_0_DQ_4<0>: length 53.2
  IN1 w0.079: v2(121.5,61.47) 120.96,61.47 120.2,60.72 120.2,53.71 121.82,52.09 121.82,45.46 121.41,45.05 121.41,38.72 127.71,32.42 127.71,31.7 127.89,31.52 128.46,31.52 128.56,31.42 128.56,31.27 128.48,31.19 127.77,31.19 127.69,31.11 127.69,30.95 127.77,30.87 128.47,30.87 128.55,30.8 128.55,30.64 128.47,30.56 127.77,30.56 127.69,30.48 127.69,30.32 127.77,30.24 128.45,30.24 128.53,30.17 128.53,30.01 128.45,29.93 127.77,29.93 127.69,29.85 127.69,29.69 127.77,29.61 128.45,29.61 128.53,29.54 128.53,29.38 128.45,29.3 127.77,29.3 127.69,29.22 127.69,29.06 127.77,28.98 128.5,28.98 128.58,28.91 128.58,28.75 128.5,28.67 127.77,28.67 127.69,28.59 127.69,28.43 127.77,28.36 128.45,28.36 128.53,28.28 128.53,28.12 128.45,28.04 127.77,28.04 127.69,27.96 127.69,27.8 127.77,27.73 128.35,27.73 128.42,27.65 v1(128.42,27.11)
  BOTTOM w0.079: U400.BH49 122.04,64.59 121.88,64.43 121.88,63.83 121.93,63.78 121.93,63.08 121.78,62.92 121.78,61.75 v2(121.5,61.47)
  BOTTOM w0.109: v1(128.42,27.11) JDIM2800.49
M_0_DQ_4<1>: length 52.4
  IN1 w0.079: v1(128.68,21.53) 127.93,22.27 127.66,22.27 127.58,22.35 127.58,22.51 127.66,22.59 127.93,22.59 128.01,22.66 128.01,22.89 127.51,23.39 127.51,23.87 126.84,24.54 126.84,30.35 125.65,31.54 125.65,33.28 120.56,38.37 120.56,45.4 121.03,45.87 121.03,51.71 119.35,53.39 119.35,61.26 121.04,62.94 121.96,62.94 122.75,62.15 v2(122.77,62.15)
  BOTTOM w0.079: U400.BH50 122.15,63.73 122.41,63.48 122.41,62.51 v2(122.77,62.15)
  BOTTOM w0.109: v1(128.68,21.53) JDIM2800.50
M_0_DQ_4<2>: length 52.1
  IN1 w0.079: v1(128.42,25.84) 127.49,25.84 127.41,25.93 127.41,26.12 127.49,26.2 127.81,26.2 127.89,26.27 127.89,26.43 127.81,26.51 127.49,26.51 127.41,26.59 127.41,26.75 127.49,26.82 127.81,26.82 127.89,26.9 127.89,27.06 127.81,27.14 127.54,27.14 127.41,27.27 127.41,32.32 121.13,38.6 121.13,45.18 121.56,45.62 121.56,51.94 119.91,53.59 119.91,61.01 121.31,62.41 121.66,62.41 122.03,62.04 122.03,61.19 122.74,60.48 122.77,60.48 v2(122.77,60.48)
  BOTTOM w0.079: U400.BH52 122.15,63.01 121.93,62.79 121.93,61.49
  BOTTOM w0.109: v2(122.77,60.48) 121.93,61.31 121.93,61.49 ; v1(128.42,25.84) 127.42,26.84 JDIM2800.45

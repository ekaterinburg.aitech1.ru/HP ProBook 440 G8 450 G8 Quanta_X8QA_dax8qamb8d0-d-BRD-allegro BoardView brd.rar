# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Nets (continued)
N66149192: TP2000.1 U2000.A3
N66149611: TP2001.1 U2001.A3
N66154196: TP2002.1 U2002.A3
N66155185: TP2004.1 U2004.A3
N66156322: TP2005.1 U2005.A3
N66156623: TP2006.1 U2006.A3
N69862011: R1603.1 U400.DA15 U400.DA17
N69862027: R1602.1 U400.DD17 U400.DD18
N71200998: R1001.2 U400.AR2
N71203256: TP608.1 U400.DF31
N4193523427: JDIM2800.162 TP2800.1
N4193523428: JDIM2800.165 TP2801.1
N4193827027: JDIM2900.162 TP2900.1
N4193827028: JDIM2900.165 TP2901.1

Pads without a net: CON1900 4 7; CON3400 3 4 29; CON3401 3 4; CON3501 13 14; CON4100 8 12 20 44 46 48 66 68 70; CON4202 7 9 22 29 31 35 37 38 40 42 44 46 48 59 60 61 62 63 64 65 68; CON4300 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CON5002 4 5; CON7602 10; CON7700 2 16 17 18; CON7702 1 2; CON7704 8; D5003 3 4 5; H7918 1; NOREF 1; NOREF#4 1; NOREF#6 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; NOREF#13 1; NOREF#14 1; NOREF#15 1; NOREF#16 1; NOREF#17 1; NOREF#18 1; NOREF#20 1; NOREF#21 1; NOREF#22 1; PU8101 5; PU8602 4; PU8800 16 17 18 19 20 21; PU8900 19; PU8901 19; PU9800 14 18; U400 A3 A15 A18 A20 A48 A52 AB2 AC1 AC2 AC41 AC42 AC45 AC47 AC50 AC53 AD1 AD2 AD5 AD7 AF5 AF7 AH5 AH7 AH9 AK9 AP9 AT1 AT2 AU1 AU2 AY5 AY7 AY12 B3 B15 B18 B20 B22 B53 BB5 BB7 BB12 BD5 BD7 BE1 BE2 BF1 BF2 BF12 BH5 BH7 BJ1 BJ2 BK1 BK2 BK5 BK7 BL53 BM5 BM7 BM12 BN10 BN51 BN53 BP42 BP44 BP45 BP47 BP52 BP53 BT45 BT47 BW1 BW2 C16 C53 CA51 CA53 CB39 CD39 CD41 CD42 CD45 CD47 CE50 CE53 CF39 CM39 CT1 CT2 CU7 CU8 CW9 CW12 CY15 CY28 CY30 CY39 D4 D15 D16 D18 D20 D22 DA9 DB47 DD44 DD47 DF6 DF13 DF25 DF27 DF29 DF35 DF43 DF47 DF49 DF50 DF52 DG8 DG17 DG19 DG29 DG47 DJ8 DJ19 DJ27 DJ29 DJ47 DK13 DK15 DK23 DK31 DK33 DM31 DN23 DN31 DN33 DP4 DR7 DR9 DR12 DR15 DR24 DT12 DT14 DT15 DT21 DT27 DT35 DT44 DU14 DU25 DU31 DV6 DV11 DV12 DV14 DV15 DV21 DV24 DV25 DV31 DW6 DW12 DW32 DW47 DW49 E3 E15 E18 E22 E53 F53 G14 G16 G18 G20 H14 H16 H18 H20 J53 K51 K53 L14 L16 L18 L20 M52 M53 N14 N16 N18 N20 N42 N44 N45 N47 R45 R47 T35 U21 U35 U37 U38 V21 V35 W20 W34 W37 W38 W51 W53; U1800 B2 C2; U1801 B2 C2; U1802 B2 C2; U1803 B2 C2; U1804 B2 C2; U1805 B2 C2; U1806 B2 C2; U1807 B2 C2; U1809 B2 C2; U1900 B2 C2; U1902 B2 C2; U1903 B2 C2; U1904 B2 C2; U1905 B2 C2; U1906 B2 C2; U1907 B2 C2; U1908 B2 C2; U1909 B2 C2; U2000 B2 C2; U2001 B2 C2; U2002 B2 C2; U2004 B2 C2; U2005 B2 C2; U2006 B2 C2; U2007 B2 C2; U2008 B2 C2; U2010 B2 C2; U3501 12 20; U3600 10 17 18; U4700 D3 G3 G9 H2 J2 K10 K11 L6 L7 M2; U5100 3 5 10 11 12 13 14 15 25 26 27 28 29 30 31; U5403 6; U5900 A1 A2 A12 J6 L3; U6100 24; U6101 3 4; U6202 3; U6203 13; U6600 A3 A7 A14 A16 A17 A20 A22 A23 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AC27 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B19 C3 C4 C7 C14 D4 D5 D10 D11 E6 E7 E9 E10 F3 F4 F5 F6 F7 F19 H2 H5 L2 P2 P5 P25 P27 T27 U2 U5 U27 W5 W22 Y3 Y4 Y27; U7600 13 22 23 24 25 26 31; VRAM7000 A5 A10 U5 U10; VRAM7001 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4435 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 2213 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 361 vias
v4: diameter 0.711, hole 0.356, TOP to BOTTOM, 34 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON: length 161.6
  TOP w0.203: v1(39.9,104.64) 39.79,104.98 39.58,105.5 39.22,105.86 PR9828.1 v1(38.55,106.43) ; 62.18,98.37 62.08,98.47 57.55,98.47 57.37,98.65 R6826.1 ; R6965.2 67.94,93.18 67.94,91.18 67.64,90.88 66.88,90.88 66.5,91.26 66.5,92.02 65.12,93.39 64.59,93.39 64.23,93.04 57.96,93.04 R6839.1
  TOP w0.305: v1(39.9,104.64) 40.12,103.91 40.16,103.69 40.16,100.78 40.26,100.68 v1(40.26,100.28)
  TOP w0.381: v1(80.1,96.57) 80.1,96.26 78.69,94.85 78.69,93.7 78.56,93.57 v1(78.56,93.24)
  TOP w0.508: v1(80.1,96.57) 81,96.57 81.09,96.66 81.48,96.66 81.83,97.01 85.05,97.01 85.62,96.44 v1(86,96.44)
  IN3 w0.305: v1(40.26,100.28) 41.04,99.5 50.94,99.5 51.29,99.15 53.99,99.15 55.22,100.38 60.65,100.38 61.69,99.34 77.47,99.34 78.26,100.12 78.89,100.12 79.28,100.52 81.47,100.52 82.19,99.8 82.19,98.93 81.48,98.22 80.4,98.22 80.05,97.87 80.05,97.24 80.1,97.19 v1(80.1,96.57)
  IN3 w0.381: v1(70.53,83.23) 71.03,83.73 71.03,86.66 71.36,86.98 71.36,91.35 70.77,91.94 70.77,94.54 70.24,95.07 v1(69.98,95.07)
  IN3 w0.508: v1(66.65,96.53) 66.65,96.68 67.09,97.13 69.16,97.13 69.28,97.01 76.54,97.01 76.66,97.13 78.53,97.13 79.09,96.57 v1(80.1,96.57) 80.1,93.64 80,93.54 80,90.68 82.55,88.13 82.55,86.85 83.15,86.24 v1(84.31,86.24)
  BOTTOM w0.203: PR9808.2 35.74,106.85 36.16,106.43 v1(38.55,106.43) ; v1(78.56,93.24) 78.33,93.01 R6927.1 77.77,93.01 77.12,93.01 R6923.1
  BOTTOM w0.254: v1(80.1,96.57) 80.1,95.4 79.96,95.25 R6800.2 79.96,91.82 R6952.2
  BOTTOM w0.381: PR10501.1 71.04,58.37 73.46,58.37 74.01,58.93 v1(74.17,58.93) ; R6809.2 61.64,93.77 61.92,94.05 62.58,94.05 63.9,95.37 65.58,95.37 66.34,96.14 66.34,96.22 v1(66.65,96.53) ; R6903.2 R6902.2 R6904.2 70.21,94.87 70.01,95.07 v1(69.98,95.07)
  BOTTOM w0.508: 81.4,59.66 80.91,60.16 80.91,61.09 U6601.5 79.16,61.39 C6680.2 ; C6900.2 C6714.2 90.76,96.39 U6902.5 89.7,96.21 89.15,95.65 87.16,95.65 86.78,96.04 U6701.5 86.73,96.44 v1(86,96.44)
  vias: v1(70.53,82.57) v1(74.04,67) v1(74.93,66.29) v1(75.53,66.12) v1(81.46,76.88) v1(81.76,58.62) v1(82.65,82.37) v1(85.69,78.92)
1V8_AON_EN: length 26
  IN2 w0.508: v1(88.57,79.78) 88.61,79.82 88.61,83.72 88.3,84.03 88.3,91.71 88.87,92.28 88.87,94 89.31,94.44 v1(89.63,94.44)
  BOTTOM w0.508: v1(89.63,94.44) 89.21,94.44 88.68,94.98 86.96,94.98 86.16,95.77 84.46,95.77 84.08,96.16 84.08,97.95 83.44,98.58 83.43,98.58 82.64,98.58 82.64,98.58 82.56,98.58 82.33,98.35 U6901.4
  vias: v1(89.86,79.27)
1V8_MAIN: length 14
  TOP w0.508: v1(70.94,95.91) 70.22,96.63 PR10519.1
  BOTTOM w0.254: v1(75.56,93.95) 75.71,94.1 R6807.2 76.12,94.69 76.27,94.54 Q6900.2
  BOTTOM w0.381: Q6900.5 78.08,94.54 77.98,94.64 77.21,94.64 77.11,94.54 Q6900.2 ; R6615.2 80.21,63.58 80.59,63.96 v1(80.77,63.96)
  BOTTOM w0.508: v1(70.94,95.91) 67.23,95.91 65.5,94.18 64.15,94.18 L6600.1
  vias: v1(61.52,64.82) v1(61.54,64.18) v1(73.23,71.01) v1(73.34,72.34) v1(73.84,71.78) v1(78.26,75.16) v1(79.1,75.67) v2(63.31,70.99) v2(64.13,71.03) v2(64.91,71.03) v2(65.75,71.11) v2(66.57,71.04) v2(69.07,71.83) v2(69.87,71.83) v2(70.48,71.8)
1V8_MAIN_EN: length 156
  TOP w0.109: PQ10501.2 68.88,99.41 69.01,99.29 69.01,98.88 69.75,98.14 70.69,98.14 v1(71.22,97.61) ; v1(81.6,85.9) 80.94,85.9 80.34,85.29 78.81,85.29 78.05,84.53 76.27,84.53 75.26,85.54 73.35,85.54 72.97,85.16 72.97,84.78 72.57,84.38 v1(72.38,84.38) ; v1(85.85,83.23) 86.43,82.65 86.43,82.4 87.4,81.43 87.85,81.43 89.42,79.86 90.01,79.86 90.81,79.06 91.48,79.06 91.95,78.6 91.95,78.46 92.49,77.92 92.49,76.75 92.4,76.66 92.4,72.04 PR10517.1 ; v1(37.03,99.77) 37.49,99.31 39.9,99.31 v1(40.13,99.54) 40.69,100.1 40.69,100.96 40.59,101.06 40.59,103.99 40.41,104.42 40.41,104.64 39.95,105.74 38.84,106.85 PR9817.1
  IN2 w0.089: v1(65.96,60.38) 66.01,60.38 71.98,66.34 71.98,70.63 72.11,70.76 72.68,70.76 72.82,70.62 75.23,70.62 80.06,75.44 80.06,81.28 80.85,82.07 80.85,84.78 81.6,85.53 v1(81.6,85.9) 80.62,86.87 80.62,89.25 80.01,89.86 80.01,96.04 77.95,98.09 71.7,98.09 v1(71.22,97.61) 70.91,97.61 70.43,98.09 57.68,98.09 56.26,96.67 53.87,96.67 53.46,97.08 41.25,97.08 40.03,98.3 38.89,98.3 37.87,99.31 37.49,99.31 v1(37.03,99.77)
  BOTTOM w0.109: v1(37.03,99.77) 36.32,99.77 35.94,100.15 35.94,102.43 PD9800.1 34.31,103.42 33.88,102.99 PR9833.1 33.07,102.99 32.83,103.23 PD9801.2 ; R6958.1 84.8,86.7 84.13,86.7 83.81,86.38 82.88,86.38 R6960.1 v1(81.6,85.9) 81.6,85.71 81.91,85.39 81.91,83.96 D6901.3 84.96,83 85.19,83.23 v1(85.85,83.23) ; v1(65.96,60.38) 66.24,60.66 PR10508.2 ; U6600.F9 v1(72.38,84.38)
1V8A_PG: length 200.7
  IN1 w0.079: v1(171.85,48.61) 171.73,48.49 169.64,48.49 168.79,47.64 168.79,47.46 168.2,46.86 166.65,46.86 166.27,46.48 165.71,46.48 v1(165.53,46.66) ; v1(128.01,104.77) 128.01,104.29 128.66,103.64 131.35,103.64 131.79,103.2 132.2,103.2 133.64,104.64 143.41,104.64 144.65,103.4 145.51,103.4 145.67,103.25 145.67,102.87 146.28,102.26 149.64,102.26 151.25,100.66 153.29,100.66 154,99.95 165.44,99.95 v2(166.13,99.26)
  IN2 w0.089: v2(166.13,99.26) 165.86,99 165.86,94.54 166.42,93.98 166.42,91.39 165.98,90.95 165.98,89.36 167.1,88.24 167.1,87.35 166.85,87.09 166.62,87.09 166.29,86.76 166.29,85.45 166.6,85.14 167.84,85.14 168.02,84.96 168.02,83.29 169.85,81.47 169.85,80.48 169.58,80.21 169.58,79.46 169.43,79.31 169.43,75.81 171.37,73.87 171.37,70.27 171.1,70 171.1,69.28 171.95,68.43 171.95,66.11 170.74,64.9 170.74,64.31 172.45,62.6 172.45,59.47 172.67,59.26 172.67,56.97 172.16,56.46 172.16,55.45 171.85,55.14 171.85,51.56 172.06,51.36 172.06,50.24 171.85,50.04 v1(171.85,48.61)
  IN3 w0.089: v1(165.53,46.66) 165.86,46.66 166.6,45.92 166.6,45.41 168.27,43.74 168.27,41.65 170.05,39.87 170.88,39.87 172.26,38.49 172.26,36.93 174.9,34.29 174.9,31.85 177.77,28.98 177.77,27.67 178.84,26.6 178.84,24.91 178.32,24.39 178.32,21.13 177.5,20.31 176.52,20.31 175.63,19.43 165.65,19.43 163.68,17.46 163.18,17.46 162.45,16.73 157.08,16.73 155.52,18.29 142.11,18.29 141.52,17.69 140.98,17.69 140.66,18.01 140.66,18.02 140.2,18.48 136.46,18.48 135.65,17.67 135.15,17.67 134.8,18.02 134.8,18.38 134.54,18.63 124.16,18.63 v1(123.51,17.98)
  BOTTOM w0.109: v1(128.01,104.77) 127.71,105.08 PR9121.1 PR9114.1 ; v1(123.51,17.98) 123.43,18.05 PR9206.2 122.58,18.05 122.57,18.06 PR8107.2
2V5_PG: length 201.5
  TOP w0.109: R3304.2 18.31,44.67 18.24,44.6 R3302.2 18.24,43.98 R3303.2 18.77,43.61 19.05,43.33 19.05,42.54 v1(18.58,42.08) ; v1(35.68,27.96) 35.68,30.74 37.03,32.09 37.03,36.2 34.85,38.38 34.85,41.76 33.97,42.63 v1(33.97,44.74)
  IN1 w0.079: v1(18.58,42.08) 18.81,41.85 23.42,41.85 25.42,43.84 27.95,43.84 29.1,44.99 33.52,44.99 33.77,44.74 v1(33.97,44.74)
  BOTTOM w0.109: v1(35.68,27.96) 36.88,29.16 37.59,29.16 39.42,30.99 102.11,30.99 102.97,30.12 119.93,30.12 124.25,34.45 152.19,34.45 153.64,32.99 153.64,23.07 154.02,22.69 154.02,21.16 154.28,20.9 154.28,19.38 154.48,19.18 178.3,19.18 178.73,18.76 178.73,18.07 178.28,17.62 PR8716.2
3V3_VCCST_OVERRIDE: length 46.3
  TOP w0.109: PD9600.1 143.05,93.44 143.74,93.44 144.07,93.77 144.07,96.24 143.63,96.67 143.2,96.67 PD9603.2 143.08,97.42 143.15,97.35 144.86,97.35 144.88,97.33 145.92,97.33 146.06,97.19 PU10602.1 145.37,97.04 145.01,96.68 145.01,95.8 145.34,95.48 148.08,95.48 v1(148.48,95.07) 148.86,94.7 150.46,94.7 150.73,94.43 155.82,94.43 158.03,92.22 158.03,91.45 158.57,90.91 158.57,88.56 159.41,87.73 160.02,87.73 160.18,87.57 PU10605.2 160.18,86.53 159.52,85.87 159.11,85.87 158.32,85.08 v1(158.32,84.71)
  BOTTOM w0.109: v1(158.32,84.71) 157.88,84.27 157.88,81.77 158.19,81.47 158.19,79.52 158.63,79.08 PQ10603.3 158.63,78.48 157.45,77.3 157.45,76.24 PR10618.1
3V3DS_PG_R: length 3.2
  BOTTOM w0.109: PR8125.1 PR8126.1 186.24,11.43 PC8109.1 186.98,11.93 187.37,12.32 PU8102.2
3V_5V_PG: length 55.6
  TOP w0.109: v1(163.45,18.03) 163.82,17.66 163.82,15.55 164.3,15.07 164.3,12.56 164.72,12.14 167.36,12.14 167.69,11.81 v1(168.88,11.81)
  IN1 w0.079: v1(183.74,12.32) 183.74,11.96 182.96,11.17 180.39,11.17 178.49,9.28 172.73,9.28 172.68,9.33 171.49,9.33 169.7,11.12 169.57,11.12 v1(168.88,11.81)
  IN3 w0.089: v1(141.14,18.08) 141.53,18.46 155.6,18.46 157.15,16.91 162.32,16.91 v1(163.45,18.03)
  BOTTOM w0.109: PR8617.1 169.13,11.1 168.88,11.35 v1(168.88,11.81) ; v1(141.14,18.08) 141.13,18.07 140.73,18.07 140.42,17.77 PR8600.1 ; PR8125.2 185,12.28 184.55,11.83 184.22,11.83 v1(183.74,12.32)
+1.2V_CR: length 20.9
  TOP w0.203: 173.45,41.46 173.95,40.95 U7600.10 ; U7600.14 174.87,39.35 174.68,39.16
  TOP w0.381: 169.87,37.56 169.87,37.56 170.65,36.79 C7614.1 172.86,36.79 v1(173.5,37.43) 173.7,37.63 173.7,38.77 174.09,39.16 174.68,39.16
  TOP w0.508: 169.87,37.56 167.98,39.45 167.98,40.23 168.38,40.64 C7613.2 169.14,40.8 169.14,41.67 169.9,42.44 172.18,42.44 C7610.1 172.53,42.09 172.53,41.74 172.81,41.46 173.45,41.46
+1.2VSUS: length 203.7
  TOP w0.254: v1(62.22,22.79) 62.19,22.81 R2912.1 R2908.1 ; v1(158.17,22.07) 158.16,22.09 R2811.2 ; R2901.1 73.24,21.52 v1(73.21,21.49) ; 145.95,47.83 147.98,49.86 152.64,49.86 153.43,50.65 153.43,52.53 153.02,52.94 153.02,53.95 R509.1 ; U1903.D1 U1903.D2 109.68,16.2 109.77,16.3 C1909.2 109.77,17.09 110.87,18.18 113.28,18.18 v1(113.71,18.62) ; R2916.2 112.47,24.48
  TOP w0.381: C2903.1 52.78,21.45 v1(52.72,21.51) ; C2815.1 162.76,21.45 v1(162.68,21.54) ; v1(147.17,21.51) 146.62,21.51 C2811.1 146.22,21.49 v1(145.68,21.49) ; v1(96.22,21.5) 96.24,21.48 C2912.1 ; C2901.1 57.68,24.47 57.57,24.36 v1(56.97,24.36) ; 115.87,63.01 v2(116.47,62.41) ; C2803.1 148.57,25.2 v1(147.9,25.2) ; C2918.1 70.6,21.52 v1(70.21,21.52) ; v1(71.72,21.54) 71.72,21.53 C2921.1 ; v1(144.23,21.52) 144.69,21.52 C2802.1 ; v1(72.21,25.89) 72.25,25.84 C2916.1 ; v1(151.48,21.53) 151,21.53 C2809.1 ; v1(41.72,22.15) 41.82,22.26 42.39,22.26 C2905.1 ; C2907.1 90.05,24.47 v1(90.02,24.51)
  BOTTOM w0.203: U400.CG40 130.78,68.72 ; U400.CG40 130.21,68.72 ; U400.CG40 130.49,69.01 ; U400.CC40 128.95,68.72 ; U400.CC40 128.38,68.72 ; U400.CC40 128.66,69.01 ; 132.04,68.72 U400.CL40 ; U400.CL40 132.61,68.72 ; U400.CL40 132.32,69.01 ; U400.AB40 110.36,69.01 ; U400.AB40 110.65,68.72 ; U400.AB40 110.08,68.72 ; U400.AK40 114.31,68.72 ; U400.AK40 114.02,69.01 ; U400.AK40 113.74,68.72 ; 130.67,69.19 U400.CH39 ; U400.CH39 130.95,69.47 ; U400.CH39 130.95,68.9 ; U400.CE40 129.86,68.72 ; U400.CE40 129.3,68.72 ; U400.CE40 129.58,69.01 ; 116.49,68.72 U400.AU40 117.05,68.72 ; U400.BV51 U400.BV52 126.45,62.98 v2(126.45,62.71) ; U400.BK51 U400.BK52 122.79,62.74 122.77,62.72 v2(122.77,62.71) ; 127.75,69.01 U400.CA40 128.03,68.72 ; U400.AH40 113.11,69.01 ; U400.AH40 113.39,68.72 ; U400.AH40 112.83,68.72 ; U400.AG39 112.93,69.19 ; U400.AG39 112.65,68.9 ; U400.AG39 112.65,69.47 ; U400.AG39 112.37,69.19 ; U400.AF40 112.48,68.72 ; U400.AF40 112.19,69.01 ; U400.AF40 111.91,68.72 ; 131.69,68.72 U400.CJ40 131.13,68.72 ; 114.66,68.72 U400.AM40 ; U400.AM40 115.22,68.72 ; U400.AM40 114.94,69.01 ; U400.AP40 116.14,68.72 ; U400.AP40 115.85,69.01 ; U400.AP40 115.57,68.72 ; U400.AR39 116.31,69.47 ; U400.AR39 116.03,69.19 ; U400.AR39 116.31,68.9 ; 111,68.72 U400.AD40 ; U400.AD40 111.28,69.01 ; U400.AD40 111.56,68.72 ; U400.BD52 U400.BD51 v2(120.24,64.29) ; 113.28,69.19 U400.AJ39 ; U400.AJ39 113.57,68.9 ; U400.AJ39 113.85,69.19 ; U400.AJ39 113.57,69.47 ; 111.45,69.19 U400.AE39 ; U400.AE39 111.74,68.9 ; U400.AE39 111.74,69.47 ; U400.AE39 112.02,69.19 ; JDIM2900.96 63.22,22 62.42,22.79 62.22,22.79 v1(62.22,22.79) ; v2(111.24,64.29) U400.AD51 U400.AD52 ; 109.91,68.9 U400.AA39 ; U400.AA39 109.91,69.47 ; U400.AA39 110.19,69.19 ; U400.AL39 114.76,69.19 ; U400.AL39 114.2,69.19 ; U400.AL39 114.48,68.9 ; U400.AL39 114.48,69.47 ; U400.AN39 115.68,69.19 ; U400.AN39 115.4,69.47 ; U400.AN39 115.4,68.9 ; U400.AN39 115.11,69.19 ; 110.54,69.19 U400.AC39 ; U400.AC39 111.1,69.19 ; U400.AC39 110.82,68.9 ; U400.AC39 110.82,69.47 ; U400.T51 U400.T52 107.34,63.07 107.34,62.3 107.24,62.21 v2(107.24,62.21) ; v2(113.79,64.29) U400.AK51 U400.AK52 ; v2(117.69,64.29) U400.AW51 U400.AW52 ; U400.CR40 133.81,68.72 ; v2(116.47,62.41) 116.47,63.03 U400.AT52 ; U400.CN40 133.52,68.72 ; U400.CN40 132.96,68.72 ; U400.CN40 133.24,69.01
  BOTTOM w0.254: JDIM2800.33 124.42,25.24 125.12,24.55 v1(125.42,24.55) ; v1(56.97,24.36) 57.04,24.36 57.97,25.29 JDIM2900.75 ; JDIM2800.96 140.17,22.54 140.47,22.84 v1(140.68,22.84) ; v2(133.25,66.08) 133.27,66.08 U400.CP47 ; v1(156.17,22.14) 156.3,22.14 156.68,21.77 JDIM2800.154 ; v1(147.17,21.51) JDIM2800.124 ; v1(162.68,21.54) JDIM2800.178 ; JDIM2800.148 155.17,21.19 v1(154.84,21.52) ; JDIM2900.141 74.47,26.67 v1(74.53,26.61) ; v1(48.46,24.55) 48.16,24.55 47.46,25.24 JDIM2900.33 ; JDIM2800.129 148.43,26.8 148.09,26.47 v1(147.9,26.47) ; v1(90.02,24.51) 90.14,24.51 90.97,25.33 JDIM2900.199 ; JDIM2900.142 v1(74.72,21.54) ; JDIM2900.154 79.72,21.49 v1(79.78,21.55) ; JDIM2800.153 156.43,26.49 156.99,25.93 v1(156.99,25.79) ; v1(82.24,26.59) 81.97,26.87 JDIM2900.163 ; JDIM2900.129 71.47,27.27 71.43,27.23 71.43,26.63 71.12,26.33 v1(70.94,26.33) ; v1(129.68,21.59) JDIM2800.54 ; v2(102.49,64.44) 102.42,64.44 U400.D50 ; v2(102.49,64.44) 102.65,64.27 U400.E51 ; v2(102.49,64.44) 103.06,64.44 U400.F49 ; JDIM2900.147 77.97,25.58 v1(78.47,25.07) ; v1(145.92,29.74) 145.81,29.74 145.43,29.35 JDIM2800.117 ; v1(71.72,21.54) JDIM2900.130 ; v1(72.21,25.89) 72.46,25.89 72.97,26.39 JDIM2900.135 ; JDIM2800.130 148.68,22.37 149.09,22.78 v1(149.27,22.78) 149.38,22.78 149.98,22.17 149.98,21.4 150.17,21.21 JDIM2800.136 ; JDIM2900.117 68.47,24.39 v1(69.93,22.92) ; v1(145.48,30.22) 144.99,30.22 144.71,29.94 144.35,29.94 143.93,29.52 JDIM2800.111 ; v1(73.21,21.49) JDIM2900.136 ; v1(66.72,22.3) 67.22,21.81 JDIM2900.112 ; JDIM2800.141 151.43,27.04 v1(151.03,26.65) ; JDIM2900.12 42.22,21.73 41.79,22.15 v1(41.72,22.15) ; v1(81.21,22.62) 81.74,22.1 81.74,21.68 81.21,21.16 JDIM2900.160 ; v1(168.43,26.48) 168.32,26.48 167.92,26.88 JDIM2800.199 ; JDIM2900.111 66.97,27.24 v1(67.08,27.12) ; JDIM2900.241 101.47,26.82 101.82,26.46 v1(101.96,26.46) ; v1(79.47,26.01) JDIM2900.153 ; v1(133.93,24.57) 134.1,24.57 134.93,25.39 JDIM2800.75 ; v1(144.23,21.52) 144.17,21.47 JDIM2800.112 ; v1(68.73,21.63) 68.72,21.61 JDIM2900.118 ; JDIM2800.147 154.93,27.38 154.85,27.31 154.85,26.47 155.54,25.77 v1(155.69,25.77) ; v1(70.94,25.06) 70.79,25.06 69.97,25.88 JDIM2900.123 ; v1(85.72,21.54) JDIM2900.178 ; JDIM2800.135 149.93,29.53 150.18,29.78 v1(151.15,29.78) ; v1(81.61,25.91) 80.97,26.55 JDIM2900.159 ; v1(77.39,21.73) 77.8,21.73 78.21,21.32 JDIM2900.148 ; JDIM2800.12 119.18,21.81 118.75,22.23 v1(118.68,22.23) ; JDIM2800.160 v1(158.17,22.07) ; U400.CC49 128.69,64.59 v2(128.97,64.32) 128.59,63.94 U400.CC50 ; v1(145.68,21.49) JDIM2800.118 ; JDIM2800.142 151.68,21.33 v1(151.48,21.53) ; JDIM2800.123 146.93,26.03 147.76,25.2 v1(147.9,25.2) ; JDIM2900.124 v1(70.21,21.52) ; v1(173.18,21.5) JDIM2800.220 ; v1(52.72,21.51) JDIM2900.54 ; JDIM2800.241 178.43,27.4 177.92,26.9 177.92,25.67 178.36,25.24 v1(178.45,25.24) ; JDIM2800.159 157.93,26.7 158.3,26.33 v1(158.43,26.33) 158.61,26.33 158.93,26.64 JDIM2800.163 ; v1(96.22,21.5) JDIM2900.220
  vias: v1(74.5,38.66) v1(114.7,26.48) v1(114.88,29.02) v1(114.88,28.38) v1(114.88,27.75) v1(114.88,27.11) v1(115.34,26.48) v1(115.52,29.02) v1(115.52,28.38) v1(115.52,27.75) v1(115.52,27.11) v2(109.87,69.65) v2(110.35,69.37) v2(110.81,69.68) v2(111.26,69.37) v2(111.72,69.68) v2(112.2,69.37) v2(112.66,69.68) v2(113.12,69.37) v2(113.57,69.68) v2(114.03,69.37) v2(114.5,69.69) v2(114.95,69.37) v2(115.4,69.68) v2(115.86,69.37) v2(116.32,69.68) v2(117.44,69.7) v2(127.72,69.37) v2(128.23,69.75) v2(128.64,69.37) v2(129.12,69.75) v2(129.6,69.37) v2(130.01,69.75) v2(130.52,69.37) v2(130.92,69.75) v2(131.81,69.75) v2(132.29,69.37) v2(132.7,69.75) v2(133.19,69.5)
+1.2VSUS_S:
  vias: v1(107.26,16.24) v1(107.26,15.6) v1(107.26,14.97) v1(107.26,14.33) v1(107.9,16.24) v1(107.9,15.6) v1(107.9,14.97) v1(107.9,14.33) v1(108.66,16.81)
+1.05V_GFX_S2:
  vias: v1(59.79,59.56)
+1.8V: length 300.9
  TOP w0.203: v1(198.87,40.13) 198.87,39.91 198.28,39.32 U3600.29
  TOP w0.254: v1(199.33,40.59) v1(198.87,40.13)
  TOP w0.508: v1(180.52,56.59) 180.87,56.59 181.63,57.35 183.06,57.35 183.9,56.51 v1(184.55,56.51) ; v1(181.64,70.5) 181.64,71.16 v1(180.45,72.35) 179.84,72.35 179.65,72.16 PR9509.2 178.63,72.52 177.73,73.42 176.81,73.42 175.66,74.57 175.41,74.67 174.3,74.67 173.87,75.11 169.17,75.11 168.2,76.08 167.4,76.08 166.47,77.01 166.47,78.53 166.02,78.97 164.1,78.97 163.17,79.9 162.91,79.9 162.42,80.39 161.8,80.39 161.41,80 159.58,80 157.57,77.99 156.93,77.99 156.67,77.73 153.85,77.73 153.29,77.16 151.84,77.16 151.2,77.8 151.2,77.82 151.09,77.93 151.09,78.57 151.31,78.79 151.31,79.86 151.1,80.06 v2(150.77,80.06)
  IN1 w0.254: v1(198.87,40.13) 198.8,40.13 197.57,38.9 194.87,38.9 194.07,39.7 194.07,41.6 193.29,42.38 193.29,43.28 194.87,44.85 v1(198.96,44.85)
  IN1 w0.508: v1(184.55,56.51) 185.6,56.51 186.97,55.14 186.97,54.46 189.15,52.27 190.88,52.27 191.91,53.3 192.73,53.3 193.01,53.58 194.81,53.58 195.34,54.12 200.86,54.12 201.06,53.91 v1(201.57,53.91) ; v1(180.52,56.59) 180.37,56.73 177.73,56.73 177.73,56.74 177.66,56.67 ; v1(150.41,49.11) 151.01,48.52 152.47,48.52 153.11,47.88 155.88,47.88 155.95,47.8 156.98,47.8 158.01,48.83 158.01,48.87 159.61,50.47 159.61,51.23 160.2,51.81 160.2,52.46 160.81,53.07 162.05,53.07 163.9,54.92 171.35,54.92 171.98,55.54 172.82,55.54 173.15,55.86 173.99,55.86
  IN2 w0.508: v1(80.65,97.62) 81.29,98.26 82.53,98.26 83.56,99.3 87.92,99.3 88.98,98.24 88.98,97.92 90.5,96.4 90.5,92.25 89.1,90.85 89.1,86.33 89.55,85.89 89.55,85.3 89.24,85 89.24,78.77 86.34,75.87 86.34,72.98 80.53,67.18 80.53,65.08 77.66,62.2 74.09,62.2 73.51,61.62 73.51,58.77 v1(66.14,51.41) ; v1(181.64,70.5) 181.43,70.29 181.43,69.26 181.18,69.01 181.18,68.27 179.86,66.95 179.86,65.92 178.55,64.61 178.55,63.76 179.47,62.83 179.47,60.91 180.03,60.36 180.3,60.36 180.8,59.86 180.8,58.82 180.9,58.72 180.9,58.07 180.52,57.68 v1(180.52,56.59)
  IN3 w0.508: v1(201.57,53.91) 201.12,53.46 201.12,52.76 200.25,51.9 200.25,45.51 v1(199.59,44.85)
  BOTTOM w0.508: v1(66.14,51.41) 73.87,51.41 76.54,54.08 78.99,54.08 80.33,52.74 106.33,52.74 109.12,55.52 113.26,55.52 113.9,54.88 114.7,54.34 115.52,54.34 120.2,49.67 149.59,49.67 150.15,49.11 v1(150.41,49.11) ; v1(80.65,97.62) 80.72,97.69 U6901.5
+1.8V_AVDD: length 2
  TOP w0.203: C3608.1 197,41.98 196.15,41.12 U3600.33
  vias: v1(198.68,42.87)
+1.8V_DEEP_SUS: length 435.5
  TOP w0.109: 173.91,65.71 174.06,65.86
  TOP w0.203: R1609.2 135.36,74.49 135.65,74.78 135.65,75.43 135.51,75.57 135.51,76.74 135.82,77.05 C1610.2
  TOP w0.254: v2(136.65,77.18) 136.65,77.13 136.57,77.05 C1610.2 ; R1241.1 137.28,77.88 137.3,77.87 v2(137.3,77.82) ; R1227.1 140.44,76.71 140.23,76.5 138.66,76.5 ; R1520.2 189.53,8.22 v1(189.14,7.83) ; R1612.1 135.99,68.96 135.92,69.03 R1611.1 135.92,69.44 135.71,69.65 v2(135.71,69.78)
  TOP w0.381: v1(170.64,83) 170.64,82.88 172.14,81.37 179.16,81.37 v1(179.73,81.94) ; R1231.2 153.74,82.17 153.62,82.04 v1(153.62,81.68) 153.59,81.66 R1400.1 ; 89.91,63.93 90.42,64.43
  TOP w0.508: v1(186.23,58.9) 186.2,58.93 186.2,65.05 185.79,65.45 181.27,65.45 180.55,66.17 178.4,66.17 ; 93.83,65.66 94.82,65.66 95.94,64.53 ; v1(180.57,8.18) 179.58,8.18 178.38,9.37 178.38,9.93 177.54,10.77 175.72,10.77 175.31,11.17 175.31,11.99 176.32,13 176.32,16.18 v1(175.51,16.99) ; v1(197.99,9.5) 197.76,9.72 R4725.1
  TOP w0.889: 91.18,65.48 89.25,65.48
  TOP w2.032: 87.55,58.14 87.55,55.32 86.21,53.97 85.29,53.97 74.57,43.25 70.33,43.25 69.39,44.19 67.26,44.19
  IN1 w0.508: v1(187.81,50.57) 187.81,49.68 188.27,49.22 189.03,49.22 189.48,48.77 189.48,48.26 189.58,48.16 191.36,48.16 191.84,48.64 199.98,48.64 v1(200.91,49.57)
  IN2 w0.178: 150.92,71.14 151.28,71.5 151.81,71.5 151.93,71.61 151.93,72.42
  IN2 w0.381: 150.92,71.14 v2(150.52,70.73) ; v1(180.92,83.18) 180.92,82.81 180.05,81.94 v1(179.73,81.94) ; v2(152.18,73.53) 152.18,72.68 151.93,72.42
  IN2 w0.508: v1(115.91,13.74) 115.91,13.74 116.31,14.14 118.15,14.14 119.66,15.64 123.77,15.64 124.86,16.74 124.86,17.96 125.17,18.26 130.48,18.26 131.1,17.64 137.17,17.64 137.43,17.38 139.03,17.38 139.19,17.22 141.15,17.22 142.38,18.45 155.83,18.45 156.87,17.41 164.4,17.41 165.52,18.53 169.3,18.53 v1(169.55,18.27) ; v1(186.23,58.9) 185.84,58.51 185.84,56.03 186.76,55.11 186.76,51.74 187.81,50.7 v1(187.81,50.57)
  IN2 w2.032: 38.86,20.14 59.05,20.14 59.94,19.25 70.38,19.25 70.58,19.05 73.96,19.05 ; 47.45,40.23 44.57,37.36 44.57,35.79 37.02,28.23
  IN3 w0.254: v1(197.99,9.5) 198.16,9.66 198.84,9.66 199.13,9.95 200.76,9.95 201.65,9.07 202.54,9.07 204.24,10.77 206.18,10.77 206.6,11.19 v2(207.41,11.19)
  IN3 w0.508: 172.19,43.43 171.47,44.15 169.81,44.15 168.59,45.37 168.59,47.35 v1(167.84,48.1) ; v1(169.55,18.27) 172.81,18.27 174.09,16.99 v1(175.51,16.99) 176.15,16.99 176.63,17.47 178.33,17.47 179.07,18.21 179.07,19.11 180.37,20.41 181.29,20.41 182.38,21.51 182.38,22.79 181.23,23.95 181.23,28.44 181.47,28.69 181.47,29.6 181.26,29.81 ; v1(115.91,13.74) 116.69,12.96 116.69,12.34 115.68,11.33 114.56,11.33 114.15,11.5 113.59,11.61 112.39,11.61 111.75,10.97 111.17,10.97 110.22,10.02 109.94,10.02 108.38,8.46 106.09,8.46 105.84,8.71 104.32,8.71 103.48,9.55 99.72,9.55 98.78,10.49 96.42,10.49 95.65,11.25 93.32,11.25 93.2,11.13 86.26,11.13 85.61,10.47 74.44,10.47 74.24,10.27 61.19,10.27 60.09,9.17 60.09,8.41 59.36,7.67 54.77,7.67 53.86,8.58 52.58,9.11 51.51,9.11 50.93,8.53 50.15,8.53 49.63,8.01 46.74,8.01 45.97,7.23 43.18,7.23 42.72,7.69 39.86,7.69 39.49,7.33 34.46,7.33 33.38,6.25 30.47,6.25 30.12,6.6 27.47,6.6 26.65,7.42 26.02,7.68 22.15,7.68 21.52,8.31 20.61,8.31 20.14,8.78 17.19,8.78 15.57,10.4 15.57,13.71 v1(15.36,13.92) ; v1(197.99,9.5) 197.47,8.97 191.37,8.97 190.31,7.91 189.22,7.91 v1(189.14,7.83) 189.07,7.83 187.82,9.09 184.52,9.09 184.21,8.77 181.53,8.77 180.93,8.18 v1(180.57,8.18) ; 173.78,41.41 175.26,39.94 175.26,37.62 175.71,37.17 175.71,36.72 178.1,34.33 178.1,33.21 180.39,30.92
  BOTTOM w0.203: 136.97,77.21 U400.DA20 ; U400.DA20 136.97,77.8 ; U400.DA20 136.68,77.51 ; U400.DA20 137.27,77.51 ; U400.CY20 136.62,77.51 ; U400.CY20 136.32,77.8 ; U400.CY20 136.03,77.51 ; U400.CY20 136.32,77.21 ; 136.62,75.02 U400.CY26 136.03,75.02 ; v2(145.18,76.52) 145.12,76.59 144.66,76.59 U400.DV22 ; 136.68,75.02 U400.DA26 ; U400.DA26 137.27,75.02 ; U400.DA26 136.97,75.31 ; U400.DA18 137.27,78.34 ; U400.DA18 136.97,78.63 ; U400.DA18 136.68,78.34 ; U400.DA18 136.97,78.04 ; U400.DA24 137.27,75.85 ; U400.DA24 136.97,75.55 ; U400.DA24 136.68,75.85 ; 136.32,78.04 U400.CY18 ; U400.CY18 136.03,78.34 ; U400.CY18 136.62,78.34 ; 136.62,75.85 U400.CY24 136.03,75.85 ; 137.27,76.68 U400.DA22 136.97,76.97
  BOTTOM w0.254: v2(150.72,79.47) 150.59,79.6 R1143.1 ; PR8104.1 209.27,10.99 R7711.1 209.08,10.99 208.71,11.36 207.59,11.36 v2(207.41,11.19) ; v2(135.71,69.78) 135.53,69.61 U400.CV39 ; R1601.2 153.63,82.93 150.85,82.93 150.33,82.41 150.33,81.45 R1136.1 ; v1(180.92,83.18) 180.92,83.06 180.92,83.05 R4144.1
  BOTTOM w0.381: v1(153.62,81.68) 153.62,81.9 R1601.2 ; R4141.2 179.7,81.66 179.73,81.68 v1(179.73,81.94)
  BOTTOM w0.508: v1(200.91,49.57) 201.08,49.41 F4200.2
  vias: v1(13.49,14.09) v1(63.47,44.8) v1(64.16,44.8) v1(64.84,44.8) v1(75.56,18.29) v1(76.22,18.29) v1(76.88,18.29) v1(132.03,16.1) v1(132.36,15.57) v1(132.61,16.36) v1(132.94,15.82) v1(169.88,70.99) v1(170.18,71.53) v1(170.27,70.51) v1(173.51,66.52) v1(174.05,66.19) v1(177.06,66.34) v1(177.71,66.31) v2(136.65,77.82) v2(136.65,75.46) v2(137.25,75.46) v2(137.3,77.18) v2(137.3,76.27) v2(137.85,75.43) v2(137.95,77.82) v2(137.93,77.18) v2(137.92,76.27)
+1.8V_DEEP_SUS_R: length 1.8
  TOP w0.254: C1918.1 170.53,72.43 170.24,72.15 170.09,72.15 U1907.D3
  vias: v1(172.13,72.13)
+1.8V_R: length 53.4
  IN2 w0.254: v1(191.01,48.82) 191.01,48.66 190.6,48.26 190.6,46.15 190.88,45.87 190.88,41.98 191.89,40.97 191.89,39.62 193.12,38.4 196.93,38.4 197.11,38.57 198.37,38.57 199.19,39.39 199.94,39.39 v1(201.17,40.61)
  IN3 w0.254: v1(191.01,48.82) 191.84,49.65 191.84,52.8 189.05,55.6 187.76,55.6 186.38,56.98 186.38,58.06 185.69,58.76 185.69,59.12 185.83,59.26 185.83,60.67 185.69,60.81 185.69,61.54 182.81,64.42 181.28,64.42 180.41,65.29 179.54,65.29 177.11,67.72 177.11,70.27 v1(177.19,70.35)
  BOTTOM w0.254: U1801.D3 200.6,41.2 200.58,41.22 C1804.1 200.94,41.53 201.17,41.3 v1(201.17,40.61)
  vias: v1(177.37,71.19)
+1.8VPCU_R:
  vias: v1(128.83,14.25) v1(128.83,13.61) v1(129.16,15.09) v1(129.46,14.25) v1(129.46,13.61)
+1.8VPCU_TUNE: length 11.6
  BOTTOM w0.508: F4200.1 202.57,47.21 203.3,46.48 C4215.2 C4217.2 C4216.2 200.83,45.9 200.48,46.25 197.84,46.25 197.13,45.54 195.2,45.54 194.64,44.98 CON4203.1
+2.5VSUS: length 32.8
  TOP w1.524: 180.26,20.37 171.7,20.37
  IN2 w1.524: 120.31,19.96 144.5,19.96
  vias: v1(106.55,28.88) v1(106.55,28.24) v1(107.24,28.55) v1(170.97,21.56) v1(170.99,22.2) v1(171.4,22.68) v1(183.21,27.13) v1(183.21,26.49)
+2.5VSUS_S: length 3.8
  TOP w0.254: U1809.D3 184.34,28.92 184.67,28.59 C1819.1 185.12,27.92 185.12,27.39 PR8717.2
  vias: v1(186.1,27.51) v1(186.33,26.92)
+3.3V_8270C: length 3.4
  BOTTOM w0.203: PC8618.1 165.22,9.5 165.22,10.42 165.39,10.8 165.39,12.12 165.59,12.33 PU8601.10
+3V: length 414.5
  TOP w0.178: 201.55,61.87 200.85,61.17 200.85,61.12 200.23,60.5 200.18,60.5 200.06,60.38 U3501.30
  TOP w0.203: PR9803.1 PR9800.1 33.48,105.84 33.73,105.59 v1(33.81,105.59) ; C3529.1 201.55,61.87 ; R1404.2 154.09,72.96 R1523.1 ; R1404.2 R1525.1 ; R1404.2 154.09,72.11 153.89,71.91 v2(153.89,71.72) ; v1(17.22,54.25) 17.24,54.23 R4308.2 ; v1(191.62,36.92) U3600.8
  TOP w0.254: v1(106.65,18.57) 106.65,18.06 106.81,17.9 R2903.1 106.3,17.45 R2902.1 ; v1(146.02,54.35) 145.68,54.01 145.1,54.01 144.61,53.53 142.76,53.53 139.36,56.93 v1(139.36,58.18) 138.79,58.18 138.58,57.96 138.15,57.96 137.82,58.29 R627.2 137.82,58.86 R1220.1 ; v1(32.08,32.43) 32.08,32.68 R3421.1 ; 30.27,7.81 31.66,6.42 33.43,6.42 34.95,7.95 R5218.2 ; v2(151.76,80.73) 151.76,80.74 151.53,80.97 R1119.1 ; R625.2 R1119.1 ; R1119.1 151.46,81.26 151.11,80.9 R1526.1 ; v1(160.14,22.86) 160.32,23.03 R2814.2 ; v1(197.43,31.87) 197.35,31.79 196.88,31.79 R3608.1 ; v2(149.68,74.93) 149.38,75.23 R1407.2 ; R5127.1 169.75,63.63 ; v1(42.75,10.51) 42.2,11.06 R5216.2 41.98,11.72 R5215.1 ; R2904.1 83.97,22.3 v1(83.67,22.6) ; v1(182.17,30.31) 182.94,29.54 184.3,29.54 184.62,29.21 185.74,29.21 187.71,27.24 187.71,26.6 187.57,26.46 186.94,26.46 186.41,25.93 186.26,25.93 185.8,25.47 R2812.2 185.8,24.86 R2813.2 ; C5412.1 183.81,10.83 v1(183.72,10.74)
  TOP w0.381: v1(39.52,102.74) 39.3,102.74 38.92,102.36 PR9819.1 ; R3425.1 24.71,50.82 v1(26.67,52.78) ; v2(154.01,76.77) 154.01,76.92 154.26,77.17 155.29,77.17 v2(155.55,76.91)
  TOP w0.508: Q4104.2 182.54,66.63 183.08,66.09 186.07,66.09 186.82,65.33 v1(186.82,61.31) ; 169.75,63.63 169.75,63.29 168.35,61.9 v1(168.35,61.59)
  TOP w1.016: 59.26,52.25 60.22,52.25 60.55,52.58 70.66,52.58 73.2,50.04 77.24,50.04 84.96,57.76 84.96,58.6 85.44,59.08 85.44,60.37
  IN1 w0.381: v1(38.21,8.25) 38.79,8.84 39.67,8.84 41.35,10.51 v1(42.75,10.51)
  IN1 w0.508: v1(92.62,9.58) 91.25,9.58 90.78,10.06 88.52,10.06 88.34,10.23 86.61,10.23 85.27,8.89 72.62,8.89 v1(72.31,8.58)
  IN2 w0.254: v1(114.6,21.05) 114.2,21.05 109.5,25.75 106.53,25.75 ; v2(201.47,14.83) 201.04,14.83 200.18,13.97 198.75,13.97 197.94,14.78 197.33,14.78 196.82,14.27 196.82,13.79 195.04,12.01 192.33,12.01 v2(191.74,12.6) ; v1(119.38,23.31) 120.24,22.45 120.24,21.41 120.71,20.94 157.74,20.94 159.66,22.86 v1(160.14,22.86)
  IN2 w0.508: v1(83.67,22.6) 83.67,20.98 84.28,20.37 86.56,20.37 88.34,18.59 91.44,18.59 ; 188.15,51.29 187.37,52.07 187.37,55.35 186.44,56.28 186.44,58.21 186.87,58.64 186.87,59.15 186.34,59.68 186.34,60.19 186.82,60.67 v1(186.82,61.31) 186.82,63.77 189.18,66.13 189.18,67.57 191.88,70.28 191.88,71.15 190.85,72.19 190.85,73.87 189.27,75.45 189.27,76.91 188.64,77.54 188.64,79.58 188.39,79.83 188.39,80.85 v1(188.19,81.05)
  IN2 w0.762: 105.46,23.86 104.76,23.16 104.76,20.9 104.18,20.32 93.98,20.32 92.16,18.5
  IN3 w0.254: v1(183.72,10.74) 183.97,11 183.97,11.1 184.17,11.3 186.72,11.3 187.33,11.92 189.31,11.92 190.04,12.65 191.01,12.65 191.06,12.6 v2(191.74,12.6) ; v1(147.04,52.7) 147.06,52.72 147.06,53.32 v1(146.02,54.35)
  IN3 w0.381: v1(26.67,52.78) 27.53,53.64 27.53,57.45 v1(28.8,58.72)
  IN3 w0.508: v1(188.19,81.05) 189.15,82.01 189.15,82.65 188.47,83.34 188.47,88.97 187.58,89.86 186.97,89.86 v2(186.36,90.47)
  BOTTOM w0.203: PR8117.2 42.77,10.56 42.75,10.54 v1(42.75,10.51) ; v1(79.04,107.14) 79.04,102.99 79.5,102.54 R1146.1 ; PR9830.2 41.93,100.81 41.2,100.81 40.39,101.61 PQ9801.1 ; v2(186.36,90.47) 186.36,90.55 186.35,90.56 186.35,91.03 R5925.1 ; PU9900.20 78.8,107.86 78.92,107.74 79.75,107.74 PC9906.2 ; v1(55.34,104.52) 55.1,104.28 PU9901.20 ; v1(39.52,102.74) 39.52,102.74 39.04,103.22 39.04,103.43 38.58,103.89 PR9829.1 ; R3420.1 192.42,13.51 192.23,13.31 191.84,13.31 191.74,13.21 v2(191.74,12.6) ; Q5404.2 91.74,70.65 92.16,71.08 R5418.1
  BOTTOM w0.229: U5403.1 156.6,15.35 156.75,15.21 156.75,14.48 156.33,14.07 156.28,14.07 155.75,13.54 154.58,13.54 v1(152.73,11.68)
  BOTTOM w0.254: v1(199.01,53.19) 199.01,53.18 199.01,52.54 v1(199.01,52.53) 199.25,52.3 R3506.2 ; 29.03,56.87 32.02,56.87 32.23,56.67 R5401.1 ; PC9914.2 55.68,104.86 v1(55.34,104.52) ; R5418.1 92.55,70.99 92.25,70.69 92.25,69.77 92.05,69.57 91.47,69.57 90.63,68.73 87.99,68.73 v1(87.83,68.57) ; v1(119.38,23.31) 118.82,23.87 117.14,23.87 114.6,21.33 v1(114.6,21.05) ; R810.2 138.1,55.27 139.59,53.78 144.51,53.78 144.96,54.23 145.9,54.23 v1(146.02,54.35) 147.34,54.35 147.92,53.78 153.07,53.78 153.28,53.57 155.94,53.57 156.23,53.86 v1(156.23,54.28) ; Q5404.5 89.45,70.65 89.15,70.35 R5417.1 87.95,70.35 v1(87.7,70.6) ; R804.2 135.61,56.03 139.41,52.23 146.56,52.23 v1(147.04,52.7) ; v1(152.73,11.68) 153.26,11.15 R1120.2 ; v1(139.36,58.18) 139.45,58.27 R1200.1 ; R1145.1 151.4,81.1 151.76,80.74 v2(151.76,80.73) ; R5403.1 33.88,59.05 33.14,58.32 31.06,58.32 30.66,58.72 v1(28.8,58.72) ; v1(106.65,18.57) 106.65,18.92 106.86,19.12 106.86,22.88 106.07,23.67 106.07,25.55 v1(105.43,26.19) v1(105.43,26.82) 104.96,27.29 JDIM2900.255
  BOTTOM w0.305: v1(39.52,102.74) 39.52,102.74 39.78,103 PQ9801.1
  BOTTOM w0.381: Q1100.5 153.86,76.92 v2(154.01,76.77) ; 85.13,68.24 86.15,67.21 86.15,65.67 86.57,65.25 86.57,64.76 v1(86.8,64.53) ; R626.2 46.45,7.49 v1(46.89,7.06) ; v1(79.04,107.14) 79.21,107.14 PC9906.2
  BOTTOM w1.016: 177.34,29.9 170.58,29.9 169.82,30.66 166.34,30.66 164.56,32.44 164.56,38.38
  vias: v1(15.14,24.58) v1(15.77,24.58) v1(18.23,10.45) v1(18.22,9.39) v1(18.84,10.45) v1(18.83,9.39) v1(19.45,9.39) v1(19.84,58.29) v1(20.11,55.34) v1(20.13,54.69) v1(20.11,54.05) v1(26.96,51.81) v1(26.95,51.15) v1(29.18,7.74) v1(29.61,8.33) v1(29.82,7.74) v1(29.97,8.84) v1(30.25,8.2) v1(31.12,36.83) v1(31.59,36.4) v1(33.21,36.73) v1(33.2,36.09) v1(54.68,53.16) v1(55.34,53.16) v1(56,53.16) v1(86.31,64.03) v1(91.44,17.5) v1(92.07,17.5) v1(92.83,82.07) v1(93.24,9.58) v1(147.9,10.43) v1(148.51,10.43) v1(164.27,39.76) v1(164.91,39.76) v1(188.53,50.54) v1(189.16,50.56) v1(191.39,40.74) v1(191.39,40.1) v1(202.92,61.08) v1(202.92,60.45) v1(207.54,23.75) v2(150.39,74.45) v2(205.05,13.94)
+3V_1.8V_DEEP_SUS: length 2.5
  TOP w0.109: v2(136.61,73.84) 136.61,73.84 136.21,74.24 R1609.1 135.81,74.01 135.36,73.56 R1610.1
  BOTTOM w0.254: U400.DA28 136.96,74.19 v2(136.61,73.84)
+3V_ALW: length 219.2
  TOP w0.178: 22.96,41.73 22.85,41.84 U7500.1
  TOP w0.203: R4825.1 184.76,9.85 184.59,10.02 v1(184.59,10.74) ; v1(161.03,8.64) 161.03,9.04 161.9,9.91 161.9,11.22 161.69,11.44 161.69,12.61 161.74,12.74 PR8720.2
  TOP w0.254: 22.96,41.73 22.96,40.87 R7500.1 23.09,40.21 v1(22.97,40.08) R7507.2 ; v1(179.93,9.07) 179.93,11.99 179.2,12.72 179.2,13.83 178.92,14.12 PU8101.2 ; v1(35.3,12.52) 35,12.22 35,11.12 35.51,10.61 35.51,9.7 v1(32.74,6.93) ; CON7602.16 10.57,19.18 10.89,19.5 v1(10.89,19.73) ; v1(160.22,69.82) 160.75,69.82 R1415.1 ; R7503.2 20.88,41.06 v1(20.88,40.67) ; v1(23.22,42.96) 23.42,43.15 R3300.1
  TOP w0.305: v1(145.05,17.55) 145.05,17.32 143.56,15.83 143.56,14.68 142.97,14.09 142.97,12.21 144.09,11.1 144.09,10.34 143.63,9.88 143.63,8.62 142.89,7.87 142.89,6.64 v1(142.85,6.6)
  TOP w0.508: 16.71,45.29 16.08,44.65 16.08,43.08 v1(15.88,42.88) 14.48,41.48 v1(13.05,41.48)
  IN1 w0.508: v1(23.22,42.96) 21.69,42.96 21.44,43.2 16.2,43.2 v1(15.88,42.88)
  IN2 w0.254: 189.94,12.9 189.94,16.46 188.3,18.1 187.36,18.1 187.03,17.77 185.98,17.77 185.55,18.2 185.55,18.69 183.86,20.37 183.86,22.13 181.48,24.51 181.48,27.83 179.34,29.96 179.34,32.47 174.55,37.26 v1(174.35,37.26) ; v1(160.22,69.82) 160.91,69.14 160.91,65.15 161.5,64.55 161.5,61.26 163.04,59.72 163.04,58.45 163.64,57.85 163.64,57.46 163.46,57.28 163.46,55.19 164.26,54.39 164.26,51.27 164.96,50.58 164.96,49.87 165.81,49.02 165.81,48.71 166.42,48.11 166.42,47.72 167.97,46.17 167.97,45.21 170.36,42.82 171.79,42.82 174.32,40.3 v1(174.32,38.61)
  IN2 w0.762: 93.32,10.56 86.13,10.56 85.91,10.35 75.69,10.35 73.67,8.33 73.12,8.33 71.24,6.44 69.22,6.44 ; 138.4,7.24 136.82,7.24 136.38,6.8 133.27,6.8 132.58,7.49 131.01,7.49 130.71,7.19 127.94,7.19 127.38,6.63 125.6,6.63 125.14,7.08 123.54,7.08 122.28,6.56 118.48,6.56 116.69,8.35 111.43,8.35 110.87,7.8 106.78,7.8 106.5,8.07 104.75,8.07 104.16,8.66
  IN3 w0.254: v1(174.32,38.61) 174.32,37.29 v1(174.35,37.26)
  IN3 w0.508: v1(13.05,41.48) 12.76,41.19 12.76,38.81 11.85,37.9 11.85,35.6 10.62,34.37 10.62,20.01 v1(10.89,19.73) ; v1(23.22,42.96) 22.97,42.7 v1(22.97,40.08)
  BOTTOM w0.254: PR8126.2 185,11.38 184.59,10.97 v1(184.59,10.74) ; PU8602.6 143.48,17.3 144.24,17.3 PC8605.1 144.62,17.13 v1(145.05,17.55) ; v1(35.3,12.52) 35.46,12.68 PR8106.1
  BOTTOM w0.508: v1(20.88,40.67) 21.67,40.67 22.25,40.08 v1(22.97,40.08)
  vias: v1(190.22,12.16)
+3V_CAM: length 24.9
  TOP w0.254: R3412.2 19.7,27.41 19.79,27.31 C2019.2 20.39,27.31 20.7,27 U2008.D2 U2008.D1
  TOP w0.381: R3412.2 18.91,28.51 19.43,29.03 22.12,29.03 22.96,29.87 22.96,30.66 23.59,31.3 23.87,31.3 24.48,31.9 24.48,32.92 23.6,33.8 23.6,34.32 23.65,34.37 23.65,35.98 23.26,36.37 23.26,36.73 23.73,37.19 23.73,37.62 24.31,38.21 24.31,39.99 24.32,40 24.32,42.63 24.75,43.06 C3425.1
  BOTTOM w0.254: v1(27.28,42.93) 27.47,42.75 CON3400.35
  vias: v1(26.09,48.85) v1(26.62,42.93) v1(26.73,48.85)
+3V_CAM_R: length 32.8
  TOP w0.254: U3402.1 20.97,56.15 v1(21.43,55.68)
  IN3 w0.254: v1(21.43,55.68) 21.43,51.17 21.73,50.87 21.73,47.9 20.94,47.11 20.94,45.22 19.98,44.27 19.98,34.37 20.36,34 20.36,30.64 21.13,29.87 21.13,29.41 20.18,28.46 20.18,27.57 19.71,27.1 v1(19.71,26.18)
+3V_CLICK+: length 2.7
  TOP w0.254: U1902.D3 42.37,13.64 41.92,13.46 41.83,13.37 C1903.1 41.98,12.74 R5215.2
+3V_CLICK-: length 3.8
  TOP w0.254: R5214.2 41.22,12.74 C1903.2 41.38,13.44 41.98,14.04 v1(42.03,14.04) U1902.D2 U1902.D1
+3V_CLICK_R: length 5.1
  TOP w0.254: v1(39.6,10.39) 39.65,10.44 v1(41.65,10.44) 41.65,10.61 41,11.27 R5216.1 41.22,11.72 R5214.1
  BOTTOM w0.508: F5203.2 38.67,10.39 v1(39.6,10.39)
+3V_CM_PWR: length 877.2
  TOP w0.178: U1807.B1 14.08,17 13.87,17.21 13.87,17.65
  TOP w0.203: v1(145.17,9.86) 145.17,9.61 144.1,8.54 144.1,8.52 143.28,7.69 143.28,7.25 143.33,7.12 143.33,6.37 143.2,6.24 C2011.1 143.78,5.44 144.32,5.44 ; U2004.B1 200.68,77.8 v1(201.07,78.19)
  TOP w0.254: v1(75.99,13.92) 75.99,13.29 C2000.1 74.87,11.32 74.44,10.89 U2000.B1 ; v1(138.65,16.78) 139.17,16.27 139.4,16.27 139.53,16.14 139.53,15.51 139.95,15.09 U1804.C3 ; v1(30.01,55.48) 29.1,55.48 28.85,55.22 U1908.C3 ; v1(19.19,13.66) 19.19,13.27 19.29,13.17 C2002.1 19.29,11.75 U2002.B1 ; U1803.B1 25.97,27.31 26.08,27.19 26.08,25.48 25.79,25.19 23.96,25.19 23.71,25.44 ; U1800.B1 194.95,2.22 194.75,2.03 193.47,2.03 193.01,2.49 C1802.1 193.01,3.12 192.97,3.16 v1(192.97,3.7) 192.97,4.05 193.42,4.49 194.08,4.49 194.68,5.09 195.22,5.09 195.48,4.83 195.48,4.47 194.98,3.97 194.98,3.3 U1800.B3 ; C1906.1 111.25,14.09 112.09,13.26 112.09,11.4 111.48,10.79 111.17,10.79 110.74,10.36 110.74,9 v1(110.44,8.7) ; C1906.1 111.76,14.96 112.01,15.22 112.01,16.13 v1(111.96,16.18) ; C1906.1 111.22,14.99 U1903.B1 ; v1(138.86,11.33) 140.11,12.58 140.66,12.58 140.69,12.55 141.15,12.55 arc(141.24,12.57) 141.33,12.62 141.61,12.62 142.5,13.52 142.5,14.26 ; U1905.B1 192.73,55.63 v1(192.81,55.55) 192.86,55.6 C1908.1 ; v1(181.13,3.17) 181.13,3.2 180.34,3.99 180.34,4.58 179.12,5.79 178.86,5.79 ; v1(167.97,101.62) 167.82,101.47 167.82,99.62 167.84,99.59 167.84,98.65 C1907.1 167.81,98.32 168.19,97.94 U1904.B1 ; v1(146.15,11.68) 146.15,11.67 146.15,11.67 146.15,11.12 U1900.B3 ; v1(170.43,102.94) 170.43,104.24 171.79,105.59 171.96,105.67 172.51,106.22 175.61,106.22 v1(175.74,106.09) ; v1(172.54,95.07) 172.54,96.04 170.65,97.94 U1904.B3 ; U2005.B1 176.15,52.56 v1(176.07,52.48) 175.91,52.32 175.59,52.32 175.26,52 C2009.1 175.25,51.8 174.27,51.8 173.89,51.43 172.04,51.43 171.85,51.61 171.32,51.61 170.72,51.01 170.44,51.01 169.57,50.14 167.05,50.14 166.37,49.45 166.37,48.33 v1(165.94,47.9) ; 142.44,14.93 142.44,14.93 142.72,15.21 C1809.1 142.93,15.55 143.15,15.77 143.15,16.01 143.71,16.57 v1(143.71,16.79) ; U2004.C3 U2004.B3 200.68,76.54 v1(200.84,76.38) 200.82,76.36 200.82,76.03 200.71,75.91 C2008.1 ; U1906.B1 162.22,6.99 162.59,7.36 C1912.1 162.59,10.11 163.43,10.95 v2(164.97,10.95) 164.97,10.51 165.83,9.65 166.39,9.65 167,9.04 170.28,9.04 170.43,8.89 C1810.1 172.85,8.89 174.5,7.24 174.89,7.24 ; v1(201.22,39.24) 199.89,39.24 199.56,39.1 199.26,38.81 v1(199.26,38.71) ; v1(180.6,29.74) 181.14,29.74 181.76,29.12 U1809.B3 ; U1809.B1 181.76,27.55 181.96,27.36 v1(181.96,27.05) 181.84,26.93 C1816.1 ; U2000.B3 74.44,9.8 74.67,9.57 76.52,9.57 76.79,9.84 76.79,11.92 77.93,13.05 v1(77.93,13.97) ; v1(117.88,95.39) 117.88,94.93 117.95,94.86 117.95,91.52 118.36,91.11 119.38,91.11 C2001.1 119.99,91.72 U2001.B1 ; 175.44,7.36 177.52,7.36 178.51,6.37 178.51,5.99 178.51,5.99 ; v1(21.54,58.81) 24.14,58.81 v1(25.65,57.3) 26,56.95 26,54.41 26.44,53.97 v1(26.95,53.97) 26.95,53.46 27.53,52.88 C1915.1 27.74,53.21 28.45,53.92 U1908.B1 ; v1(46.27,11.77) 46.27,13.87 46.02,14.12 C1900.1 46.02,15.18 45.66,15.54 44.63,15.54 44.01,14.92 U1902.B1 ; v1(25.04,64.01) 25.04,65.29 C1916.1 25.37,66.39 25.65,66.67 U1909.B1 ; v1(83.06,109.88) 82.79,109.88 82.52,110.15 C2018.1 82.62,110.43 83.32,110.43 83.53,110.22 83.98,110.22 84.23,110.46 U2010.B1 ; 13.87,17.65 13.87,18.11 14.17,18.41 C1815.1 14.63,18.68 14.92,18.39 15.77,18.39 15.95,18.21 16.74,18.21 17.14,18.62 17.14,20.03 v1(17.75,20.64) ; 178.53,5.64 177.93,5.03 U1806.B1 ; C1902.1 145.77,9.05 146.18,9.46 v1(146.3,9.46) 146.18,9.59 U1900.B1 ; v1(173.33,64.82) 171.83,66.32 170.48,66.32 170.05,66.75 170.05,67.46 168.64,68.87 C1914.1 168.64,69.89 168.56,69.97 U1907.B1 ; 175.38,7.03 175.38,6.01 175.96,5.43 U1806.C3
  IN1 w0.254: v1(83.06,109.88) 84.06,110.88 85.42,110.88 86.57,109.73 88.84,109.73 90.1,110.98 101.56,110.98 102.3,110.25 105.61,110.25 107.6,108.26 111.45,108.26 112.47,107.24 121.44,107.24 122.5,108.3 125.65,108.3 130.02,103.93 131.52,103.93 131.76,103.7 v1(132,103.7) 132.3,103.7 133.49,104.89 143.52,104.89 144.75,103.66 145.62,103.66 146.05,103.22 v1(146.05,103.02) 146.05,102.89 146.43,102.51 149.74,102.51 150.73,101.52 162.35,101.52 163.52,102.69 164.13,102.69 165.3,101.52 167.87,101.52 v1(167.97,101.62) 167.97,101.75 168.37,102.16 169.64,102.16 v1(170.43,102.94) 171.35,102.94 172.13,102.16 174.06,102.16 v1(174.75,101.47) ; v1(200.84,76.38) 201.07,76.62 v1(201.07,78.19) 201.14,78.26 202.33,78.26 202.69,77.9 202.69,68.45 203.2,67.94 203.2,63.98 204.26,62.91 v1(204.26,62.08) 204.67,62.08 205.46,61.29 205.46,59.18 203.86,57.58 203.86,54.02 203.32,53.49 203.32,50.49 202.13,49.3 202.13,46.51 201.39,45.77 200.48,45.77 200.2,46.05 195.58,46.05 192.58,43.05 192.58,41.68 192.91,41.35 192.91,39.25 193.59,38.57 198.15,38.57 198.29,38.71 v1(199.26,38.71) ; v1(192.81,55.55) 192.73,55.47 192.73,54.36 192.35,53.98 190.75,53.98 v1(188.58,56.14)
  IN2 w0.254: v1(30.01,55.48) 29.11,55.48 27.6,53.97 v1(26.95,53.97) ; v1(117.88,95.39) 117.88,95.67 119.85,97.64 119.85,100.03 123.17,103.35 131.65,103.35 v1(132,103.7) ; v1(181.96,27.05) 181.96,28.38 v1(180.6,29.74) ; v1(167.97,101.62) 167.84,101.5 167.84,98.91 166.6,97.66 166.6,95.2 167.04,94.75 167.04,94.75 167.04,89.27 169.29,87.02 169.29,83.41 170.96,81.74 170.96,80.76 172.94,78.78 172.94,76.58 172.45,76.09 172.45,72.22 172.92,71.74 172.92,66.27 173.33,65.86 v1(173.33,64.82) ; v1(31.65,12.95) 31.65,16.86 22.64,25.87 22.06,25.87 19.66,28.27 v1(19.66,28.47)
  IN3 w0.254: v1(181.13,3.17) 181.13,3.4 181.84,4.11 181.84,4.33 182.63,5.12 184.97,5.12 186.56,3.53 192.81,3.53 v1(192.97,3.7) 193.01,3.66 193.01,2.25 193.4,1.86 205.78,1.86 207.12,3.21 207.12,4.48 207.97,5.33 209.87,5.33 213.29,8.75 213.29,11.53 212.6,12.22 212.6,13.06 214.66,15.12 214.66,20.03 213.57,21.12 213.57,23.2 210.01,26.76 v1(210.01,26.96) 209.93,26.96 209.2,27.69 204.36,27.69 203.05,29 v1(203.05,29.54) 202.35,29.54 200.8,31.09 199.26,31.09 198.67,31.68 198.12,31.68 197.66,31.23 195.41,31.23 193.52,33.12 193.52,33.32 192.83,34.01 192.83,36.01 193.19,36.37 195.4,36.37 196.04,37.01 196.04,38.12 196.29,38.37 196.89,38.37 197.23,38.71 v1(199.26,38.71) ; v1(201.07,78.19) 201.33,78.45 201.33,78.81 199.34,80.8 199.34,83.41 200.58,84.65 200.58,86.31 198.04,88.85 198.04,92.56 196.24,94.36 194.98,94.36 194.63,94.72 194.63,96 193.6,97.03 189.13,97.03 188.88,97.28 187.95,97.28 187.52,96.84 187.52,94.42 186.84,93.75 186.03,93.75 185.49,93.22 185.49,92.96 184.83,92.3 184,92.3 183.1,91.41 183.1,90.21 182.94,90.05 181.79,90.05 181.48,90.37 181.48,90.71 180.49,91.69 180.49,92.68 179.46,93.71 178.22,93.71 177.93,94 173.61,94 v1(172.54,95.07) 172.54,96.11 172.03,96.62 172.03,96.84 173.3,98.11 173.3,100.84 173.94,101.47 v1(174.75,101.47) ; v1(180.6,29.74) 180.3,29.44 179.6,29.44 177.63,31.41 177.63,34.14 175.24,36.53 175.24,36.98 174.79,37.43 174.79,39.75 173.29,41.25 172.77,41.25 172.38,41.64 172.38,41.96 171.75,42.59 169.84,42.59 169.18,43.25 169.18,44.1 168.12,45.16 168.12,46.43 167.79,46.76 167.08,46.76 v1(165.94,47.9) ; v1(138.65,16.78) 138.94,17.07 142.48,17.07 142.77,16.79 v1(143.71,16.79) ; v1(19.19,13.66) 19.19,14.67 17.71,16.14 17.71,18.83 17.36,19.18 17.36,20.24 v1(17.75,20.64) 17.75,22.23 18.34,22.82 18.34,26.65 19.66,27.96 v1(19.66,28.47) 19.66,28.94 20.01,29.3 20.01,33.67 v1(19.52,34.17) 19.52,35.09 19.64,35.21 19.64,44.41 20.6,45.36 20.6,48.71 20.85,48.97 20.85,58.12 v1(21.54,58.81) 24.18,61.45 24.18,63.16 v1(25.04,64.01) ; v1(111.96,16.18) 111.96,16.38 111.21,17.14 105.76,17.14 105.71,17.09 104.22,17.09 103.78,17.52 103.78,18.18 103.59,18.38 103.09,18.38 102.49,17.78 102.49,17.55 100.53,15.59 93.98,15.59 92.94,14.56 89.4,14.56 88.79,15.16 87.7,15.16 87.65,15.21 86.31,15.21 86.13,15.03 80.23,15.03 79.34,14.15 78.1,14.15 v1(77.93,13.97) 77.93,13.76 77.62,13.46 76.45,13.46 v1(75.99,13.92) 75.79,13.92 74.38,15.33 71.85,15.33 70.15,13.62 67.35,13.62 67.05,13.92 63.24,13.92 62.37,13.04 58.67,13.04 58.44,12.81 57.85,12.81 56.77,13.89 53.41,13.89 53.29,14.02 47.88,14.02 46.27,12.41 v1(46.27,11.77) 45.66,11.77 45.46,11.96 44.86,11.96 44.47,11.58 44.47,11.22 44.13,10.88 43.68,10.88 43.29,11.27 39.14,11.27 38.87,11.54 38.87,12.08 38.73,12.22 36.75,12.22 36.56,12.02 35.09,12.02 34.64,12.47 32.13,12.47 v1(31.65,12.95) ; v1(110.44,8.7) 124.67,8.7 125.55,9.58 131.37,9.58 132.03,10.23 133.6,10.23 133.7,10.13 134.47,10.13 134.9,10.56 134.9,11.26 135.07,11.43 135.31,11.53 135.54,11.53 135.87,11.2 138.73,11.2 v1(138.86,11.33) 139.01,11.33 139.56,10.77 141.5,10.77 143.36,11.54 144.06,11.54 144.21,11.39 145.87,11.39 146.15,11.67 v1(146.15,11.68) 146.16,11.68 146.62,12.14 147.18,12.14 147.6,11.73 148.62,11.73 149.05,11.3 149.29,11.2 151.53,11.2 151.98,10.76 157.52,10.76 157.66,10.9 158.89,10.9 159.99,11.35 164.08,11.35 164.25,11.18 164.75,11.18 v2(164.97,10.95)
  BOTTOM w0.254: v1(19.52,34.17) 20.1,34.74 24.25,34.74 24.84,35.33 25.47,35.33 v1(26.05,34.75) ; v1(204.26,62.08) 203.78,61.59 202.51,61.59 202.39,61.47 201.04,61.47 199.82,60.25 198.35,60.25 193.65,55.55 v1(192.81,55.55) ; v1(175.74,106.09) 175.81,106.02 U2006.B1 ; v1(210.01,26.96) 208.52,26.96 208.23,26.67 208.23,26.26 207.82,25.85 206.86,25.85 206.6,26.11 203.71,26.11 203.35,26.47 C1808.1 203.35,27.05 203.02,27.38 U1805.B1 ; 145.19,9.88 146.15,10.84 v1(146.15,11.68) ; 145.19,9.88 145.37,9.7 145.69,9.7 145.93,9.46 v1(146.3,9.46) ; 145.19,9.88 v1(145.17,9.86) ; v1(188.58,56.14) 188.37,55.93 180.64,55.93 179.44,54.73 178.13,54.73 176.07,52.66 v1(176.07,52.48) ; C1800.1 201.78,39.8 v1(201.22,39.24) ; U2006.C3 176.21,104.25 176.22,104.24 C2010.1 175.86,103.68 174.75,102.56 v1(174.75,101.47) ; U1801.B1 199.65,39.6 199.26,39.22 v1(199.26,38.71) ; U1805.C3 202.62,28.91 203.05,29.33 v1(203.05,29.54)
  BOTTOM w0.508: v1(146.05,103.02) 146.05,103.56 R1900.1
+3V_CR: length 31.7
  TOP w0.203: R7614.2 179.53,43.02 v1(179.36,43.19)
  TOP w0.254: U2005.D1 U2005.D2 177.48,53.41 177.83,53.76 179.39,53.76 180.23,52.92 180.23,50.87 R7606.2 ; 180.63,47.44 180.63,45.05 R7602.2 179.9,44.64 179.62,44.36 R1411.2
  IN2 w0.508: v1(180.09,47.57) 179.84,47.32 179.84,46.71 180.74,45.82 180.74,45.1 179.36,43.72 v1(179.36,43.19) 179.36,42.93 v1(181.7,40.58)
  BOTTOM w0.508: v1(172.84,40.18) 174.33,40.18 177.59,43.44 177.59,44.34 178.35,45.09 178.35,46.25 179.67,47.57 v1(180.09,47.57)
  vias: v1(173.15,40.74)
+3V_DEEP_SUS: length 579.7
  TOP w0.203: v2(136.88,66.62) 136.91,66.65 R1521.2 ; v1(183.92,42.36) 184.14,42.14 185.06,42.14 185.93,41.26 186.35,41.26 187.18,40.43 187.83,40.43 R1232.1 ; v1(77.14,95.59) 76.77,95.59 76.6,95.42 R4748.1
  TOP w0.254: v1(143,59.21) 143,58.8 R1306.1 ; 158.67,48.45 158.67,47.77 158.3,47.39 158.3,46.1 157.93,45.73 157.47,45.73 156.1,44.36 156.1,43.74 156.49,43.36 156.49,41.81 R1560.1 ; 158.67,48.45 157.59,47.37 C1501.2 156.79,47.6 156.79,47.72 156.61,47.91 155.87,47.91 155.74,48.04 155.11,48.04 R1308.1 154.66,48.04 153.83,48.04 153.64,47.85 153.64,46.52 153.41,46.29 U1501.5 ; 158.67,48.45 v1(158.67,48.64) ; v2(35.47,11.45) 35.47,11.26 35.91,10.82 36.32,10.82 36.55,10.59 36.55,9.85 36.22,9.52 36.22,7.44 35.8,7.02 35.34,7.02 35.13,6.8 v2(35.13,6.04) ; v1(153.85,65.54) 153.72,65.67 151.03,65.67 150.82,65.45 149.93,65.45 149.66,65.73 v2(149.66,66.02) ; R4133.1 194.26,68.02 191.87,68.02 191.54,67.69 R4134.1 190.83,67.69 190.66,67.51 190.66,66.91 v1(190.47,66.72) ; v2(136.88,66.62) 136.88,66.22 136.13,65.47 136.13,64.24 136.65,63.73 136.65,60.45 R815.1 R816.1 135.99,59 135.99,58.7 R811.2 136.53,57.98 138.73,55.78 139.99,55.78 142.81,52.95 144.75,52.95 v1(145.29,53.49) ; R407.1 143.89,58.19 v1(144.19,58.49) ; v1(160.36,74.77) 160.45,74.67 R1236.1 ; v2(151.9,79.59) R1129.2 ; 167.74,74.22 167.74,73.61 167.46,73.33 167,73.33 165.34,74.99 165.34,75.75 164.74,76.35 163.9,76.35 R5636.1 ; U2007.D1 145.72,6.02 145.95,6.24 v1(145.95,6.24) 145.94,6.24 145.77,6.42 U2007.D2 ; R1132.1 187.85,5.64 187.73,5.76 187.73,6.02 v1(188.11,6.4) ; v1(182.72,87.48) 182.72,87.31 182.22,86.8 U4102.5 180.99,86.8 180.39,87.4 180.37,87.4 R812.2 ; v1(156.26,81.58) 156.76,82.09 R1207.1
  TOP w0.381: v2(147.55,84.95) 147.55,83.82 148.37,83 150.13,83 150.44,82.69 151.93,82.69 v1(152.4,82.22) 152.42,82.2 R1230.2 ; R1234.1 141.03,78.79 141.37,78.46 143.48,78.46 144.91,77.03 146.22,77.03 146.64,77.03 146.95,76.71 147.83,76.71 148.03,76.91 149,76.91 149.25,77.16 150.21,77.16
  TOP w0.508: v1(157.88,76.86) 157.88,76.99 160.04,79.15 163.05,79.15 163.96,78.23 164.31,78.23 167.31,75.23 167.31,74.65 167.74,74.22 ; v1(80.21,54.7) 80.66,54.7 84.07,58.11 84.07,59.36 84.48,59.76 84.48,61.85 84.66,62.02 84.66,63.96 v1(85.86,65.16)
  IN1 w0.254: v1(182.72,87.48) 182.72,89.07 183.78,90.13 183.78,90.61 184.11,90.94 184.54,90.94 184.57,90.91 187.09,90.91 187.33,91.01 190.06,91.01 190.3,90.77 v2(190.3,90.58) ; v1(190.47,66.72) 187,66.72 186.52,67.19 186.14,67.19 185.8,66.85 185.8,65.32 v1(179.96,59.49)
  IN1 w0.508: v1(160.36,74.77) 160.55,74.57 161.11,74.57 161.39,74.85 162.1,74.85 162.63,74.32 166.27,74.32 166.48,74.53 167.5,74.53 167.59,74.44 172.26,74.44 173.13,75.32 177.53,75.32 v1(177.65,75.44) ; v1(17.57,45.54) 18.18,45.54 18.73,46.09 21.28,46.09 23.06,47.88 25.88,47.88 26.56,47.2 26.56,46.7 27.09,46.17 27.66,46.17 29.18,47.68 30.85,47.68 31.5,48.34 38.97,48.34 40.18,49.55 46.86,49.55 48.05,50.75 49.91,50.75 51.23,52.07 56.49,52.07 57.07,52.65 58.69,52.65 59.16,53.12 v1(59.82,53.12) ; v1(157.88,76.86) 157.43,76.86 v2(156.13,75.56)
  IN2 w0.254: v1(192.97,70.72) 192.97,69.96 190.47,67.46 v1(190.47,66.72)
  IN2 w0.381: v2(156.13,75.56) 156.13,77.16 155.64,77.66 154.75,77.66 153.34,79.07 152.72,79.07 152.47,79.32 152.1,79.32 151.89,79.53 151.89,79.59 v2(151.9,79.59) ; v1(156.26,81.58) 156.26,81.65 155.61,82.3 152.48,82.3 v1(152.4,82.22) ; v2(136.88,66.62) 136.88,67.08 136.14,67.82 136.14,68.88 135.79,69.24 134.87,69.24 134.19,69.92 134.19,70.69 134.94,71.44 134.94,72.06 v2(135.57,72.7) ; v2(149.66,66.02) 149.66,66.88 149.97,67.2 149.97,67.98 149.69,68.27 v2(149.69,68.69) 149.69,68.7 149.7,68.72 149.7,70.89 150.26,71.45 150.26,72.7 150.57,73.01 151.2,73.01 151.5,73.31 151.5,73.92 v2(151.33,74.09) ; v1(146.8,88.98) 147.47,88.3 147.47,87.12 147.55,87.04 v2(147.55,84.95)
  IN2 w0.508: v1(157.88,76.86) 157.88,78.97 156.26,80.59 v1(156.26,81.58)
  IN2 w1.016: 164.03,6.04 165.07,6.04 165.58,6.55 168.96,6.55 169.8,5.71 169.8,4.95 173.15,1.6 179.37,1.6 180.08,2.31 ; 70.47,3.81 73.29,6.63 75.33,6.63 77.31,8.6 98.1,8.6 98.93,7.77 101.15,7.77 102.34,6.58 103.72,6.58 104.48,5.81 108.48,5.81 108.81,5.48 133.17,5.48 133.51,5.82 136.38,5.82 ; 183.61,37.42 183.61,36.34 187.57,32.38 187.57,30.34 187.73,29.94 188.97,28.7 ; 173.88,86.11 170.74,89.25 170.74,90.91
  IN3 w0.254: v1(145.29,53.49) 144.14,53.49 143.74,53.9 143.74,55.95 142.69,57 142.69,58.89 v1(143,59.21) ; v1(158.67,48.64) 158.47,48.84 158.47,50.17 157.17,51.47 157.17,52.19 v1(157.55,52.57) ; v1(192.97,70.72) 193.25,70.72 193.37,70.84 193.37,71.4 192.83,71.93 192.83,73.3 189.38,76.76 189.38,77.35 185.57,81.15 185.57,81.33 185.04,81.86 185.04,82.4 184.5,82.93 184.5,84.33 182.72,86.1 v1(182.72,87.48)
  IN3 w0.381: v2(150.8,72.49) 150.72,72.49 150.35,72.86 146.31,72.86 146.26,72.9 ; v2(196.92,90.75) 196.57,91.11 195.63,91.11 194.1,89.58 193.58,89.58 193.29,89.76 193.19,89.84 193.01,90.02 190.62,90.02 190.3,90.34 v2(190.3,90.58)
  IN3 w0.508: v1(9.4,18.31) 12.42,18.31 12.98,18.87 12.98,19.78 11.39,21.37 11.39,34.02 13.16,35.79 v1(13.16,36.78) 13.16,37.79 13.66,38.3 13.66,40.85 14.78,41.97 14.78,43.48 16.84,45.54 v1(17.57,45.54) ; v1(78.77,72.34) 78.53,72.58 78.53,72.96 80.85,75.27 80.85,77.76 81.31,78.22 81.72,78.22 82.18,78.67 82.18,81.6 81.48,82.29 81.48,84.07 80.97,84.59 80.97,85.7 80.56,86.11 80.56,88.11 80.79,88.35 80.79,88.74 79.19,90.34 79.19,95.23 78.06,96.36 77.46,96.36 77.14,96.03 v1(77.14,95.59) ; v1(157.88,76.86) 157.88,76.79 158.27,76.4 158.27,75.92 159.42,74.77 v1(160.36,74.77)
  BOTTOM w0.109: U1502.5 160.24,74.64 v1(160.36,74.77)
  BOTTOM w0.203: v1(53.37,5.45) 53.37,5.46 54.23,6.32 54.23,7.57 PR8219.1 ; 34.98,11.45 PR8102.1 ; 34.98,11.45 v2(35.47,11.45) ; 34.98,11.45 PR8118.1 ; v2(149.66,66.02) 149.66,65.94 150.09,65.5 R1247.1 150.32,65.33 150.37,65.38 R1214.1 ; R1510.1 195.12,89.2 196.67,90.75 v2(196.92,90.75) ; R1511.1 R1514.1 149.69,68.62 v2(149.69,68.69)
  BOTTOM w0.254: v2(149.69,68.69) 150.18,68.69 150.43,68.45 150.43,68.16 150.6,67.99 R1512.1 ; R628.2 147.02,89.45 146.8,89.22 v1(146.8,88.98) ; R1223.1 137.41,58.17 137.41,55.12 139.35,53.18 144.98,53.18 v1(145.29,53.49) 145.39,53.59 147.25,53.59 147.66,53.18 152.82,53.18 153.03,52.97 156.19,52.97 156.82,53.6 157.23,53.6 157.7,53.13 157.7,52.72 v1(157.55,52.57) ; v1(144.19,58.49) 144,58.49 R406.1 143.37,58.84 v1(143,59.21) ; R506.1 92.63,69.62 92.2,69.19 91.73,69.19 ; 153.84,74.51 153.84,74.87 R1125.2 ; R5929.2 190.3,90.88 v2(190.3,90.58) ; CON7700.1 15.81,34.69
  BOTTOM w0.381: R1613.2 154.16,65.86 v1(153.85,65.54)
  BOTTOM w0.457: v2(153.69,73.66) 153.84,73.81 153.84,74.51
  BOTTOM w0.508: v1(13.16,36.78) 15.25,34.69 15.81,34.69 ; v1(78.77,72.34) 79.25,71.86 79.25,69.42 79.89,68.77 82.61,68.77 83.11,68.27 84.19,68.27 85.59,66.86 85.59,65.42 v1(85.86,65.16) ; 89.61,65.81 89.16,65.36 89.16,62.99 88.8,62.64 88.8,58.72 86.66,56.58 85,56.58 83.11,54.7 v1(80.21,54.7) 76.28,54.7 73.97,52.38 61.4,52.38 60.66,53.12 v1(59.82,53.12)
  vias: v1(151.59,6.44) v1(152.21,6.44) v1(170.71,92.96) v1(171.3,92.58) v1(194.13,6.32) v2(154.86,67.75)

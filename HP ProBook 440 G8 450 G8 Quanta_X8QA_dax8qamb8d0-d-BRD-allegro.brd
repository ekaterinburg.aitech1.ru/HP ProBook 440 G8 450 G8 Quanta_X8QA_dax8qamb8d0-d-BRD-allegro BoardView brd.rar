# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 191.85,36.34 191.92,36.31 191.95,36.23 191.95,36.22 191.95,36.02 191.98,35.95 192.05,35.92 192.56,35.92 192.76,35.71 192.76,35.17 192.55,34.97 192.52,34.98 192.48,34.98 192.2,34.98 192.1,34.96 192.03,34.9 191.95,34.86 191.87,34.9 191.79,34.96 191.7,34.98 191.42,34.98 191.32,34.96 191.24,34.89 191.17,34.85 191.09,34.88 191.04,34.93 190.94,34.93 190.93,34.96 190.85,35.07 190.72,35.11 190.42,35.11 190.3,35.07 190.22,34.96 190.21,34.93 190.16,34.93 189.99,34.76 189.97,34.76 189.95,34.78 189.91,34.8 189.88,34.81 189.71,34.81 189.04,35.48 188.83,35.48 188.79,35.53 188.81,35.57 188.84,35.61 188.85,35.66 188.85,35.86 188.84,35.9 188.85,36 188.93,36.04 189.23,36.04 189.44,35.84 189.44,35.79 189.49,35.64 189.64,35.58 189.92,35.58 190.06,35.64 190.12,35.79 190.12,36.05 190.28,36.21 190.87,36.21 191,36.34
GND on TOP (solid shape): 144.73,14.2 144.73,13.3 144.67,12.61 145.17,13.08 145.18,13.17 145.25,13.22 145.41,13.22 145.74,13.22 145.9,13.38 148.91,13.38 149.16,13.14 149.16,12.35 149.2,12.29 149.24,12.27 149.38,12.13 150.23,12.13 150.32,12.08 150.33,11.99 150.31,11.82 150.37,11.65 150.37,11.63 150.37,11.59 150.33,11.57 150.27,11.57 150.26,11.56 150.23,11.56 150.15,11.53 150.12,11.45 150.12,11.41 149.99,11.28 148.37,11.28 148.37,11.55 148.34,11.63 148.26,11.66 148.19,11.66 148.01,11.85 147.31,11.85 147.27,11.9 147.22,11.95 147.11,12.01 146.99,12.03 146.88,12.02 146.78,11.97 146.74,11.94 146.37,12.31 144.29,12.31 144.29,12.32 143.53,12.32 143.24,12.61 143.24,13.98 143.56,14.3 144.63,14.3
GND on TOP (solid shape): 179.12,41.15 179.13,41.15 179.13,41.09 179.12,41.05 179.12,40.85 179.13,40.82 179.15,40.78 179.16,40.75 179.15,40.72 179.13,40.69 179.12,40.65 179.12,40.45 179.13,40.42 179.15,40.38 179.16,40.35 179.15,40.32 179.13,40.29 179.12,40.25 179.12,40.05 179.13,40.02 179.15,39.98 179.16,39.95 179.15,39.92 179.13,39.89 179.12,39.85 179.12,39.65 179.13,39.62 179.15,39.59 179.17,39.55 179.08,39.45 179.08,39.25 179.17,39.15 179.15,39.12 179.13,39.09 179.12,39.05 179.12,38.45 176.12,38.45 176.12,38.76 176.11,38.76 176.11,38.81 176.12,38.85 176.12,39.05 176.11,39.09 176.09,39.12 176.08,39.15 176.09,39.18 176.11,39.22 176.12,39.25 176.12,39.45 176.11,39.49 176.09,39.52 176.08,39.55 176.09,39.58 176.11,39.62 176.12,39.65 176.12,39.85 176.11,39.88 176.1,39.91 176.09,39.95 176.11,39.98 176.16,40.03 176.17,40.1 176.17,40.2 176.16,40.26 176.13,40.3 176.11,40.36 176.12,40.42 176.14,40.46 176.15,40.5 176.15,40.6 176.13,40.66 176.1,40.71 176.08,40.75 176.09,40.78 176.11,40.82 176.12,40.85 176.12,41.45 179.12,41.45
GND on TOP (solid shape): outline of 104 points within 153.36,78.09 158.14,79.55
GND on TOP (solid shape): 152.7,22.32 152.84,22.46 153.04,22.45 153.09,22.43 153.14,22.43 153.19,22.41 153.23,22.37 153.23,22.05 153.21,22.04 153.07,21.95 153,21.8 152.99,21.78 152.9,21.68 152.9,20.17 153.01,20.06 159.81,20.06 159.92,20.17 159.92,20.5 159.92,20.5 159.92,21.47 159.92,21.55 159.92,21.73 159.66,22 159.32,22 159.26,22.08 159.29,22.17 159.41,22.29 159.77,22.29 159.82,22.24 159.81,22.15 159.92,21.89 160.17,21.79 160.27,21.81 160.37,21.85 160.38,21.86 160.53,21.86 160.54,21.84 160.58,21.82 160.61,21.81 160.98,21.81 160.98,21.69 160.99,21.66 160.99,21.47 160.89,21.47 160.86,21.45 160.83,21.45 160.81,21.44 160.47,21.44 160.4,21.4 160.37,21.36 160.35,21.14 160.55,21.02 160.8,21.02 160.89,20.95 160.87,20.84 160.37,20.35 160.37,20.24 159.9,19.77 157.41,19.77 157.4,19.76 157.3,19.76 157.1,19.56 154.33,19.56 154.02,19.24 152.95,19.24 152.89,19.31 152.89,19.63 152.09,20.42 151.86,20.42 151.71,20.57 151.71,20.93 152.23,21.45 152.23,21.84 152.69,22.3
GND on TOP (solid shape): 197.41,70.53 197.41,70.22 196.91,70.22 196.58,69.89 196.58,69.78 196.34,69.54 196.18,69.37 196.18,69.14 196.18,68.9 196.34,68.74 196.39,68.69 196.39,68.16 196.42,68.08 196.5,68.05 196.88,68.05 196.88,67.82 196.97,67.73 196.99,67.62 196.89,67.56 196.83,67.56 196.76,67.53 196.72,67.46 196.71,67.42 196.57,67.42 196.15,67.85 194.66,67.85 194.66,67.9 194.66,67.95 194.66,68.15 194.66,68.18 194.64,68.22 194.63,68.27 194.64,68.33 194.66,68.36 194.66,68.4 194.66,68.56 194.84,68.74 194.84,69 195.21,69 195.29,69.03 195.32,69.11 195.32,69.58 195.36,69.66 195.44,69.68 195.48,69.68 195.74,69.79 195.85,70.04 195.81,70.21 195.7,70.34 195.66,70.43 195.73,70.51 195.76,70.53 195.8,70.55 195.86,70.49 196.1,70.48 196.3,70.48 196.36,70.49 196.54,70.49 196.66,70.61 197.33,70.61
GND on TOP (solid shape): 201.32,16.84 201.38,16.93 201.49,16.91 201.6,16.8 201.6,16.8 201.75,16.66 201.88,16.63 202,16.66 202.02,16.67 202.08,16.68 202.11,16.64 202.11,16.62 202.12,16.58 202.18,16.52 202.21,16.5 202.23,16.46 202.22,16.41 202.21,16.36 202.21,16.31 202.21,16.25 202.23,16.19 202.23,16.16 202.3,16.05 202.41,15.98 202.46,15.98 202.47,15.94 202.48,15.91 202.47,15.86 202.56,15.64 202.78,15.55 202.82,15.56 202.86,15.5 202.9,15.45 202.94,15.41 202.94,15.03 202.38,14.48 202.31,14.49 202.26,14.54 202.15,14.7 201.97,14.78 201.89,14.78 201.86,14.77 201.81,14.78 201.8,14.82 201.8,14.89 202.06,14.89 202.2,14.95 202.26,15.09 202.26,15.42 202.2,15.56 202.06,15.62 201.79,15.62 201.54,15.87 201.55,15.91 201.55,16.29 201.55,16.33 201.56,16.38 201.32,16.61
GND on TOP (solid shape): 133.26,97.74 133.26,96.38 133.22,96.38 133.22,95.51 133.22,95.47 133.22,95.27 133.22,95.23 133.25,95.19 133.25,95.15 133.24,95.14 133.22,95.11 133.22,95.07 133.22,94.47 133.22,94.43 133.22,94.29 133.18,94.25 133.18,93.7 132.62,93.14 132.62,92.66 133.49,91.8 133.49,91.42 133.63,91.27 133.67,91.27 133.71,91.24 133.7,91.19 133.1,90.59 133.06,90.51 132.98,90.5 132.93,90.57 132.88,90.63 132.87,90.66 132.88,90.7 132.82,91.46 132.05,91.47 131.57,91.61 131.17,91.31 130.85,91.63 130.85,91.88 132.28,93.31 132.28,94.34 132.16,94.46 132.16,94.67 132.14,94.74 132.08,94.78 132.04,94.79 132.04,94.87 131.33,94.87 131.33,94.79 131.3,94.78 131.27,94.77 131.24,94.74 131.05,94.74 130.87,94.92 130.87,95.09 130.9,95.16 130.97,95.2 131.24,95.2 131.27,95.17 131.3,95.16 131.33,95.15 131.33,95.07 132.04,95.07 132.04,95.15 132.08,95.16 132.14,95.2 132.16,95.27 132.16,95.45 132.31,95.6 132.31,97.33 132.9,97.92 133.08,97.92
GND on TOP (solid shape): 65.91,59.43 65.91,56.1 65.72,55.78 65.91,55.46 65.91,55.13 65.77,55 65.72,54.81 65.73,54.75 65.74,54.69 65.75,54.66 65.31,54.21 62.23,54.21 62.23,54.27 62.24,54.31 62.3,54.36 62.38,54.35 62.46,54.33 62.54,54.32 62.91,54.69 62.54,55.06 62.35,55 62.21,54.86 62.15,54.81 62.08,54.81 62,54.84 61.92,54.85 61.72,54.79 61.58,54.63 61.51,54.57 61.41,54.59 60.91,55.1 59.86,55.1 59.65,55.31 59.67,55.38 59.67,55.42 59.67,55.48 59.65,55.53 59.67,55.62 59.75,55.66 59.84,55.66 59.98,55.8 59.98,56.39 60.36,56.77 60.36,57.3 60.7,57.65 60.81,57.54 65.5,57.54 65.72,57.76 65.72,59.25 65.17,59.8 65.15,59.91 65.24,59.97 65.29,59.98 65.36,59.99
GND on TOP (solid shape): 109.25,15.55 109.31,15.55 109.34,15.55 109.46,15.55 109.46,15.49 109.45,15.48 109.43,15.41 109.44,15.34 109.41,15.25 109.32,15.22 109.2,15.22 109.1,15.16 109,15.16 108.76,14.92 108.76,13.78 110.34,12.2 110.34,9.12 110.1,8.85 110.07,8.7 110.25,8.38 110.72,8.37 110.77,8.29 110.77,7.44 110.61,7.29 110.28,7.29 110.28,7.8 110.25,7.88 110.17,7.91 109.46,7.91 109.4,7.89 109.36,7.84 109.27,7.82 109.22,7.74 109.22,7.69 109.06,7.69 108.58,8.17 108.58,9.07 108.93,9.43 108.93,10.49 108.97,10.5 109.06,10.56 109.1,10.66 109.11,10.68 109.22,10.79 109.22,11.96 109.12,12.05 109.12,12.21 108.98,12.35 109,12.43 109,12.47 108.89,12.73 108.63,12.83 108.59,12.83 108.54,12.82 108.46,12.84 108.42,12.92 108.42,13.66 108.41,13.67 108.41,13.74 108.3,13.85 108.33,13.91 108.36,13.91 108.49,14.05 108.49,15.14 108.91,15.55 109.2,15.55
GND on TOP (solid shape): 144.86,95.59 144.89,95.63 144.95,95.62 145.27,95.3 147.03,95.3 147.26,95.07 148.03,95.07 148.13,94.96 148.22,94.82 148.37,94.73 148.66,94.43 149.92,94.43 149.96,94.5 150.02,94.52 150.39,94.52 150.66,94.26 155.74,94.26 157.86,92.14 157.86,91.53 157.79,91.44 157.68,91.46 155,94.14 150.16,94.14 150.15,94.15 147.26,94.15 147.07,93.96 146.94,93.96 146.81,94.1 146.62,94.16 146.36,94.05 146.25,93.79 146.26,93.68 146.31,93.58 146.32,93.56 146.32,93.5 146.26,93.5 146.18,93.46 146.15,93.38 146.15,92.82 146.18,92.74 146.26,92.71 146.97,92.71 147.01,92.72 147.07,92.66 146.92,92.51 146.89,92.53 146.81,92.55 146.73,92.56 146.55,92.52 146.41,92.39 146.36,92.35 146.28,92.36 146.21,92.38 146.12,92.39 146.05,92.39 145.99,92.37 145.89,92.38 145.85,92.46 145.85,92.65 145.5,93 145.5,94.68 145.5,94.74 145.42,94.97 145.22,95.1 145.2,95.11 144.86,95.45
GND on TOP (solid shape): 70.98,88.53 70.98,84.72 70.99,84.71 70.99,84.61 71.22,84.39 71.22,84.37 71.24,84.25 71.31,84.14 71.35,84.11 71.19,83.94 71.19,83.69 71.12,83.6 71.01,83.62 70.99,83.64 70.62,83.64 70.57,83.67 70.58,83.72 70.6,83.75 70.71,83.75 70.76,83.75 70.86,83.76 71.01,83.82 71.08,83.97 71.08,84.25 71.01,84.41 70.86,84.47 70.76,84.48 70.71,84.48 70.3,84.48 69.64,83.83 69.6,83.79 69.58,83.74 69.49,83.69 69.4,83.74 69.27,83.86 69.02,83.89 68.89,84.02 68.89,84.09 68.95,84.09 69.04,84.06 69.12,84.05 69.36,84.15 69.46,84.4 69.44,84.5 69.39,84.6 69.36,84.64 69.67,84.94 69.71,84.92 69.8,84.87 69.9,84.86 70.14,84.96 70.24,85.2 70.24,85.23 70.7,85.68 70.7,87.37 70.6,87.46 70.6,88.75 70.61,88.78 70.62,88.81 70.66,88.85
GND on TOP (solid shape): 146.89,79.51 146.94,79.54 147,79.53 147.06,79.44 147.15,79.37 147.15,78.97 147.61,78.51 147.8,78.51 147.81,78.5 147.85,78.48 147.89,78.47 148.27,78.47 148.3,78.47 148.34,78.49 148.6,78.49 148.61,78.45 148.65,78.38 148.72,78.36 149.04,78.36 149.07,78.32 149.1,78.26 149.08,78.19 149.06,78.15 149.05,78.12 149.05,77.74 149.01,77.7 148.47,77.7 148.33,77.84 148.15,77.89 148.06,77.88 148.02,77.92 147.64,77.92 147.29,78.27 145.16,78.27 144.51,78.92 144.49,79.03 144.58,79.09 145.04,79.09 145.1,79.07 145.14,79.01 145.13,78.99 145.13,78.74 145.2,78.63 145.31,78.55 145.57,78.55 145.62,78.58 145.66,78.61 145.73,78.64 145.8,78.62 145.84,78.59 145.88,78.56 146.14,78.56 146.25,78.64 146.32,78.75 146.32,79.01 146.32,79.02 146.35,79.07 146.41,79.09 146.47,79.09
GND on TOP (solid shape): outline of 89 points within 189.05,79.63 196.39,88.06
GND on TOP (solid shape): 113.73,88.66 113.78,88.74 113.87,88.76 113.91,88.75 113.93,88.72 113.92,88.66 113.92,88.62 113.93,88.55 113.95,88.49 114.03,88.4 114.07,88.37 114.1,88.28 114.06,88.2 114.03,88.17 113.99,88.13 113.94,88.08 113.92,88.02 113.92,87.95 113.92,87.88 113.94,87.82 114.03,87.72 114.12,87.64 114.19,87.62 114.26,87.61 114.33,87.62 114.39,87.64 114.44,87.6 114.46,87.54 114.46,87.27 114.38,87.18 114.25,87.18 114.18,87.18 113.83,87.18 113.44,86.79 113.36,86.76 113.29,86.8 113.29,86.84 113.22,86.95 113.11,87.03 112.85,87.03 112.8,87 112.76,86.98 112.69,87.01 112.67,87.08 112.67,88.26 112.68,88.32 112.73,88.36 113,88.36 113.06,88.39 113.11,88.43 113.15,88.44 113.18,88.43 113.24,88.39 113.29,88.36 113.55,88.36 113.66,88.43 113.73,88.54
GND on TOP (solid shape): 187.39,35.53 187.46,35.5 187.49,35.22 187.5,35.17 187.54,35.13 187.58,35.06 187.56,34.98 187.49,34.87 187.47,34.75 187.58,34.49 187.84,34.39 187.98,34.41 188.1,34.5 188.35,34.5 188.36,34.46 188.37,34.43 188.4,34.39 188.4,34.29 188.32,34.21 187.82,34.21 187.75,34.19 187.71,34.13 187.7,34.09 187.57,34.09 187.38,33.9 187.38,33.28 187.56,33.09 187.7,33.09 187.71,33.06 187.72,33.03 187.74,33.01 187.77,32.94 187.74,32.87 187.72,32.84 187.71,32.79 187.71,32.41 187.23,32.41 187.23,32.79 187.22,32.84 187.2,32.87 187.17,32.94 187.2,33.01 187.22,33.05 187.23,33.09 187.23,33.44 187.19,33.53 187.11,33.56 186.4,33.56 186.2,33.76 186.2,34.15 186.24,34.2 186.26,34.2 186.59,34.57 186.26,34.93 186.24,34.93 186.2,34.98 186.2,35.16 186.37,35.33 186.42,35.31 186.43,35.3 186.55,35.22 186.69,35.2 186.92,35.28 187.05,35.49 187.06,35.53
GND on TOP (solid shape): outline of 140 points within 205.38,105.94 209.57,108.79
GND on TOP (solid shape): outline of 90 points within 135.74,72.8 137.48,76.83
GND on TOP (solid shape): 210.64,112.01 210.87,111.86 211.14,111.8 211.56,111.8 211.65,111.78 211.73,111.73 211.73,111.47 210.84,111.47 210.84,111.45 210.77,111.45 210.47,111.15 209.57,111.15 209.29,111.1 209.04,110.93 208.97,110.89 208.89,110.93 208.28,110.86 208.65,110.36 208.73,110.34 208.76,110.26 208.76,110.08 208.74,110.06 208.03,110.06 208.01,110.07 207.98,110.09 207.94,110.09 207.88,110.09 207.86,110.12 207.51,110.35 207.1,110.28 206.22,110.28 206.14,110.36 206.14,110.68 206.21,111.01 206.38,111.3 207.34,111.3 207.35,111.29 207.36,111.3 207.39,111.27 207.57,111.16 207.77,111.13 208.05,111.2 208.26,111.39 208.28,111.41 208.33,111.41 208.4,111.44 208.43,111.52 208.43,111.61 208.48,111.61 208.54,111.6 208.59,111.59 208.68,111.58 208.77,111.58 208.99,111.58 209.12,111.45 209.78,111.45 210.34,112.01
GND on TOP (solid shape): 18.72,13.9 18.74,13.9 18.82,13.86 18.83,13.77 18.82,13.72 18.85,13.51 18.95,13.38 18.95,13.17 19.04,13.07 19.04,11.72 19.05,11.68 19.04,11.61 18.98,11.56 18.94,11.58 18.85,11.58 18.81,11.57 18.77,11.61 18.76,11.66 18.76,12.01 18.54,12.23 18.44,12.23 18.34,12.3 18.37,12.41 18.47,12.54 18.51,12.7 18.47,12.86 18.36,12.99 18.32,13.08 18.36,13.16 18.47,13.29 18.51,13.46 18.14,13.83 17.77,13.46 17.81,13.29 17.93,13.16 17.97,13.08 17.93,12.99 17.81,12.86 17.77,12.7 17.81,12.54 17.91,12.41 17.94,12.3 17.85,12.23 17.47,12.23 17.47,13.54 17.36,13.65 17.36,13.74 17.35,13.79 17.35,13.87 17.36,13.92 17.36,14.07 17.44,14.16 18.47,14.16
GND on TOP (solid shape): 165.69,9.41 166.23,9.41 166.76,8.88 166.76,8.88 166.86,8.78 170.05,8.78 170.26,8.57 170.85,8.57 170.89,8.53 170.89,7.57 172.64,5.81 172.85,5.81 172.88,5.81 173.26,5.81 173.29,5.81 173.5,5.81 173.7,6.02 174.25,6.02 174.36,5.92 174.36,5.49 174.36,5.48 174.36,4.99 174.7,4.65 174.82,4.57 174.97,4.54 175.23,4.65 175.33,4.91 175.31,5.05 175.23,5.17 175.1,5.3 175.1,5.37 175.22,5.49 175.22,5.59 175.28,5.68 175.39,5.66 175.86,5.19 175.9,5.19 175.99,5.13 175.97,5.01 174.79,3.84 174.79,3.25 174.64,3 174.71,2.72 174.73,2.61 174.63,2.55 172.8,2.55 171.86,3.49 171.14,5.54 169.59,7.1 168.15,7.75 164.25,7.75 164.16,7.8 164.17,7.91 164.06,8.41 163.56,8.32 163.48,8.28 163.39,8.32 163.26,8.43 163.09,8.47 162.96,8.6 162.96,10.13 163.4,10.56 164.54,10.56
GND on TOP (solid shape): 44.52,76.92 44.48,76.84 44.39,76.82 44.35,76.83 44.32,76.83 44.07,76.73 43.97,76.48 44.02,76.3 44.16,76.18 44.22,76.09 44.17,76 44.04,75.87 44,75.7 44.1,75.46 44.34,75.36 44.4,75.36 44.46,75.38 44.52,75.38 44.52,75.22 44.45,75.22 44.38,75.24 44.07,75.15 43.97,74.9 43.94,74.83 43.87,74.8 43.47,74.8 43,74.33 42.96,74.36 42.86,74.42 42.69,74.44 42.63,74.43 42.57,74.43 42.57,74.57 42.63,74.57 42.69,74.56 42.74,74.55 43.09,74.9 42.74,75.24 42.69,75.24 42.62,75.25 42.58,75.3 42.73,75.46 43.29,75.46 43.71,75.87 43.71,76.37 43.71,76.38 43.71,77.2 43.76,77.2 43.97,77.32 44.06,77.54 44.06,77.6 44.52,77.6
GND on TOP (solid shape): 207.86,5.51 207.86,5.04 207.95,4.95 208.12,4.95 208.2,4.87 208.2,4.27 208.08,4.15 208,4.11 207.95,4.07 207.79,3.93 207.73,3.73 207.74,3.67 207.75,3.61 207.76,3.58 207.65,3.46 207.54,3.46 207.49,3.41 207.42,3.41 207.27,3.35 207.21,3.2 207.21,3.02 207.2,3.02 207.2,2.53 207.16,2.44 207.15,2.33 207.17,2.2 207.24,2.09 207.26,1.98 207.16,1.92 206.07,1.92 205.74,2.25 205.96,2.47 206.04,2.5 206.11,2.46 206.24,2.36 206.4,2.32 206.66,2.43 206.77,2.69 206.75,2.79 206.71,2.88 206.7,2.97 206.76,3.03 206.93,3.17 207,3.38 206.89,3.64 206.63,3.74 206.57,3.74 206.57,4.3 206.72,4.43 206.77,4.62 206.66,4.89 206.4,4.99 206.34,4.99 206.25,5.02 206.23,5.12 206.23,5.15 206.24,5.18 206.24,5.48 206.37,5.62 207.75,5.62
GND on TOP (solid shape): 138.79,75.22 138.86,75.19 138.89,75.12 138.9,75.07 138.91,75.01 138.96,74.97 138.94,74.88 138.86,74.85 138.85,74.85 138.77,74.82 138.74,74.75 138.74,74.54 138.77,74.47 138.85,74.44 139.23,74.44 139.27,74.45 139.3,74.47 139.31,74.49 139.62,74.49 139.84,74.71 139.9,74.7 139.94,74.69 140,74.7 140.06,74.72 140.19,74.85 140.25,74.87 140.3,74.85 140.45,74.71 140.51,74.69 140.57,74.68 140.65,74.69 140.71,74.63 140.74,74.56 140.7,74.49 140.61,74.49 140.51,74.41 140.43,74.31 140.43,74.05 140.51,73.95 140.61,73.88 140.81,73.88 140.9,73.79 140.92,73.68 140.83,73.61 140.66,73.61 140.58,73.6 140.51,73.57 140.5,73.57 140.02,73.57 139.31,72.86 139.31,72.82 139.3,72.79 139.25,72.75 138.97,73.03 138.97,73.1 138.94,73.17 138.87,73.2 138.49,73.2 138.42,73.17 138.39,73.1 138.39,72.9 138.42,72.83 138.49,72.8 138.6,72.8 138.6,72.71 138.58,72.7 138.5,72.65 138.45,72.59 138.31,72.59 138.26,72.62 138.28,72.68 138.28,75.02 138.22,75.07 138.21,75.13 138.26,75.16 138.28,75.16 138.34,75.22
GND on TOP (solid shape): outline of 86 points within 101.91,81.41 103.5,85.5
GND on TOP (solid shape): 84.67,110.83 84.75,110.81 84.79,110.73 84.79,110.67 85.03,110.43 85.27,110.67 85.27,110.83 85.42,110.83 85.57,110.68 85.58,110.68 85.74,110.52 85.89,110.52 85.91,110.5 85.93,110.47 85.96,110.44 85.96,110.28 86.62,109.63 89.34,109.63 89.34,109.47 89.05,109.47 88.97,109.44 88.94,109.36 88.94,109.26 88.41,108.73 88.34,108.7 88.27,108.72 88.16,108.79 88.02,108.82 87.81,108.75 87.68,108.58 87.67,108.54 87.58,108.54 87.58,108.55 86.97,108.55 86.94,108.54 86.89,108.56 86.88,108.6 86.88,108.63 86.88,109.25 86.4,109.25 86.37,109.25 85.38,109.25 85.28,109.31 85.3,109.42 85.37,109.53 85.39,109.66 85.28,109.92 85.02,110.03 84.88,110 84.77,109.93 84.69,109.9 84.62,109.94 84.52,110.02 84.4,110.06 84.32,110.13 84.34,110.23 84.47,110.36 84.47,110.67 84.47,110.72 84.49,110.81 84.58,110.83
GND on TOP (solid shape): outline of 123 points within 140.58,64.32 142.24,66.7
GND on TOP (solid shape): 204.66,93.62 204.66,93.61 204.96,93.23 205.42,93.09 205.57,93.1 205.72,93.15 205.82,93.13 205.86,93.05 205.86,90.75 205.82,90.66 205.72,90.65 205.57,90.7 205.42,90.71 205,90.6 204.7,90.28 204.66,90.23 204.6,90.22 204.5,90.32 204.53,90.36 204.68,90.61 204.73,90.9 204.5,91.48 203.92,91.71 203.45,91.56 203.15,91.17 203.12,91.12 203.06,91.1 202.11,92.04 201.69,92.04 201.64,92.1 201.67,92.17 201.74,92.2 202.55,92.2 202.99,92.64 203.09,92.67 203.16,92.61 203.46,92.23 203.92,92.09 204.5,92.32 204.73,92.9 204.68,93.2 204.52,93.45 204.5,93.56 204.58,93.62 204.61,93.66
GND on TOP (solid shape): outline of 84 points within 135.27,59.15 136.65,68.48
GND on TOP (solid shape): 155.39,51.97 155.46,51.95 155.57,51.88 155.7,51.85 155.83,51.88 155.94,51.94 156,51.91 156,51.82 156.03,51.74 156.11,51.7 156.63,51.7 156.63,50.29 156.58,50.24 156.57,50.23 156.37,50.1 156.3,49.88 156.4,49.62 156.67,49.51 156.89,49.59 157.02,49.78 157.03,49.8 157.09,49.86 157.2,49.88 157.26,49.79 157.26,49.58 157.29,49.5 157.37,49.47 157.85,49.47 157.85,48.69 157.77,48.6 157.25,48.6 157.19,48.66 156.83,48.66 156.76,48.7 156.73,48.78 156.74,48.81 156.74,48.85 156.63,49.11 156.37,49.22 156.22,49.19 156.1,49.1 156.03,49.07 155.96,49.1 155.93,49.12 155.93,49.63 154.96,50.6 153.77,50.6 153.76,50.59 153.7,50.58 153.67,50.62 153.67,51.84 153.74,51.94 153.85,51.9 154.05,51.74 154.3,51.68 154.55,51.74 154.75,51.89 154.81,51.93 154.88,51.92 154.98,51.87 155.08,51.86 155.21,51.88 155.32,51.95
GND on TOP (solid shape): outline of 150 points within 137.88,68.79 140.4,70.6
GND on TOP (solid shape): 193.85,74.01 193.94,73.96 193.94,73.85 193.91,73.79 193.9,73.73 193.9,73.45 193.91,73.37 193.96,73.3 193.98,73.23 193.95,73.16 193.82,73.03 193.82,71.88 194.09,71.6 195.18,71.6 195.18,71.48 195.14,71.45 194.98,70.96 195.3,70.54 195.35,70.45 195.3,70.36 195.25,70.32 195.2,70.28 195.09,70.25 195.02,70.34 195.02,70.53 194.97,70.59 194.97,70.6 194.7,70.87 194.64,70.87 194.63,70.88 194.59,70.9 194.55,70.91 194.17,70.91 194.09,70.91 194.05,70.9 194.02,70.88 194.01,70.87 193.67,70.87 193.51,70.71 193.41,70.68 193.34,70.77 193.08,71.08 192.69,70.96 192.57,70.92 192.51,71.02 192.51,71.43 192.47,71.51 192.39,71.55 191.86,71.55 191.81,71.53 191.77,71.5 191.69,71.46 191.61,71.49 191.53,71.57 191.33,71.57 191.22,71.65 191.08,71.67 190.95,71.65 190.83,71.57 190.59,71.57 190.59,71.61 190.55,71.68 190.48,71.71 190.28,71.71 190.25,71.71 190.17,71.73 190.14,71.81 190.14,72.42 190.46,72.74 191.24,72.74 191.36,72.86 192.83,72.86 193.02,73.04 193.02,73.8 193.23,74.01
GND on TOP (solid shape): 144.16,56.51 144.22,56.49 144.34,56.41 144.48,56.38 144.53,56.38 144.57,56.39 144.66,56.37 144.7,56.29 144.7,55.99 144.73,55.91 144.81,55.88 144.96,55.88 144.96,55.79 144.89,55.69 144.78,55.72 144.66,55.81 144.51,55.84 144.25,55.73 144.14,55.47 144.14,55.43 144.16,55.36 144.03,55.24 144.03,55.16 144.02,55.14 144,55.1 143.99,55.06 143.99,54.68 143.99,54.65 144.03,54.58 144.01,54.54 143.95,54.43 143.94,54.22 143.96,54.14 143.96,54.04 143.87,54 143.05,54 142.44,54.6 142.47,54.64 142.51,54.73 142.53,54.84 142.47,55.02 142.33,55.16 142.33,55.9 142.37,55.91 142.4,55.92 142.43,55.94 142.48,55.9 142.48,55.85 142.56,55.62 142.77,55.49 142.83,55.45 142.86,55.38 142.85,55.35 142.96,55.09 143.22,54.99 143.48,55.09 143.59,55.35 143.58,55.44 143.55,55.51 143.55,55.59 143.59,55.65 143.63,55.69 143.65,55.74 143.65,56.12 143.64,56.17 143.62,56.2 143.6,56.22 143.6,56.32 143.6,56.42 143.69,56.48 144.03,56.48 144.06,56.48 144.1,56.5
GND on TOP (solid shape): outline of 81 points within 200.38,42.37 216.83,47.42
GND on TOP (solid shape): 149,17.36 148.97,17.32 148.91,17.21 148.89,17.09 148.99,16.82 149.25,16.72 149.34,16.73 149.41,16.75 149.51,16.75 149.56,16.66 149.56,16.58 149.92,16.22 149.92,16.07 149.89,16.02 149.83,16.03 149.8,16.06 149.67,16.06 149.64,16.07 149.26,16.07 149.23,16.06 146.48,16.06 146.3,16.24 146.22,16.24 146.04,16.43 146.04,16.93 146.03,16.97 146,17.01 145.98,17.02 145.98,17.29 146.06,17.4 146.09,17.54 145.98,17.8 145.72,17.91 145.58,17.88 145.46,17.8 145.39,17.77 145.31,17.81 145.19,17.89 145.05,17.92 144.78,17.82 144.68,17.48 144.71,17.41 144.72,17.37 144.23,16.88 144.13,16.85 144.06,16.91 143.92,17.09 143.71,17.16 143.45,17.05 143.35,16.71 143.38,16.63 143.39,16.6 142.92,16.13 142.92,16.11 142.92,15.92 142.83,15.83 142.63,15.83 142.55,15.76 142.53,15.76 142.45,15.72 142.42,15.65 142.42,15.62 142.19,15.4 142.19,15.23 141.93,14.96 141.51,14.96 141.43,15 141.4,15.07 141.4,15.13 141.42,15.21 141.5,15.25 141.66,15.26 141.73,15.32 141.88,15.47 141.88,15.59 142.69,16.39 142.69,16.4 142.69,17.1 143.67,18.07 148.28,18.07
GND on TOP (solid shape): 124.17,23.13 124.24,22.85 124.19,22.76 124.18,22.72 124.17,22.68 124.16,22.65 124.12,22.63 123.88,22.52 123.79,22.27 123.9,22.01 124.16,21.9 124.34,21.95 124.48,22.09 124.57,22.14 124.66,22.09 124.79,21.95 124.98,21.9 125.06,21.91 125.14,21.93 125.18,21.94 125.21,21.92 125.24,21.87 125.3,21.83 125.38,21.76 125.43,21.65 125.43,21.6 125.42,21.55 125.42,21.49 125.41,21.43 125.4,21.34 125.44,21.25 125.44,21.14 125.35,21.09 122.83,21.09 122.83,21.17 122.85,21.18 122.88,21.21 122.91,21.24 122.94,21.26 122.98,21.25 123.07,21.21 123.18,21.2 123.54,21.57 123.18,21.94 123.13,21.93 123.08,21.92 123.04,21.92 123.02,21.94 122.99,21.98 122.94,22.06 122.93,22.15 122.92,22.18 122.92,22.22 122.94,22.3 123.01,22.4 123.05,22.49 123.09,22.48 123.13,22.47 123.18,22.47 123.44,22.58 123.54,22.84 123.56,22.87 123.59,22.89 123.7,22.93 123.76,23.03 123.81,23.1 123.87,23.15
GND on TOP (solid shape): outline of 101 points within 24.89,49.39 29.02,54.34
GND on TOP (solid shape): 70.13,92.28 70.13,91.84 70.64,91.34 71.8,91.34 72.95,90.19 73.25,90.19 73.32,90.16 73.35,90.08 73.35,90.07 73.46,89.81 73.72,89.7 73.95,89.78 74.08,89.99 74.12,90.06 74.19,90.08 74.22,90.07 74.42,90.13 74.56,90.29 74.57,90.33 74.6,90.36 74.65,90.36 74.71,90.33 74.79,90.31 74.87,90.25 74.85,90.14 72.05,87.35 72.05,87.04 72.05,87.04 72.05,86.16 72.02,86.07 72.02,86 72.36,85.66 72.7,86 72.7,86.07 72.67,86.15 72.67,86.78 72.71,86.83 72.83,86.85 72.89,86.75 72.89,86.17 72.86,86.1 72.86,86.03 72.88,85.9 72.95,85.79 72.96,85.79 72.98,85.74 72.59,85.35 72.59,84.84 72.55,84.76 72.46,84.74 72.42,84.75 72.38,84.75 72.12,84.64 72.01,84.38 72.02,84.31 72.04,84.24 72.03,84.15 71.94,84.11 71.89,84.11 71.85,84.13 71.84,84.17 71.89,84.28 71.9,84.38 71.88,84.51 71.81,84.62 71.8,84.63 71.8,84.71 71.81,84.72 71.89,84.84 71.92,84.99 71.87,85.18 71.71,85.32 71.7,85.32 71.46,85.56 71.46,88.72 69.42,90.77 69.42,92.43 69.54,92.56 69.85,92.56
GND on TOP (solid shape): 183.49,40.12 183.51,40.03 183.46,39.96 183.24,39.62 183.45,39.29 183.5,39.24 183.5,39.16 183.5,38.9 183.68,38.71 183.68,38.44 183.54,38.31 183.48,38.12 183.59,37.87 183.85,37.76 183.91,37.76 184.37,37.3 184.4,37.2 184.33,37.13 184.27,37.13 184.21,37.13 183.98,37.13 183.93,37.13 183.75,37.13 183.64,37.02 183.53,37.13 183.35,37.13 183.3,37.13 183.07,37.13 183.01,37.13 182.84,37.13 182.67,36.97 182.39,36.69 182.39,36.49 182.33,36.39 182.22,36.42 182.02,36.61 181.77,36.61 181.77,36.65 181.48,36.94 181.11,36.77 180.27,36.77 180.23,36.73 180.12,36.71 180.06,36.81 179.75,37.2 179.33,36.94 179.26,36.87 179.16,36.9 179.05,37.01 178.78,37.01 178.76,37.05 178.73,37.09 178.71,37.2 178.8,37.25 179.22,37.25 179.22,38.35 180.32,38.35 180.32,38.76 180.31,38.76 180.31,38.81 180.32,38.88 180.35,38.93 180.4,38.92 180.45,38.87 180.45,38.35 180.74,38.06 180.99,38.06 181.02,38.07 181.32,38.07 181.35,38.06 182.13,38.06 182.16,38.07 182.46,38.07 182.5,38.06 182.64,38.06 182.91,38.33 182.91,40.31 183.3,40.31
GND on TOP (solid shape): outline of 90 points within 199.24,73.11 201.58,76.73
GND on TOP (solid shape): outline of 98 points within 150.01,5.82 160.61,8.18
GND on TOP (solid shape): outline of 154 points within 86.8,68.83 105.88,98.75
GND on TOP (solid shape): outline of 91 points within 140.33,54.93 141.99,59.61
GND on TOP (solid shape): outline of 85 points within 123.92,16.26 134.54,18.44
GND on TOP (solid shape): outline of 222 points within 152.35,43.23 156.68,47.8
GND on TOP (solid shape): outline of 106 points within 179.63,93.23 184.62,99.27
GND on TOP (solid shape): outline of 212 points within 126.98,86.05 129.26,91.27
GND on TOP (solid shape): outline of 138 points within 188.05,32.64 192.16,35.88
GND on TOP (solid shape): outline of 111 points within 159.47,85.74 166.58,89.77
GND on TOP (solid shape): outline of 217 points within 164.46,12.32 175.92,18.34
GND on TOP (solid shape): outline of 158 points within 162.17,60.44 166.11,65.3
GND on TOP (solid shape): outline of 88 points within 109.91,11.88 116.79,17.85
GND on TOP (solid shape): outline of 112 points within 177.67,23.19 182.55,30.58
GND on TOP (solid shape): outline of 131 points within 22.96,28.21 29.65,36.26
GND on TOP (solid shape): outline of 99 points within 199.95,74.8 206.34,80.87
GND on TOP (solid shape): outline of 149 points within 21.56,42.25 26.62,49.83
GND on TOP (solid shape): outline of 151 points within 185.4,93.78 189.19,99.01
GND on TOP (solid shape): outline of 118 points within 118.68,80.72 124.4,84.2
GND on TOP (solid shape): outline of 139 points within 125.34,81.25 127.68,84.07
GND on TOP (solid shape): outline of 148 points within 151.8,58.64 160.9,66.4
GND on TOP (solid shape): outline of 297 points within 202.67,13.25 206.16,23.23
GND on TOP (solid shape): outline of 179 points within 19.42,5.15 31.6,13.75
GND on TOP (solid shape): outline of 152 points within 159.71,67.9 165.14,71.91
GND on TOP (solid shape): outline of 239 points within 103.36,77.27 119.33,81.08
GND on TOP (solid shape): outline of 283 points within 137.14,58.29 141.14,68.96
GND on TOP (solid shape): outline of 328 points within 75.33,79.75 83.78,87.39
GND on TOP (solid shape): outline of 164 points within 14.71,38.94 21.84,47.34
GND on TOP (solid shape): outline of 334 points within 103.21,21.04 110.94,28.74
GND on TOP (solid shape): outline of 91 points within 204.49,47.25 207.99,55.94
GND on TOP (solid shape): outline of 395 points within 197.75,94.54 218.33,105.96
GND on TOP (solid shape): outline of 195 points within 93.67,70.77 98.89,76.59
GND on TOP (solid shape): outline of 165 points within 103.16,84.83 113.76,91.97
GND on TOP (solid shape): outline of 188 points within 193.04,3.07 198.91,11.87
GND on TOP (solid shape): outline of 382 points within 92.3,67.6 105.46,71.91
GND on TOP (solid shape): outline of 390 points within 24.62,38.52 33.9,45.42
GND on TOP (solid shape): outline of 203 points within 96.45,10.64 106.12,18.63
GND on TOP (solid shape): outline of 493 points within 167.65,12.88 185.84,24.04
GND on TOP (solid shape): outline of 229 points within 184.4,1.53 205.4,6.43
GND on TOP (solid shape): outline of 514 points within 147.46,52.19 159.41,65.07
GND on TOP (solid shape): outline of 173 points within 53.96,2.42 61.33,11.7
GND on TOP (solid shape): outline of 521 points within 166.13,56.22 174.16,65.84
GND on TOP (solid shape): outline of 541 points within 43.6,37.52 52.82,54.24
GND on TOP (solid shape): outline of 603 points within 6.83,7.95 11.33,23.6
GND on TOP (solid shape): outline of 616 points within 133.97,8.4 142.44,18.3
GND on TOP (solid shape): outline of 685 points within 87.33,69.77 120.63,100.94
GND on TOP (solid shape): outline of 691 points within 127.44,69.44 141.98,80.98
GND on TOP (solid shape): outline of 844 points within 32.87,60.03 40.66,75.93
GND on TOP (solid shape): outline of 787 points within 166.94,65.88 182.62,74.74
GND on TOP (solid shape): outline of 734 points within 135.16,82.83 144.44,92.49
GND on TOP (solid shape): outline of 951 points within 154.13,100.57 218.33,119.74
GND on TOP (solid shape): outline of 1026 points within 60.72,51.43 83.27,71.28
GND on TOP (solid shape): outline of 1000 points within 116.62,5.62 134.89,16.18
GND on TOP (solid shape): outline of 1057 points within 142.35,48.64 153.19,67.17
GND on TOP (solid shape): outline of 1105 points within 53.13,2.97 89.85,19.03
GND on TOP (solid shape): outline of 1140 points within 187.19,52.21 214.83,71.25
GND on TOP (solid shape): outline of 1207 points within 175.37,42.35 198.89,65.8
GND on TOP (solid shape): outline of 1206 points within 90.45,93.34 134.25,108.79
GND on TOP (solid shape): outline of 1377 points within 26.05,20.39 73.72,60.6
GND on TOP (solid shape): outline of 1729 points within 13.46,6.67 46.03,24.77
GND on TOP (solid shape): outline of 1863 points within 49.7,56.83 67.84,83.23
GND on TOP (solid shape): outline of 7787 points within 0.51,0.51 217.53,113.89
GND on BOTTOM (solid shape): 39.92,9.8 39.92,8.3 39.67,8.05 38.94,8.05 38.78,8.2 38.78,8.79 39.06,9.07 39.06,9.8 39.16,9.9 39.82,9.9
GND on BOTTOM (solid shape): 90.6,77.9 90.6,76.81 90.55,76.76 90.22,76.76 90.21,76.77 90.16,76.77 89.28,77.65 89.28,77.9 89.36,77.98 90.52,77.98
GND on BOTTOM (solid shape): 203.87,50.1 203.87,48.48 203.69,48.3 203.69,47.51 203.6,47.42 203.39,47.42 203.29,47.52 203.29,50.02 203.51,50.24 203.73,50.24
GND on BOTTOM (solid shape): 175.97,84.15 176.35,84.15 176.4,84.1 176.4,82.98 175.72,82.29 175.72,82.09 175.69,82.07 175.46,82.07 175.41,82.12 175.41,83.25 175.09,83.57 175.09,84.21 175.41,84.53 175.59,84.53
GND on BOTTOM (solid shape): 216.74,12.95 216.74,11.91 216.61,11.78 215.82,11.78 215.8,11.76 215.8,10.34 215.39,9.93 214.4,9.93 214.25,10.08 214.25,11.91 214.07,12.09 213.21,12.09 212.93,12.37 212.93,12.77 213.26,13.1 216.58,13.1
GND on BOTTOM (solid shape): 200.68,16.1 200.68,15.82 199.49,14.63 197.53,14.63 197.41,14.76 197.41,15.09 197.48,15.16 199.39,15.16 199.83,15.61 199.9,15.65 199.94,15.71 200.02,15.8 200.02,16.1 200.1,16.18 200.61,16.18
GND on BOTTOM (solid shape): 154.51,101.67 154.51,101.21 154.48,101.17 154.48,100.91 154.51,100.87 154.51,100.78 154.38,100.66 154.38,100.28 154.25,100.15 153.62,100.15 153.49,100.28 153.49,101.17 153.62,101.29 153.62,101.67 153.74,101.8 154.38,101.8
GND on BOTTOM (solid shape): 82.82,65.77 82.91,65.71 82.89,65.6 82.55,65.25 80.22,65.25 80.13,65.32 80.15,65.43 80.49,65.77
GND on BOTTOM (solid shape): 162.49,64.76 162.56,64.85 162.67,64.83 162.91,64.58 163.15,64.58 163.15,61.46 163.08,61.36 162.97,61.39 162.49,61.86
GND on BOTTOM (solid shape): 67.89,92.31 68.16,92.31 68.36,92.11 68.36,91.24 69.31,90.29 69.31,88.44 69.25,88.35 69.13,88.37 68.72,88.79 68.72,90.26 67.8,91.18 67.8,92.31
GND on BOTTOM (solid shape): 80.31,84.31 80.31,82.97 80.27,82.88 80.18,82.87 80.08,82.89 80.08,84.14 79.72,84.5 79.32,84.5 79,84.81 78.15,84.81 77.83,84.5 77.71,84.5 77.38,84.82 77.38,85 77.45,85.06 79.56,85.06
GND on BOTTOM (solid shape): 149.92,54.63 153.14,54.63 153.79,53.99 153.81,53.88 153.72,53.81 153.38,53.81 153.17,54.02 148.02,54.02 147.49,54.55 147.48,54.6 147.53,54.63 147.97,55.07 149.48,55.07
GND on BOTTOM (solid shape): 48,12.82 48,11.54 48.01,11.53 48.02,11.48 47.98,11.45 47.52,11.45 47.52,11.83 47.5,11.85 47.5,11.87 47.4,12.07 47.2,12.17 47.19,12.17 46.89,12.47 46.89,12.8 47.01,12.93 47.9,12.93
GND on BOTTOM (solid shape): 50.98,80.19 51.08,80.11 51.21,80.06 51.28,79.99 51.26,79.89 51.05,79.69 51.05,78.73 51.02,78.68 50.96,78.69 50.93,78.73 50.43,78.73 50.43,79.67 50.38,79.72 50.92,80.25
GND on BOTTOM (solid shape): 140.4,21.78 140.45,21.86 140.54,21.87 140.61,21.85 140.68,21.84 140.72,21.85 140.79,21.86 141.02,21.63 141.02,21.19 140.99,21.17 140.97,21.15 140.95,21.12 140.94,21.09 140.8,21.09 140.8,19.49 140.55,19.49 140.55,21.09 140.4,21.09
GND on BOTTOM (solid shape): 118.33,21.84 118.39,21.93 118.49,21.93 118.58,21.89 118.68,21.87 118.71,21.88 118.77,21.89 118.95,21.71 118.95,21.09 118.8,21.09 118.8,19.49 118.55,19.49 118.55,21.09 118.41,21.09 118.4,21.12 118.38,21.15 118.36,21.17 118.33,21.19
GND on BOTTOM (solid shape): 88.61,67.92 88.83,67.69 88.81,67.66 88.79,67.62 88.79,67.59 88.79,67.38 88.81,67.31 88.87,67.27 88.87,66.77 88.52,66.42 88.17,66.42 88.07,66.52 88.07,68.15 88.04,68.22 88.08,68.29 88.14,68.36 88.18,68.45 88.19,68.49 88.61,68.49
GND on BOTTOM (solid shape): 117.96,22.37 118.02,22.28 118.02,21.19 117.99,21.17 117.97,21.15 117.95,21.12 117.94,21.09 117.8,21.09 117.8,19.49 117.55,19.49 117.55,21.09 117.41,21.09 117.4,21.12 117.38,21.15 117.36,21.17 117.33,21.19 117.33,22.1 117.56,22.33 117.63,22.32 117.68,22.31 117.77,22.33 117.86,22.37
GND on BOTTOM (solid shape): 138.33,21.79 138.39,21.88 138.49,21.88 138.58,21.84 138.68,21.83 138.72,21.83 138.79,21.84 139.02,21.62 139.02,21.19 138.99,21.17 138.97,21.15 138.95,21.12 138.94,21.09 138.8,21.09 138.8,19.49 138.55,19.49 138.55,21.09 138.41,21.09 138.4,21.12 138.38,21.15 138.36,21.17 138.33,21.19
GND on BOTTOM (solid shape): 170.6,82.09 170.6,80.49 170.44,80.34 168.94,80.34 168.67,80.61 168.67,81.16 168.72,81.25 168.81,81.26 168.87,81.24 168.93,81.24 169.19,81.35 169.3,81.61 169.3,81.67 169.28,81.74 169.27,81.77 169.68,82.18 170.51,82.18
GND on BOTTOM (solid shape): 54.57,50.69 54.59,50.57 54.49,50.52 54.46,50.52 54.21,50.41 54.1,50.15 54.07,50.08 54,50.05 53.53,50.05 52.97,50.61 52.98,50.62 52.98,50.75 54.51,50.75
GND on BOTTOM (solid shape): 188.08,18.42 188.11,18.35 188.09,18.29 188.06,18.22 188.05,18.16 188.05,17.87 188.07,17.78 188.13,17.71 188.17,17.63 188.13,17.55 187.44,17.55 187.42,17.56 187.39,17.63 187.32,17.66 187.05,17.66 187.05,18.31 186.92,18.43 187.23,18.74 187.76,18.74
GND on BOTTOM (solid shape): 163.34,59.95 163.44,59.89 163.41,59.78 163.31,59.67 163.31,56.52 163.73,56.09 164.24,56.09 164.33,56.05 164.34,55.96 164.33,55.91 164.32,55.85 164.34,55.74 164.39,55.64 163.28,54.52 163.17,54.5 163.1,54.59 163.1,59.95
GND on BOTTOM (solid shape): 61.79,8.64 61.9,8.66 61.96,8.57 61.96,8.51 62.19,8.28 63.58,8.28 63.65,8.35 63.71,8.36 63.74,8.31 63.74,6.35 64.6,5.49 64.62,5.38 64.53,5.32 61.95,5.32 60.93,6.33 60.98,6.39 61.21,6.39 61.38,6.55 61.38,8.23
GND on BOTTOM (solid shape): 32.37,91.82 32.43,91.92 32.54,91.9 32.91,91.53 32.91,90.17 32.53,90.17 32.39,90.31 32.2,90.36 32.11,90.35 32.02,90.32 31.92,90.32 31.87,90.4 31.87,90.62 31.98,90.72 31.99,90.75 32.04,90.83 32.12,90.88 32.15,90.9 32.37,91.12
GND on BOTTOM (solid shape): 141.01,14.04 141.02,13.98 140.99,13.9 140.98,13.82 141.09,13.55 141.35,13.45 141.38,13.42 141.38,13.08 141.3,13 140.17,13 140.12,13.05 140.12,13.43 140.16,13.52 140.18,13.62 140.17,13.66 140.16,13.73 140.48,14.04 140.91,14.04 140.96,14.05
GND on BOTTOM (solid shape): 112.71,63.23 112.76,63.24 112.8,63.2 112.8,63.04 112.69,62.94 112.67,62.9 112.66,62.86 112.66,62.4 112.67,62.36 112.69,62.32 112.74,62.27 112.74,62.07 112.13,61.46 112.05,61.46 112.05,62 112.42,62.36 112.44,62.4 112.45,62.44 112.45,62.74 112.44,62.78 112.39,62.9 112.39,63 112.47,63.14 112.53,63.21 112.64,63.21 112.69,63.22
GND on BOTTOM (solid shape): 85.07,98.48 85.06,98.41 85.05,98.37 85.08,98.22 85.17,98.1 85.17,97.36 84.63,97.36 84.58,97.35 84.49,97.36 84.44,97.44 84.44,98.1 83.89,98.66 83.86,98.77 83.96,98.83 83.98,98.83 84.11,98.88 84.19,98.99 84.2,99.03 84.52,99.03
GND on BOTTOM (solid shape): 146.11,53.35 146.2,53.29 146.18,53.17 146.09,53.05 146.06,52.91 146.06,52.86 146.08,52.8 145.98,52.7 139.6,52.7 139.53,52.77 139.51,52.88 139.61,52.94 145.08,52.94 145.26,53.12 145.29,53.12 145.48,53.18 145.61,53.32 145.63,53.35
GND on BOTTOM (solid shape): 30.56,41.11 30.67,41.14 30.74,41.04 30.74,40.03 30.43,39.72 30.43,39.64 30.22,39.44 30.22,39.23 30.22,39.2 30.22,38.9 30.2,38.82 30.12,38.8 30.05,38.8 29.89,38.63 29.72,38.63 29.7,38.61 29.63,38.64 29.63,39.47 29.79,39.62 29.95,39.62 30.03,39.65 30.06,39.73 30.06,40.11 30.06,40.16 30.03,40.19 30.02,40.21 30.02,40.7 30.39,41.08 30.52,41.08
GND on BOTTOM (solid shape): 134.71,63.83 134.75,63.78 134.8,63.74 134.8,63.65 134.82,63.63 134.85,63.55 134.81,63.48 134.75,63.42 134.73,63.34 134.73,63.27 134.56,63.1 134.56,62.46 134.67,62.35 134.67,62.09 134.63,62.01 134.54,61.99 134.5,62 134.45,62.01 134.42,62.01 134.35,61.99 134.22,62.13 134.22,62.73 134.15,62.9 134.15,63 134.22,63.14 134.29,63.21 134.44,63.21 134.61,63.38 134.61,63.85 134.69,63.85
GND on BOTTOM (solid shape): 164.91,79.13 164.97,79.22 165.08,79.2 165.71,78.58 166.23,78.58 166.4,78.4 166.42,78.4 166.43,78.37 166.46,78.34 166.5,78.31 166.53,78.3 166.53,78.23 167.45,78.23 167.5,78.18 167.5,78.01 167.41,77.92 166.53,77.92 166.53,77.85 166.47,77.82 166.4,77.81 166.34,77.84 166.11,77.84 165.99,77.91 165.85,77.94 165.8,77.94 165.75,77.92 165.72,77.92 164.91,78.72
GND on BOTTOM (solid shape): 168.23,21.88 168.31,21.95 168.4,21.91 168.53,21.82 168.68,21.79 168.77,21.8 168.86,21.84 168.96,21.84 169.02,21.75 169.02,21.19 168.99,21.17 168.97,21.15 168.95,21.12 168.94,21.09 168.8,21.09 168.8,19.34 168.55,19.34 168.55,21.09 168.41,21.09 168.4,21.12 168.38,21.15 168.36,21.17 168.33,21.19 168.33,21.26 168.23,21.37
GND on BOTTOM (solid shape): 46.54,75.81 46.64,75.84 46.71,75.76 46.73,75.69 46.62,75.58 46.62,75.33 46.35,75.05 45.04,75.05 44.77,74.78 44.67,74.81 44.65,74.89 44.65,74.92 44.67,74.99 44.74,75.02 44.94,75.1 45.02,75.3 45.02,75.33 45.24,75.54 46.27,75.54
GND on BOTTOM (solid shape): 29.5,92.57 29.56,92.55 29.61,92.55 29.85,92.55 29.85,91.74 29.51,91.4 29.51,90.45 29.51,90.44 29.38,90.44 29.38,90.02 29.13,90.02 29.13,90.44 29,90.44 29,90.62 28.73,90.89 28.73,91.05 28.95,91.27 28.98,91.27 29.03,91.25 29.08,91.25 29.34,91.36 29.44,91.62 29.4,91.78 29.29,91.91 29.29,92.53 29.34,92.57 29.39,92.57
GND on BOTTOM (solid shape): 56.85,78.85 55.88,78.85 55.88,78.84 55.8,78.85 55.57,78.75 55.47,78.52 55.49,78.41 55.55,78.31 55.57,78.2 55.47,78.14 55.04,78.14 55.03,78.18 54.98,78.28 54.9,78.36 54.86,78.44 54.89,78.52 55.33,78.96 56.84,78.96
GND on BOTTOM (solid shape): 83.69,76.67 83.77,76.56 83.9,76.52 84.18,76.52 84.26,76.52 84.26,76.13 84.18,76.13 83.9,76.13 83.77,76.09 83.69,75.97 83.68,75.94 83.4,75.94 83.39,75.97 83.31,76.09 83.18,76.13 82.92,76.13 82.72,76.32 82.92,76.52 83.18,76.52 83.31,76.56 83.39,76.67 83.4,76.71 83.68,76.71
GND on BOTTOM (solid shape): 146.96,62.34 147.05,62.3 147.06,62.21 147.04,62.15 147.04,62.08 147.07,61.94 147.14,61.83 147.17,61.76 147.14,61.69 147.07,61.57 147.05,61.44 147.07,61.31 147.13,61.21 147.14,61.19 147.14,61.12 147.04,61.12 146.25,61.91 146.11,61.91 146.01,61.98 146.04,62.09 146.29,62.34
GND on BOTTOM (solid shape): 73.51,88.85 73.61,88.79 73.58,88.68 73.09,88.18 73.09,86.91 72.86,86.69 72.8,86.69 72.6,86.61 72.51,86.42 72.47,86.35 72.4,86.33 72.35,86.33 72.28,86.36 72.25,86.42 72.23,86.5 72.2,86.57 72.17,86.61 72.59,87.03 72.59,87.36 72.83,87.59 72.83,88.62 73.06,88.85
GND on BOTTOM (solid shape): 145.14,18.1 145.16,17.98 145.07,17.92 145.05,17.92 144.78,17.82 144.68,17.55 144.68,17.53 144.62,17.47 144.55,17.48 144.39,17.48 144.34,17.54 143.58,17.54 143.44,17.68 143.44,17.94 143.41,18.02 143.32,18.05 143.16,18.05 143.11,18.08 143.12,18.14 143.14,18.15 145.09,18.15
GND on BOTTOM (solid shape): 29.25,51.84 29.25,50.45 29.4,50.29 29.4,49.35 29.39,49.34 29.39,48.64 29.35,48.6 29.28,48.5 29.17,48.53 29.05,48.62 28.9,48.65 28.78,48.63 28.67,48.57 28.64,48.54 27.84,49.34 27.84,49.96 28,50.12 28,50.57 28.09,50.57 28.17,50.6 28.21,50.68 28.21,51.88 28.2,51.9 28.22,51.99 28.3,52.03 29.05,52.03
GND on BOTTOM (solid shape): 143.85,23.06 143.91,23.15 144.01,23.14 144.11,23.09 144.23,23.07 144.26,23.07 144.32,23.08 144.75,22.65 144.75,22.13 145,21.89 145,21.19 144.85,21.19 144.85,21.78 144.57,22.06 144.58,22.12 144.58,22.15 144.48,22.41 144.23,22.51 144.11,22.49 144.01,22.44 143.91,22.43 143.85,22.52
GND on BOTTOM (solid shape): 146.4,59.67 146.42,59.56 146.33,59.49 146.23,59.49 146.15,59.46 146.11,59.38 146.11,59.28 146.1,59.23 146.09,59.19 146.09,58.71 145.92,58.71 145.92,58.71 145.84,58.71 145.84,58.8 145.87,58.81 145.93,58.85 145.95,58.92 145.95,59.3 145.95,59.34 145.92,59.38 145.91,59.4 145.91,59.94 145.6,60.25 144.94,60.25 144.54,60.65 142.44,60.65 142.39,60.68 142.4,60.73 142.47,60.8 145.27,60.8
GND on BOTTOM (solid shape): 93.91,91.73 93.92,91.71 93.93,91.69 93.94,91.66 93.94,91.63 93.93,91.6 93.92,91.59 95.75,89.76 95.75,87.56 95.66,87.47 95.66,87.46 94.72,86.52 94.68,86.51 94.63,86.49 94.59,86.47 94.55,86.44 94.51,86.4 94.48,86.36 94.45,86.31 94.44,86.27 94.43,86.22 94.41,86.21 94.41,86.11 93.74,85.43 91.76,85.43 91.29,85.9 92.48,85.9 92.57,85.89 92.75,85.88 92.84,85.88 92.93,85.88 93.11,85.89 93.2,85.9 91.29,85.9 89.83,87.36 89.83,87.99 89.83,88 89.84,88.03 89.85,88.05 89.87,88.07 89.9,88.08 89.91,88.09 89.91,89.51 89.9,89.52 89.87,89.53 89.85,89.55 89.84,89.57 89.83,89.6 89.83,89.61 89.83,92.05 90.11,92.33 93.3,92.33
GND on BOTTOM (solid shape): 66.23,90.62 66.3,90.7 66.41,90.68 67.59,89.49 67.61,89.49 67.75,89.36 67.75,89.06 67.7,88.97 67.6,88.97 67.52,89 67.44,89.01 67.21,88.92 67.11,88.68 67.15,88.53 67.24,88.42 67.26,88.4 67.26,88.36 67.23,88.32 67.18,88.33 67.01,88.5 67.01,89.8 66.23,90.58
GND on BOTTOM (solid shape): 190.52,19.98 190.54,19.95 190.54,19.79 190.56,19.73 190.56,19.71 190.56,19.63 190.79,19.4 191.18,19.4 191.18,19.41 191.32,19.52 191.39,19.53 191.53,19.47 191.59,19.33 191.58,19.26 191.55,19.2 191.4,19.05 190.13,19.05 190.05,19.13 190.05,19.15 190.05,19.33 190.06,19.38 190.04,19.48 189.99,19.58 189.98,19.59 189.98,19.68 190.3,20 190.46,20
GND on BOTTOM (solid shape): 75.03,67.62 75.41,67.62 75.54,67.48 75.54,67.24 75.94,66.84 75.91,66.8 75.88,66.76 75.85,66.7 75.81,66.66 75.77,66.7 75.38,66.7 74.73,67.35 74.73,67.4 74.65,67.61 74.44,67.69 74.35,67.68 74.28,67.64 74.2,67.63 74.13,67.68 74.09,67.74 74.04,67.8 74.09,67.86 74.13,67.92 74.2,67.97 74.28,67.96 74.35,67.92 74.44,67.91 74.54,67.92 74.62,67.97 74.66,68
GND on BOTTOM (solid shape): 185.05,22.98 185.16,23 185.22,22.9 185.22,22.63 185.12,22.6 184.94,22.42 184.92,22.35 184.91,22.29 184.92,22.22 184.94,22.16 185.12,21.97 185.22,21.95 185.22,21.85 185.24,21.79 185.24,21.75 185.2,21.61 185.09,21.51 185.03,21.5 184.99,21.49 184.94,21.5 184.89,21.51 184.87,21.52 184.45,21.52 184.33,21.4 184.22,21.38 184.16,21.47 184.16,22.09
GND on BOTTOM (solid shape): 210.06,9.24 210.06,8.86 209.95,8.76 209.65,8.76 208.78,7.89 208.78,4.19 208.63,4.04 208.55,4.01 208.48,4.04 208.35,4.14 208.2,4.17 208.06,4.14 207.95,4.07 207.89,4.04 207.84,4 207.73,3.98 207.67,4.07 207.67,4.79 207.74,4.87 207.74,6.23 207.6,6.38 207.66,6.48 207.68,6.6 207.67,6.69 207.64,6.77 207.63,6.78 207.63,7.3 208.83,8.49 208.85,8.52 208.87,8.56 208.91,8.61 208.91,9.19 209.04,9.32 209.98,9.32
GND on BOTTOM (solid shape): 146.46,88.75 146.53,88.72 146.54,88.71 146.56,88.66 146.52,88.63 146.33,88.49 146.26,88.27 146.28,88.16 146.33,88.06 146.34,87.96 146.26,87.9 144.92,86.56 144.73,86.56 144.47,86.82 144.47,86.9 145.7,88.13 145.7,88.57 145.75,88.66 145.86,88.65 145.97,88.59 146.09,88.57 146.25,88.61 146.38,88.71
GND on BOTTOM (solid shape): 36.04,102.92 35.72,102.6 35.72,101.38 35.57,101.23 34.68,101.23 34.51,101.4 33.88,101.4 33.84,101.44 33.79,101.45 33.41,101.45 33.36,101.44 33.32,101.4 33.13,101.4 32.98,101.25 32.81,101.25 32.81,101.48 32.78,101.56 32.7,101.59 32.63,101.59 32.58,101.62 32.59,101.68 33.29,102.38 33.35,102.38 33.39,102.34 33.44,102.33 33.82,102.33 33.9,102.36 33.93,102.44 33.93,102.64 33.92,102.69 33.89,102.73 33.87,102.77 33.89,102.8 33.91,102.83 33.95,102.83 34.38,103.26 36.04,103.26
GND on BOTTOM (solid shape): 155.81,76.71 155.92,76.73 155.99,76.63 155.99,76.13 156.08,76.03 156.11,75.95 156.06,75.88 156,75.88 155.89,75.8 155.82,75.69 155.82,75.53 155.79,75.46 155.71,75.42 155.7,75.42 155.56,75.39 155.44,75.29 155.42,75.27 155.39,75.25 155.33,75.3 155.27,75.33 155.02,75.33 154.98,75.31 154.94,75.29 154.87,75.36 155.27,75.76 155.27,76.58 155.34,76.6 155.4,76.54 155.65,76.54
GND on BOTTOM (solid shape): 41.32,43.67 41.39,43.76 41.5,43.74 43.22,42.01 43.7,42.01 44.29,41.42 44.32,41.31 44.22,41.24 43.64,41.24 43.56,41.29 43.55,41.38 43.57,41.45 43.57,41.51 43.2,41.88 42.84,41.51 42.84,41.51 42.77,41.41 42.66,41.43 41.32,42.77
GND on BOTTOM (solid shape): 42.76,91.77 42.83,91.74 42.86,91.68 42.88,91.6 42.92,91.52 42.95,91.49 42.54,91.08 42.54,90.78 42.42,90.63 42.4,90.44 42.39,90.4 42.35,90.38 42.26,90.37 42.18,90.33 42.12,90.39 41.87,90.39 41.87,91.75 41.95,91.76 42.06,91.65 42.07,91.64 42.36,91.42 42.62,91.68 42.65,91.74 42.72,91.77
GND on BOTTOM (solid shape): 93.96,83.84 94.95,83.84 94.95,83.45 94.99,83.37 95.07,83.33 95.23,83.33 95.46,83.1 95.48,82.99 95.39,82.93 94.97,82.93 94.9,82.9 94.86,82.84 94.85,82.8 94.6,82.8 94.59,82.84 94.56,82.9 94.48,82.93 93.97,82.93 93.9,83 93.94,83.04 94.05,83.17 94.09,83.34 93.98,83.6 93.72,83.7 93.68,83.7 93.61,83.69 93.37,83.94 93.37,84.1 93.71,84.1
GND on BOTTOM (solid shape): 208.6,107.99 208.69,107.99 208.86,107.83 208.68,107.65 208.68,106.83 208.29,106.83 208.12,107.01 208.09,107.08 208.12,107.16 208.2,107.27 208.23,107.41 207.87,107.77 207.52,107.41 207.57,107.23 207.72,107.09 207.72,106.97 208.16,106.52 208.53,106.52 208.53,106.09 207.65,106.09 207.32,106.42 206.92,106.42 206.42,106.92 206.42,107.34 206.5,107.41 206.83,107.41 207.13,107.72 207.13,107.9 207.17,107.92 207.91,107.92 208.04,108.04 208.55,108.04
GND on BOTTOM (solid shape): 210.17,22.1 210.23,22.05 210.25,22.01 210.29,21.99 210.33,21.98 210.33,21.85 211.62,21.85 211.62,21.6 210.33,21.6 210.33,21.35 211.62,21.35 211.62,21.1 210.33,21.1 210.33,20.97 210.29,20.96 210.24,20.92 210.21,20.85 210.21,20.53 209.48,20.53 209.4,20.57 209.38,20.66 209.4,20.73 209.4,20.8 209.36,21.02 209.24,21.2 209.13,21.31 209.13,21.49 209.1,21.66 209.02,21.82 209.09,21.92 209.13,22.03 209.14,22.06 209.9,22.06 210,22.07 210.1,22.1
GND on BOTTOM (solid shape): 38.21,13.3 38.28,13.28 38.33,13.24 38.38,13.22 38.44,13.14 38.41,13.05 38.18,12.83 38.18,12.29 37.98,12.09 37.77,12.09 37.62,11.93 37.62,11.22 37.39,11 37.39,10.59 37.29,10.49 36.95,10.49 36.88,10.56 36.88,11.07 36.98,11.17 36.98,11.33 37.03,11.38 37.04,11.38 37.11,11.42 37.14,11.49 37.14,11.87 37.13,11.91 37.11,11.95 37.09,11.96 37.09,12.11 37.11,12.12 37.13,12.16 37.14,12.2 37.14,12.58 37.12,12.64 37.08,12.68 37.08,12.68 36.98,12.78 36.98,13.06 37.13,13.21 38.04,13.21 38.09,13.22 38.13,13.26
GND on BOTTOM (solid shape): 97.94,75.8 97.94,75.36 97.82,75.24 97.75,75.25 97.71,75.26 97.45,75.15 97.34,74.89 97.38,74.72 97.48,74.6 97.52,74.53 97.5,74.45 97.46,74.4 97.36,74.3 96.91,74.3 96.81,74.39 96.81,74.75 96.58,74.98 96.58,75.14 96.54,75.22 96.46,75.26 96.15,75.26 96.15,75.6 96.48,75.6 96.52,75.59 96.8,75.59 96.95,75.65 97.02,75.81 97.02,75.92 97.81,75.92
GND on BOTTOM (solid shape): 147.46,90.67 147.5,90.65 147.66,90.51 147.87,90.49 147.86,90.48 147.84,90.45 147.83,90.41 147.83,90.03 147.84,89.99 147.87,89.95 147.88,89.94 147.88,89.09 147.23,88.45 146.96,88.45 146.93,88.5 146.91,88.58 146.96,88.65 147.15,88.87 147.12,89.15 147.1,89.19 147.27,89.35 147.27,90.22 147.26,90.27 147.24,90.33 147.24,90.41 147.24,90.43 147.23,90.48 147.26,90.52 147.35,90.57 147.41,90.65
GND on BOTTOM (solid shape): 93.1,82.61 93.16,82.71 93.27,82.68 93.38,82.58 93.63,82.58 93.69,82.52 93.69,82.24 94.48,81.45 94.48,81.14 94.45,81.07 94.14,80.92 94.05,80.68 94.06,80.59 94.08,80.52 94.02,80.5 93.96,80.53 93.58,80.91 93.49,80.91 93.38,81.02 93.38,81.81 93.2,81.99 93.2,82.07 93.2,82.12 93.19,82.19 93.14,82.27 93.1,82.32 93.08,82.35 93.09,82.38 93.1,82.41 93.1,82.43
GND on BOTTOM (solid shape): 149.05,81.21 149.09,81.13 149.17,81.1 149.37,81.1 149.44,81.13 149.48,81.19 149.49,81.23 149.61,81.23 149.62,81.19 149.66,81.13 149.73,81.1 150.06,81.1 150.16,81.04 150.13,80.93 150.11,80.9 149.73,80.9 149.66,80.87 149.62,80.8 149.61,80.76 149.49,80.76 149.48,80.8 149.44,80.87 149.37,80.9 149.17,80.9 149.09,80.86 149.05,80.78 149.05,80.46 148.99,80.39 148.21,80.39 147.48,81.12 147.14,81.12 147.1,81.16 147.1,81.37 147.38,81.65 149.05,81.65
GND on BOTTOM (solid shape): 107.96,26.85 107.96,25.13 107.9,25.04 107.8,25.05 107.11,25.22 106.49,24.85 106.38,24.82 106.31,24.91 106.31,25.65 105.79,26.17 105.79,26.19 105.76,26.33 105.68,26.44 105.66,26.46 105.66,26.55 105.68,26.56 105.79,26.78 105.73,27.02 105.72,27.12 105.81,27.18 107.48,27.18 107.5,27.19 107.62,27.19
GND on BOTTOM (solid shape): 136.52,63.77 136.59,63.74 136.71,63.62 136.71,63.56 136.76,63.43 136.89,63.38 136.94,63.39 136.99,63.41 137.09,63.41 137.14,63.32 137.14,62.45 137.8,61.8 137.8,61.75 137.78,61.71 137.78,61.67 137.78,61.31 137.72,61.21 137.61,61.24 137.33,61.51 137.33,61.99 136.85,62.47 136.85,62.91 136.49,63.27 136.49,63.34 136.45,63.45 136.27,63.55 136.25,63.62 136.25,63.65 136.3,63.7 136.32,63.7 136.39,63.72 136.45,63.75

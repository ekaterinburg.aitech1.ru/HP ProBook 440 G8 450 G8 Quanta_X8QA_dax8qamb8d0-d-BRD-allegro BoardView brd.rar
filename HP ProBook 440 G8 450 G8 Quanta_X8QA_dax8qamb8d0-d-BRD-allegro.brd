# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_DEEP_SUS_PRIME: length 14.5
  IN3 w0.381: v2(153.08,69.92) 153.08,70.2 152.86,70.43 151.69,70.43 151.18,70.22 150.3,70.22 149.72,70.8 149.24,70.8 149.09,70.94 147.9,70.94 147.63,70.67 143.34,70.67 143.32,70.7
  BOTTOM w0.254: v2(137.91,73.84) 137.62,74.13 U400.DC28 ; v2(137.91,73.84) 138.27,73.48 U400.DD30 ; v2(137.91,73.84) 137.62,73.55 U400.DC30 137.62,73.18 137.9,72.91 137.9,72.91 v2(137.9,72.91) ; v2(137.25,71.28) 137.25,71.14 U400.DA35 ; U400.CY33 136.32,71.82 v2(136.02,72.12) 136.32,72.43 U400.CY31
  vias: v2(151.99,69.92) v2(152.54,69.92)
+3V_DEEP_SUS_PRIME_DIS: length 4.3
  BOTTOM w0.109: U1600.4 155.37,71.53 155.09,71.24 154.2,71.24 153.46,70.51 153.46,69.6 R1615.1
+3V_DEEP_SUS_R: length 8.1
  TOP w0.254: C2015.1 151.95,8.02 150.04,8.02 149.94,8.12 148.35,8.12 148.06,7.83 148.06,7.09 147.79,6.82 U2007.D3
  vias: v1(152.35,8.33)
+3V_ECACC: length 1.6
  TOP w0.203: v2(193.06,13.41) 193.06,13.53 193.29,14.08 193.81,14.6 U4700.D1
  vias: v1(192.91,11.66)
+3V_F:
  vias: v1(11.48,22.2)
+3V_FR: length 6.3
  TOP w0.203: R4415.2 147.91,8.68 148.05,8.53 149.32,8.53
  IN3 w0.203: v1(141.94,8.9) 141.94,8.97 142.34,9.37 143.87,9.37 v1(144.16,9.66)
  BOTTOM w0.254: CON7704.1 140.62,8.89 140.75,9.03 141.81,9.03 v1(141.94,8.9)
  vias: v1(152.56,8.96) v1(153.19,8.96)
+3V_R: length 131.7
  TOP w0.203: C1905.1 147.33,11.44 147.11,11.66 147,11.66 v1(146.99,11.67)
  TOP w0.254: v1(146.99,11.67) 146.99,11.66 146.98,11.65 U1900.D3 ; v1(30.57,9.4) 30.57,11.79 29.72,12.65 PR9501.1
  IN2 w0.254: v1(30.57,9.4) 30.57,8.87 31.16,8.28 37.56,8.28 38.02,8.74 38.4,8.74 38.97,8.16 44.28,8.16 44.73,8.61 50.96,8.61 51.56,8 52.63,8 53.73,9.1 55.41,9.1 55.76,8.74 58.64,8.74 58.99,9.1 60.42,9.1 61.18,9.86 66.3,9.86 66.69,9.47 73.72,9.47 75.69,11.44 79.57,11.44 80.75,12.62 88.03,12.62 88.47,13.06 91.81,13.06 92.89,11.99 100.58,11.99 101.29,11.28 102.45,11.28 103.46,10.26 104.78,10.26 105.54,9.5 106.56,9.5 106.93,9.88 107.67,9.88 108.13,9.42 109.6,9.42 109.94,9.76 111.67,9.76 111.94,10.03 111.94,10.34 112.54,10.95 114.67,10.95 114.89,11.17 116.16,11.17 116.57,11.59 121.59,11.59 121.7,11.48 123.11,11.48 123.49,11.1 123.77,11.1 124.2,11.28 128.93,11.28 129.19,11.02 130.53,11.02 131.17,11.66 135.21,11.66 135.34,11.71 137.83,11.71 138.48,12.37 140.03,12.37 140.23,12.57 140.77,12.57 140.94,12.4 140.94,11.66 141.17,11.43 142.22,11.43 142.55,11.76 145.55,11.76 145.95,12.16 146.73,12.16 146.98,11.91 146.98,11.67 v1(146.99,11.67)
  vias: v1(26.79,13.64)
+3V_RTC: length 99
  TOP w0.254: U4700.L4 v2(198.69,16.34)
  TOP w0.508: v1(181.8,8.18) 182.88,9.26 182.88,10.76 182.5,11.15 181.96,11.15 180.59,12.52 180.59,15.01 178.43,17.17 177.24,17.17 176.18,18.23 v1(175.97,18.23)
  IN1 w0.508: v2(198.69,16.34) 198.69,14.06 198.96,13.79 v1(198.96,12.95)
  IN2 w0.508: 166.44,45.34 166.98,44.8 167.71,44.8 170.16,42.35 171.2,42.35 v1(171.77,41.79) ; v1(181.8,8.18) 182.45,8.18 182.97,8.7 184.2,8.7 184.66,9.15 190.65,9.15 191.46,9.96 191.46,10.54 191.87,10.95 193.14,10.95 193.67,11.48 198.35,11.48 198.96,12.09 v1(198.96,12.95) ; 159.54,67.43 160.26,66.71 160.26,64.88 160.86,64.28 160.86,60.99 162.39,59.45 162.39,57.28 162.81,56.86 162.81,54.92 163.61,54.12 163.61,51 164.31,50.31 164.31,49.2 164.95,48.56 165,48.51 165,47.04
  IN3 w0.508: v1(175.97,18.23) 176.02,18.23 177.01,19.22 177.96,19.22 178.8,20.06 179.18,20.06 180.12,21.01 180.54,21.01 181.01,21.47 181.01,23.3 180.61,23.7 180.61,27.19 178.89,28.91 178.89,29.49 177.16,31.21 177.16,32.96 176.29,33.84 176.29,34.48 173.42,37.34 173.42,38.95 173.73,39.26 173.73,40.14 173.09,40.78 172.56,40.78 171.77,41.57 v1(171.77,41.79)
  vias: v1(159.13,69.82)
+3V_RTC_0: length 72.3
  TOP w0.508: C4706.1 174.73,5.15 v1(174.97,4.91) ; v1(171.31,8.16) 172.11,7.36 172.11,7.31 ; v1(87.73,11.72) 87.73,13.99 88.16,14.42 88.16,15.87 v1(88.49,16.2)
  IN2 w0.508: 134.15,8.72 130.8,8.72 130.62,8.9 120.69,8.9 120.29,9.29 110.16,9.29 109.56,8.7 107.3,8.7 106.98,9.01 105.36,9.01 104.6,9.78 103.28,9.78 102.29,10.77 101.12,10.77 100.38,11.5 92.7,11.5 91.78,12.43 88.91,12.43 88.2,11.72 v1(87.73,11.72) ; 157.81,10.03 159.03,10.03 159.26,9.8 160.27,9.8 160.42,9.95 162.49,9.95 163.03,9.41 165.06,9.41 165.3,9.18 170.29,9.18 v1(171.31,8.16)
  BOTTOM w0.508: v1(174.97,4.91) CON4700.1
+3V_RTC_1: length 81.8
  TOP w0.508: v1(158.8,62.74) 158.92,62.85 Q1400.2
  IN2 w0.508: 179.65,27.25 179.65,27.94 175.51,32.08 175.51,33.55 174.72,34.34 174.72,34.84 173.04,36.53 173.04,37.44 172.65,37.82 172.65,38.42 171.16,39.91 169.55,39.91 168.51,40.95 166.94,40.95 165.91,41.98 v1(164.87,41.98) ; 181.03,19.34 181.03,23.28 180.16,24.15 180.16,24.18 ; v1(163.8,46.91) 163.44,47.28 163.44,47.83 162.48,48.78 162.48,53.65 161.32,54.82 161.32,55.4 160.25,56.47 160.25,58.37 160.7,58.83 160.7,59.55 159.68,60.57 159.68,61.86 v1(158.8,62.74) 158.8,64.08 159.13,64.41 159.13,65.63 158.67,66.09 158.01,66.09 157.05,67.05 157.05,67.91 156.79,68.17 156.79,68.59 157.29,69.09 157.29,69.65 v1(157.59,69.96) ; 184.53,16.94 185.21,16.26 186.61,16.26 187.05,15.82 187.5,15.82 187.96,15.36 187.96,13.38 187.59,13.02 185.38,13.02 184.69,13.71 182.62,13.71 181.81,12.9 181.56,12.9 176.77,8.11 176.77,7.88 176.41,7.52 175.13,7.52 174.28,6.68 v1(172.84,6.68)
+3V_RTC_2: length 1.3
  TOP w0.254: R1415.2 160.56,70.67 D1400.2
+3V_SSD:
  vias: v1(7.11,7.72) v1(7.12,7.09) v1(7.12,6.46) v1(7.14,3.54) v1(7.77,3.54) v1(8.89,3.55) v1(9.57,3.55) v1(15.24,7.69) v1(15.62,8.2)
+3V_THR: length 3.1
  BOTTOM w0.109: C5410.1 R5405.1 31.12,77.04 30.67,76.59 U5401.5
+3V_VCC: length 124.6
  TOP w0.254: U4700.D12 193.72,21.96 v2(193.72,22.35)
  IN2 w0.254: v2(189.74,19.28) 188.58,19.28 188.12,19.74 187.05,19.74 185.72,21.08 185.72,24.28 184.47,25.53 183.7,27.4 183.11,27.99 183.11,28.65 181.02,30.74 181.02,32.04 177.42,35.64 177.42,36.83 176.98,37.27 176.22,37.27 175.32,38.16 175.32,40.31 173.87,41.76 173.87,42.54 173.46,42.94 172.7,42.94 171.82,43.83 169.84,43.83 168.6,45.06 168.6,48.54 166.43,50.71 166.43,51.88 165.53,52.78 165.53,58.01 164.53,59.01 164.53,60.19 165.86,61.52 165.86,64.24 165.27,64.82 163.62,64.82 163.21,65.24 163.21,67.83 163.44,68.06 163.44,70.09 162.51,71.01 162.51,73.15 163.17,73.81 163.17,74.52 163.5,74.85 163.5,76.76 162.32,77.94 162.32,78.41 161.38,79.35 161.38,81.55 160.11,82.82 160.11,86.45 158.6,87.96 158.6,89.42 154.4,93.62 150.02,93.62 147.12,96.51 147.12,96.74 146.2,97.66 146.2,97.91 145.68,98.44 v2(145.68,99.59)
  BOTTOM w0.203: v2(145.68,99.59) 145.68,98.69 145.11,98.12 142.79,98.12 PR8011.1 142.67,98.06 142.31,97.71 141.17,97.71 140.85,97.39 PQ8004.2
  BOTTOM w0.254: v2(193.72,22.35) 193.44,22.07 192.56,22.07 191.81,22.82 191.69,22.87 189.41,22.87 188.81,22.26 188.81,21.34 189.07,21.08 190.04,21.08 190.31,20.81 C4719.2 189.74,19.78 v2(189.74,19.28)
  vias: v1(190.17,13.33) v2(191.49,13.7) v2(201.3,19.68)
+3V_VCC_CR: length 57.7
  TOP w0.356: v2(203.34,19.63) 203.5,19.63 203.83,19.3 CON7600.4
  IN1 w0.381: v2(203.34,19.63) 203.6,19.9 203.6,22.1 201.9,23.8 201.05,24.15 201.03,24.15 v1(201.03,24.15)
  IN2 w0.508: v1(183.15,48.45) 183.15,48.3 183.35,48.1 183.35,45.32 185.62,43.05 185.62,40.69 184.64,39.71 184.64,36.77 188.61,32.8 188.61,32.08 189.31,31.37 189.86,31.37 192.2,29.03 192.65,29.03 194.12,27.56 195.99,27.56 196.52,27.02 197.58,27.02 198.09,26.52 198.09,26.49 199.93,24.65 200.75,24.65 201.03,24.37 v1(201.03,24.15)
  BOTTOM w0.508: v1(173.13,39.56) 174.59,39.56 178.22,43.19 178.22,44.08 178.97,44.83 178.97,45.99 179.93,46.95 180.35,46.95 180.72,47.31 180.72,47.93 181.51,48.72 182.88,48.72 v1(183.15,48.45)
  vias: v1(174.14,39.88)
+3V_WLAN_C: length 1.3
  TOP w0.203: C2012.1 199.14,77.06 199.31,76.89 U2004.D3
  vias: v1(198.6,76.3)
+3V_WLAN_P:
  vias: v1(174.8,77.95) v1(174.8,77.29) v1(175.28,76.86) v1(175.38,77.65) v1(175.84,77.21) v1(185.19,83) v1(186.92,77.57) v1(187.04,73) v1(189.25,78.15) v1(189.94,78.18) v1(191.44,78.54) v1(192.1,78.54) v1(192.73,78.31)
+3V_WWAN_P: length 1.6
  TOP w0.254: R4207.1 197.97,5.68 198.24,5.41 198.24,4.8 v1(198.12,4.67)
  vias: v1(184.99,2.86) v1(185.34,3.44) v1(185.62,2.86) v1(185.98,3.44) v1(186.26,2.86) v1(201.04,3.25) v1(201.37,3.78) v1(201.57,2.89) v1(201.95,3.53) v1(202.21,2.89)
+3VCM_PWR_B: length 21
  IN1 w0.381: v1(158.52,104.72) 158.54,104.7 158.33,104.48 154.67,104.48 152.12,101.93 150.88,101.93 149.79,103.02 v1(146.68,103.02)
  BOTTOM w0.508: v1(158.52,104.72) 158.52,105.28 157.94,105.86 v1(157.63,105.86) 155.24,105.86 CON1900.10 ; CON1900.1 147.73,105.06 146.98,104.31 R1900.2 146.98,103.32 v1(146.68,103.02)
+3VLANVCC: length 5.9
  TOP w0.254: 16.13,12.8 16.13,14.22 15.72,14.63 v1(15.09,14.63) 14.07,14.63 13.82,14.88 C1818.2 13.82,15.47 14.19,15.84 U1807.D1 U1807.D2
+3VLANVCC_R: length 5.2
  TOP w0.254: 17.47,15.01 16.74,15.75 15.31,15.75 14.65,15.08 C1818.1 14.27,15.34 14.99,16.06 U1807.D3
  vias: v1(19.94,14.73)
+3VLCD_CON: length 3
  BOTTOM w0.508: C3408.2 C3404.1 31.2,43.13 C3405.1 31.21,42.17 C3406.1
  vias: v1(26.31,36.62) v1(27.12,36.12) v1(30.35,38.17)
+3VPCU: length 729.2
  TOP w0.109: v1(213.94,116.1) 214.24,116.4 LED7600.3
  TOP w0.203: v1(57.41,9.71) 57.58,9.88 PR8230.2 ; R5015.5 117.34,8.87 117.73,8.48 119.46,8.48 119.88,8.06 R5015.10 ; R1531.1 152.61,67.15 v2(152.45,66.99) 152.06,66.99 R1532.2 ; R4817.1 167.01,35.56 R4816.1 ; PR8239.2 53.16,4.01 PR8412.2 53.61,3.96 53.9,4.24 v1(54.91,4.24)
  TOP w0.254: R4823.2 193.32,12.49 v2(193.22,12.6) ; R5628.2 190.4,26.13 190.4,25.3 192.33,23.36 194.36,23.36 195.1,22.62 v2(195.1,22.35) ; U4701.5 177.58,59.56 v1(177.32,59.83) 177.32,60.12 v1(177.59,60.4) ; R4807.2 189.24,22.45 v2(189.43,22.25) ; R5015.5 117.34,9.91 117.02,10.23 116.41,10.23 116.03,10.61 116.03,11.03 116.88,11.88 119.53,11.88 120.85,13.21 120.85,14.05 v1(120.74,14.16) ; v1(149.25,17.09) 149.25,17.44 148.38,18.31 143.57,18.31 142.45,17.2 C1812.2 142.45,16.49 141.56,15.6 U1804.D1 U1804.D2 ; R4752.2 134.48,8.68 v1(135.15,9.34) ; R4806.2 173.33,58.67 v1(173.69,58.67) 174.4,57.96 R4737.2 ; v1(157.25,55.66) 157.38,55.52 R819.1 ; C1911.1 190.73,56.97 v1(190.75,56.94) 191,56.94 U1905.D3 ; U3405.5 28.67,39.66 28.42,39.41 28.42,38.76 28.68,38.5 29.25,38.5 29.34,38.41 R3431.1 29.34,37.75 29.46,37.63 29.99,37.63 30.42,38.05 33.52,38.05 35.16,36.41 v1(35.16,36.11) ; U7601.3 85.74,67.07 85.93,67.26 85.93,67.99 85.11,68.81 85.11,69.11 85.28,69.28 C6683.1 85.88,69.08 85.88,68.68 86.27,68.28 86.7,68.28 87.17,68.75 87.17,70.77 87.5,71.09 87.95,71.09 88.59,70.45 88.59,67.99 87.75,67.15 87.75,66.48 88.04,66.19 88.47,66.19 88.57,66.29 v1(90.98,66.29) ; R1534.1 143.93,56.96 144.51,57.54 v1(144.51,57.76) ; PR8824.2 80.27,105.11 v1(80.12,105.11) ; 123.33,106.69 122.53,107.49 118.68,107.49 PR9108.2 ; v1(19.12,39.09) 19.1,39.09 18.97,39.22 PC10641.1 18.27,39.13 18.8,38.6 19.7,38.6 20.2,38.1 20.64,38.1 21.41,37.34 21.89,37.34 22.46,37.9 Q7500.2 ; U4400.5 209.7,9.59 v1(209.88,9.78) ; R4202.1 205.38,3.59 v1(205.67,3.3) ; R4726.1 R4728.1 135.56,8.93 v1(135.15,9.34) ; v1(134.24,10.61) 135.15,9.7 v1(135.15,9.34) ; v1(184.38,12.32) 184.6,12.1 PR8124.1 ; v2(191.18,21.93) 191.08,22.03 191.08,23.01 189.08,25.01 R4722.1 188.49,25.01 188.47,24.99 R4721.1
  TOP w0.305: PU9601.5 150.8,103.72 PC9605.1 150.87,103.25 150.49,103.25 150.19,102.94 149.17,102.94 148.88,102.65 148.88,101.74 v1(148.83,101.69) ; 145.24,92.76 145.24,94.64 v1(145.13,94.74) 144.6,95.28 144.6,96.4 PU10602.5 ; PU10604.5 145.5,103.72 145.29,103.5 v1(145.29,103.02) ; v3(163.78,103.81) 163.7,103.81 162.96,103.07 161.9,103.07 161.29,102.46 159.65,102.46 158.87,103.24 158.87,104.32 159.08,104.52 159.08,105.1 PQ8011.1
  TOP w0.381: 149.05,93.14 149.52,93.61 154.78,93.61 157.99,90.4 157.99,88.31 158.6,87.7 158.6,87.28 156.92,85.59 v1(156.92,85.05) 156.92,84.88 158.42,83.37 v1(158.78,83.37) 159.21,83.37 159.63,83.79 160.15,83.79 160.83,84.47 PU10605.5 160.83,85.69 162.04,86.91 PU10603.5 ; v1(164.94,83) 163.34,83 163.22,82.88 162.3,82.88 ; v1(156.89,41.22) 156.97,41.22 157.48,40.71 157.48,39.93 157.35,39.8 157.35,38.92 R4802.2 ; R4817.1 166.47,35.71 166.22,35.96 166.22,40.58 v1(166.16,40.64) 166.95,40.64 168.12,41.81 168.12,42.09 169.04,43.01 169.04,47.03 169.6,47.6 v1(169.97,47.6) ; PR9214.2 123.65,16.48 122.68,15.51 122.09,15.51 v1(120.74,14.16) ; PQ8404.1 46.14,8.62 45.3,9.46 45.09,9.46 PQ8405.1 v1(45.79,11.09) ; v1(165.42,71.53) 165.42,70.65 PR8127.2 ; R3605.1 198.12,31.71 198.4,31.43 v1(198.4,31.04)
  TOP w0.508: v1(197.38,26.37) 197.38,26.46 196.85,27 196.62,27 196.08,27.53 R4729.1 ; v1(164.94,83) 166.34,83 167.08,82.27 169.15,82.27 170.23,81.19 170.23,80.67 169.75,80.19 169.75,79.67 170.58,78.83 171.09,78.83 171.33,79.07 188.51,79.07 189.11,79.68 190.67,79.68 191.77,80.77 192.91,80.77 193.55,80.13 v1(194.05,80.13) ; v1(85.85,57.78) 85.85,57.38 77.57,49.1 71.98,49.1 70.31,50.77 63.9,50.77 63.1,51.57 v1(62.05,51.57)
  IN1 w0.254: v2(190.88,19.86) 190.6,19.58 190.6,18.92 191.21,18.31 191.21,18.11 v2(191.06,17.96)
  IN1 w0.381: v1(161.9,83.37) v1(158.78,83.37) ; v1(156.89,41.22) 157.14,40.97 160.37,40.97 160.66,41.25 162.1,41.25 163.02,40.33 165.85,40.33 v1(166.16,40.64)
  IN1 w0.508: v1(123.6,105.68) 126.01,103.27 131.19,103.27 131.64,102.83 132.35,102.83 133.8,104.27 143.15,104.27 144.4,103.02 v1(145.29,103.02) ; v1(109.72,109.11) 108.18,109.11 106.86,110.44 106.86,111.14 104.99,113 86.48,113 v1(85.57,112.1) ; v1(85.85,57.78) 85.85,59.85 90.98,64.99 v1(90.98,66.29)
  IN2 w0.254: 188.62,83.16 187.83,82.37 v2(186,82.37) ; v2(190.93,90.58) 190.93,90.8 190.12,91.62 190.12,95.65 190.73,96.26 194.15,96.26 v1(195.36,95.05)
  IN2 w0.483: v1(198.41,93.78) 198.41,93 196.8,91.39 195.86,91.39 193.93,89.45 193.93,89.1 193.42,88.59 189.84,88.59 188.69,87.45 188.69,83.23 188.62,83.16
  IN2 w0.508: v1(109.72,109.11) 110.95,109.11 112.38,107.68 119.67,107.68 121.67,105.68 v1(123.6,105.68) ; v1(80.12,105.11) 79.92,105.11 79.3,104.49 79.3,100.56 78.94,100.2 78.08,100.2 76.76,98.88 61.26,98.88 60.48,99.67 57.73,99.67 56.74,98.68 56.74,98.32 55.88,97.46 54.15,97.46 53.77,97.84 41.55,97.84 40.33,99.06 39.6,99.06 39.04,99.62 39.04,100.61 38.76,100.89 36.03,100.89 31.77,96.63 31.77,95.64 31.51,95.38 31.51,91.62 30.66,90.77 30.66,87.85 31.88,86.63 31.88,86.63 31.88,86.62 31.88,85.8 31.88,85.79 31.88,82.78 31.34,82.24 31.34,77.75 v1(32.59,76.5) 32.59,76.3 30.55,74.27 30.55,62.23 26.91,58.59 26.91,56.73 24.83,54.64 24.83,52.62 23.49,51.28 21.56,51.28 20.29,50.01 v1(20.29,49.3) ; 194.18,74.34 194.18,76.44 193.51,77.11 193.51,79.59 v1(194.05,80.13) 193.61,80.58 192.03,80.58 191.41,79.96 189.48,79.96 189.08,80.36 189.08,81.76 189.2,81.89 189.2,82.57 188.62,83.16 ; v1(169.97,47.6) 169.97,49.58 169.03,50.52 169.03,58.14 168.29,58.89 v3(168.29,58.95) ; 155.2,99.9 153.62,99.9 152.6,100.91 149.17,100.91 148.83,101.25 v1(148.83,101.69) 148.21,102.31 145.62,102.31 145.29,102.64 v1(145.29,103.02) ; v1(198.4,31.04) 198.61,30.82 198.69,30.82 199.59,29.92 201.8,29.92 202.93,28.79 203.77,28.79 204.57,27.99 205.46,27.99 205.86,27.58 208.43,27.58 212.42,23.59 212.42,21.31 v1(213.1,20.62) 213.74,19.99 213.74,14.65 212.52,13.43 212.52,12.09 212.98,11.63 212.98,10.18 212.57,9.78 v1(209.88,9.78)
  IN2 w0.762: v3(168.29,58.95) 168.29,58.97 169.52,60.2 169.52,63.14 168.6,64.06 168.6,66.16 168.38,66.38 168.38,68.26 167.42,69.23 167.42,70.09 166.52,70.99 165.96,70.99 v1(165.42,71.53) 165.62,71.72 165.62,72.81 166.34,73.53 166.34,76.81 166.58,77.04 166.58,78.57 166.03,79.12 165.54,79.12 164.94,79.71 v1(164.94,83) 164.67,83.28 164.67,84.88 162.86,86.69 162.86,93.28 161.79,94.35 161.79,97.6 161.17,98.22 156.06,98.22 155.2,99.08 155.2,99.9 158.2,102.89 163.14,102.89 163.8,103.55 163.8,103.78 v3(163.78,103.81)
  IN3 w0.381: v1(195.36,95.05) 195.47,94.95 196.64,94.95 197.8,93.78 v1(198.41,93.78)
  BOTTOM w0.109: C1654.1 156.03,69.92 U1600.5
  BOTTOM w0.203: v1(195.36,95.05) 195.29,94.98 R6124.2 ; v2(191.06,17.96) 191.26,18.16 R4800.2 ; R4804.2 208.35,19.31 208.2,19.45 205.59,19.45 202.49,22.55 R4805.2 199.7,22.55 v2(199.69,22.54) ; R4723.1 201.88,18.03 v2(201.48,18.03) 201.48,17.51 201.3,17.32 R4724.1 ; v1(135.15,9.34) 135.21,9.4 137.88,9.4 R4727.1 ; v2(186,82.37) 186,82.37 R6109.2
  BOTTOM w0.254: CON7700.7 18.43,37.69 19.12,38.38 v1(19.12,39.09) ; v1(145.13,94.74) 145.78,95.39 PU9600.5 145.78,95.79 145.2,96.38 145.2,97.01 PC9601.1 ; v1(35.16,36.11) 35.26,36.21 35.26,41.31 34.91,41.67 34.91,45.23 34.4,45.73 v1(33.49,45.73) ; v1(213.94,116.1) 212.88,116.1 211.07,114.3 208.86,114.3 205.79,111.22 205.26,111.22 204.24,110.21 204.24,108.36 202.51,106.62 200.99,105.99 198.96,103.96 198.96,96.75 198.75,96.54 198.75,95.02 198.63,94.9 C6109.1 198.63,94.31 198.41,94.09 v1(198.41,93.78) ; F5002.1 134.19,14.98 135.2,13.97 135.2,12.95 135.46,12.7 135.46,12.01 135.21,11.76 135.03,11.76 134.44,11.17 134.44,10.82 v1(134.24,10.61) ; v1(213.1,20.62) 213,20.72 CON7702.22 ; v1(18.39,35.63) 18.16,35.63 18.11,35.69 CON7700.3
  BOTTOM w0.305: v1(198.41,93.78) 198.06,93.78 197.97,93.87 U6101.10
  BOTTOM w0.381: PR10618.2 157,77.43 157.83,78.26 157.83,81.31 157.45,81.7 157.45,84.52 v1(156.92,85.05) ; R5901.2 187.43,57.57 v1(187.53,57.68) ; R1004.2 92.63,65.99 91.29,65.99 v1(90.98,66.29) ; v1(190.75,56.94) 191.52,57.72 PQ8400.2 ; PR10617.2 158.43,82.64 158.78,82.99 v1(158.78,83.37)
  BOTTOM w0.508: v1(109.72,109.11) 110.41,109.11 PR9104.1 ; v1(80.12,105.11) 80.54,105.11 84.74,100.92 85.45,100.92 86.17,101.64 86.17,104.55 87.04,105.43 87.04,108.63 86.26,109.41 86.26,111.42 v1(85.57,112.1)
  vias: v1(16.89,43.97) v1(17.52,44.6) v1(17.52,43.97) v1(21.44,49.58) v1(60.81,51.59) v1(61.43,51.57) v1(68.25,60.53) v1(68.25,59.89) v1(68.25,59.26) v1(133.58,16.64) v1(134.22,16.64) v1(153.72,15.42) v1(153.72,14.7) v1(153.72,14.09) v1(154.35,15.42) v1(154.35,14.7) v1(154.35,14.09) v1(154.99,15.42) v1(154.99,14.7) v1(154.99,14.09) v1(155.62,14.7) v1(155.62,14.09) v1(156.26,14.7) v1(156.56,55.7) v1(181.76,52.87) v1(181.76,52.24) v1(184.38,13.12) v1(188.52,54.43) v1(188.52,53.79) v1(191.21,46.3) v1(191.72,46.67) v1(192.35,46.68) v1(192.56,47.27) v1(192.99,46.68) v1(193.19,47.27) v1(194.66,72.08) v1(195.06,73.43) v1(194.99,72.79) v1(195.3,72.18) v1(195.68,73.48) v1(195.68,72.84) v1(198.8,9.08) v1(199.34,9.4) v1(199.34,8.76) v1(200.03,7.34) v1(200.65,7.34) v1(206.59,6.58) v1(206.92,7.11) v1(206.96,6.02) v2(27.33,7.92) v2(153.85,70) v2(154.41,70) v2(198.35,13.46) v2(198.38,12.9) v3(22.55,9.24) v3(22.63,9.98) v3(23.29,9.37) v3(23.37,10.11) v3(24.02,9.37) v3(25.96,9.37) v3(26.41,8.81) v3(26.77,9.45) v3(26.69,8.13) v3(27.15,8.81) v3(171.92,104.67)
+3VPCU_KB: length 5.5
  BOTTOM w0.254: CON5000.13 125.64,10.93 126,11.29 128.81,11.29 129.08,11.02
+3VPCU_PD: length 104.3
  IN2 w0.381: v1(192.71,79.98) 191.95,79.22 191.13,79.22 190.6,78.69 190.6,78 190.14,77.54 190.14,76.2 191.38,74.96 191.38,72.41 192.41,71.37 192.41,70.06 189.71,67.35 189.71,65.91 187.42,63.62 187.42,61.95 188.91,60.46 188.91,59.88 186.97,57.95 186.97,56.5 187.91,55.57 187.91,52.57 189.7,50.77 189.7,50.23 188.97,49.5 188.31,49.5 187.6,48.79 187.6,48.08 189.46,46.23 189.46,45.83 189.86,45.43 189.86,39.84 190.34,39.36 190.34,35.89 191.9,34.33 191.9,32.75 193.3,31.34 193.61,31.34 194.22,30.73 197.95,30.73 198.27,30.41 198.36,30.35 198.44,30.32 199.37,29.39 201.58,29.39 202.71,28.26 203.55,28.26 204.35,27.46 204.97,27.46 206.45,25.97 208.28,25.97 208.44,26.13 209.1,26.13 209.92,25.3 v1(209.92,24.83)
  IN3 w0.381: v1(192.71,79.98) 192.94,79.98 193.72,80.77 194.43,80.77 194.92,81.25 194.92,83 194.13,83.79 194.13,88.12 ; v2(196.6,87.67) 196,88.26 194.27,88.26 194.13,88.12 ; 194.13,88.12 193.16,89.09 v2(193.16,89.24)
  BOTTOM w0.203: U6100.11 193.01,89 193.16,89.15 v2(193.16,89.24) ; R6106.1 192.43,79.98 v1(192.71,79.98) 193.04,79.98 194.64,78.38 194.99,78.38 195.2,78.18 195.76,78.18 v1(196.58,79.01) 196.88,79.31 R6110.1 ; v2(192.61,89.24) 192.61,89.24 U6100.10 ; v2(196.6,87.67) 196.4,87.67 196.18,87.45 R6100.1
  BOTTOM w0.254: CON7702.30 210.03,24.72 v1(209.92,24.83)
+3VPCU_R: length 15.1
  TOP w0.254: PR8607.2 146.12,16 146.2,16 146.76,15.44 PC8611.1 147.02,15.44 ; 150.16,15.77 150.16,16.32 149.8,16.68 149.8,17.42 148.53,18.68 143.41,18.68 143.09,18.36 v1(142.9,18.36) 142.9,18.17 142,17.27 C1812.1 141.49,16.67 140.76,15.95 U1804.D3
  vias: v3(149.35,15.19) v3(149.38,14.45) v3(150.09,15.19) v3(150.11,14.45) v3(150.82,15.19) v3(150.85,14.45)
+5V: length 128
  TOP w0.305: Q3406.2 29.31,22.96 28.34,21.99 24.15,21.99 v1(23.44,21.28)
  TOP w0.381: v1(160.26,38.77) 160.26,38.14 159,36.87 153.92,36.87 152.54,38.26 152.54,40.65 R1530.2
  TOP w0.508: F3500.1 196.08,48.3 198.09,50.32 200.84,50.32 202.03,51.51 v1(202.03,51.69)
  IN2 w0.381: v1(170.39,38.09) 169.87,38.09 169.13,37.36 167.44,37.36 165.74,39.06 160.74,39.06 160.45,38.77 v1(160.26,38.77)
  IN2 w0.508: v1(188.7,47.99) 190.04,46.65 190.04,46 190.4,45.65 190.4,40.06 190.91,39.54 190.91,38.48 192.43,36.96 192.43,34.08 192.78,33.74 ; v1(202.03,51.69) 202.41,51.69 203.83,53.11 203.83,57.19 205.1,58.47 205.1,62.2 204.52,62.79 202.28,62.79 201.24,63.83 199.87,63.83 199.62,64.08 199.62,65.53 198.55,66.6 198.55,70.46 v1(197.94,71.07) ; 193.88,31.85 194.46,31.27 197.69,31.27 198.05,31.63 198.66,31.63 198.88,31.42 198.94,31.42 199.84,30.52 202.07,30.52 v1(202.56,30.02)
  IN2 w1.016: 174.14,31.37 177.19,28.33 177.19,27.56
  IN3 w0.508: v1(28.5,68.1) 27.91,67.5 27.91,62.07 24.83,58.99 23.54,58.99 23.16,58.61 23.16,55.97 24.18,54.94 24.18,48.41 25.25,47.34 v1(25.25,46.94) v1(25.25,46.31)
  BOTTOM w0.254: v1(44.95,11.37) Q5005.1 44.26,9.95 R5026.2
  BOTTOM w0.381: v1(197.94,71.07) 197.9,71.03 Q6100.2
  vias: v1(27.48,67.87) v1(33.07,9.39) v1(33.7,9.39) v1(34.34,9.39) v1(150.67,11.86) v1(151.29,11.86) v1(151.92,11.86) v1(159.95,12.82) v1(160.6,12.82) v1(161.23,12.82) v1(170.71,37.56) v1(170.86,38.5) v1(188.16,48.31) v1(188.7,48.63)
+5V_ALW: length 3.2
  BOTTOM w0.203: PC8627.2 166.18,9.33 165.56,9.95 165.56,10.4 165.66,10.65 165.96,10.95 166.13,10.95 166.38,11.2 PU8601.9
+5V_AVDD_R: length 10.3
  BOTTOM w0.254: v1(198.57,33.04) 198.66,32.96 201.35,32.96 201.78,32.54 201.78,29.82 201.42,29.46 201.16,29.46 200.63,28.93 200.63,28.5 200.93,28.2 C1811.2 201.87,28.2 202.04,28.37 U1805.D2 U1805.D1
  vias: v1(197.76,34.8)
+5V_CAM:
  vias: v1(27.4,47.39) v1(27.4,46.76)
+5V_FAN: length 16.5
  BOTTOM w0.508: CON5400.3 27.28,68.68 27.33,68.73 29.11,68.73 30,67.84 30,67.05 30.56,66.49 C5400.1 30.99,63.4 31.49,62.89 C5401.2 30.85,62.57 29.49,63.93 28.19,63.93 27.9,63.64 v1(26.49,63.64)
  vias: v1(26.44,64.54)
+5V_HDMIC:
  vias: v1(201.75,46.56)
+5V_LED_KBLIGHT:
  vias: v1(48.21,8.94)
+5V_LED_KBLIGHT_C:
  vias: v1(49.83,7.16)
+5V_R:
  vias: v1(159.84,8.63)
+5V_USBP1:
  vias: v1(201.97,84.94) v1(201.97,84.3) v1(201.97,83.63) v1(201.98,83) v1(201.98,66.34) v1(202.71,67.48) v1(202.71,66.85) v1(202.71,66.21) v1(202.71,65.58) v1(202.71,64.94)
+5V_USBP4:
  vias: v1(200.81,87.65) v1(201.83,88.18) v1(201.83,87.52) v1(201.8,86.9) v1(201.8,86.24) v1(202.46,88.18) v1(202.46,87.52) v1(202.43,86.9) v1(202.43,86.24) v2(196.87,86.28) v2(197.28,86.69) v2(197.36,87.25)
+5VPCU: length 306.1
  TOP w0.109: PR10518.1 78.13,99.31 78.2,99.24 v1(78.53,99.24)
  TOP w0.178: PU9501.4 25.12,9.22 v2(25.12,9.22) ; PU9502.4 175.99,66.69
  TOP w0.203: PC10512.1 90.92,73.97 90.73,74.17 90.39,74.17 90.04,74.02 89.88,73.86 PU10501.4 ; PC8714.2 105.04,14.73 104.93,14.62 PR8712.2 104.73,14.1 PU8700.12 ; PU10601.4 134.11,94.97 134.49,95.35 134.49,95.65 PC10633.2 134.57,96.23 v2(134.57,96.8) ; v1(200.16,81.67) 200.73,82.24 R6203.2 ; v1(156.39,13.43) 156.31,13.35 PU9500.4
  TOP w0.254: v1(176.55,6.7) 176.71,6.55 176.71,5.86 U1806.D2 U1806.D1 ; v2(187.8,23.87) 188.19,23.87 188.24,23.82 R4822.1
  TOP w0.381: v1(90.31,73.6) 90.66,73.6 PC10512.1 ; PC8714.2 105.48,15.19 105.94,14.73 v1(105.94,13.08) ; PC9513.1 25.13,8.27 25.13,9.18 25.12,9.19 v2(25.12,9.22) ; v1(22.42,62.53) 22.06,62.17 C7210.2 21.63,62.89 PR10212.1
  TOP w0.508: PR10201.1 26.3,89.65 v1(25.83,90.12)
  IN1 w0.508: v1(39.53,53.49) 38.78,52.74 37.29,52.74 36.05,51.5 30.47,51.5 29.37,52.59 27.71,52.59 26.94,53.37 26.43,53.37 24.3,51.23 20.17,51.23 v1(19.86,51.53)
  IN2 w0.089: v1(78.53,99.24) 79.04,99.24 81.3,101.5 81.3,102.21 81.96,102.87 v1(81.96,105.84)
  IN2 w0.254: 110.18,10.39 109.85,10.39 109.47,10.77
  IN2 w0.508: v1(39.53,53.49) 40.12,54.07 41.51,54.07 42.63,55.2 49.57,55.2 v1(50.24,55.87) 50.71,55.4 53.75,55.4 54.76,54.39 56.54,54.39 60.08,50.85 65.18,50.85 65.53,51.2 65.53,51.78 72.13,58.38 72.13,61.59 73.45,62.91 77.52,62.91 79.92,65.32 79.92,67.41 85.69,73.18 85.69,76.07 88.4,78.78 v1(88.4,78.88) ; v2(134.57,96.8) 134.57,97.49 132.94,99.12 132.94,100.46 132.05,101.35 132.05,102.17 v1(132,102.22) ; 142.32,102.96 142.32,102.96 137.73,102.96 136.22,104.47 134.22,104.47 133.12,105.57 130.1,105.57 128.88,106.79 127.73,106.79 126.08,108.43 124.28,108.43 123.85,108 123.85,107.39 v1(124.46,106.78) ; v1(54.99,98.07) 54.62,98.43 41.8,98.43 40.56,99.67 39.98,99.67 39.65,100 39.65,101.01 39.16,101.5 35.18,101.5 33.63,99.95
  IN2 w1.016: 98.96,13.87 98.12,13.87 97.18,12.93 93.22,12.93 92.19,13.96 88.06,13.96 87.62,13.52 80.37,13.52 79.19,12.34 75.23,12.34 ; 168.89,89.18 168.89,91.45
  IN3 w0.508: 128.75,105.41 128.04,106.12 125.12,106.12 v1(124.46,106.78) 124.31,106.63 122.75,106.63 121.99,107.39 116.07,107.39 112.77,104.08 105.92,104.08 105.36,103.52 104.01,103.52 103.53,104 101.76,104 101.45,104.31 101.45,105.12 100.83,105.74 ; 100.83,105.74 100.83,105.92 v1(102.93,108.02) ; 100.83,105.74 97.24,105.74 94.9,108.09 91.04,108.09 v1(90.96,108.01) 90.61,108.01 89.95,107.35 89.45,107.35 88.05,105.95 88.05,104.3 v1(87.83,104.09) 87,103.26 82.88,103.26 81.84,104.3 81.84,105.71 v1(81.96,105.84)
  BOTTOM w0.203: PR8846.2 PR8845.2 88.14,104.39 v1(87.83,104.09) ; v2(187.07,86.23) 187.14,86.29 U6100.45
  BOTTOM w0.254: 177,8.44 177,7.84 C1813.2 176.63,7.41 176.63,6.78 v1(176.55,6.7) ; PR10205.1 28.88,93.36 v1(28.2,94.04) ; PU8901.21 103.7,107.45 103.49,107.24 PC8929.2 103.33,107.24 103.33,107.63 v1(102.93,108.02) 102.53,108.43 102.53,110.52 PR8907.1 ; PR9119.1 131.31,103.29 132,102.6 v1(132,102.22) ; v1(54.99,98.07) 54.99,97.31 56.18,96.11 PR9826.2 ; PU8900.21 92.11,107.1 91.63,107.57 91.27,107.57 91.07,107.37 PC8910.2 90.73,107.78 v1(90.96,108.01) 90.37,108.59 PR8900.1
  BOTTOM w0.381: v1(50.24,55.87) PR10507.1
  BOTTOM w0.508: v1(81.96,105.84) 81.77,106.03 PR8805.1 ; PU8100.8 37.85,17.44 38.64,16.65 38.96,16.65 39.33,16.28 39.33,13.46 38.55,12.68 PC8103.2 38.55,12.14 38.48,12.07 38.48,11.82 v1(38.4,11.74) ; v1(88.4,78.88) 88.54,78.74 88.54,77.8 90.31,76.03 v1(90.31,73.6)
  vias: v1(11.33,25.04) v1(12.27,25.39) v1(12.9,25.39) v1(12.9,24.77) v1(13.53,25.39) v1(13.53,24.77) v1(14.16,25.39) v1(14.16,24.77) v1(157.63,13.41) v1(158.14,12.8) v1(158.27,13.41) v1(158.77,12.8) v1(158.9,13.41) v1(171.63,83.82) v1(173.05,82.58) v1(175.87,62.28) v1(175.94,11.45) v1(176.35,61.85) v1(176.32,12.06) v1(176.58,11.45) v1(176.96,12.06) v1(177.21,11.45) v1(177.59,12.06) v1(177.85,11.45) v1(197.4,80.98) v1(197.5,80.35) v1(197.6,79.74) v1(198.1,80.12) v1(200.33,81.05) v1(200.81,80.64) v1(203.26,79.87) v1(203.72,80.33) v1(204.04,83.68) v1(204.04,83.02) v1(204.04,82.31) v1(204.04,81.6) v1(204.04,80.93) v2(194.64,89.35) v2(195.04,89.76) v2(195.45,90.17) v2(195.65,88.77) v2(195.86,90.57) v2(196.06,89.18) v2(196.47,89.58) v2(196.57,88.92)
+5VPCU_R: length 4.2
  TOP w0.254: v1(175.92,6.7) 175.92,6.53 176.33,6.11 U1806.D3
  BOTTOM w0.254: 174.5,8.58 175.28,8.58 175.69,8.18 175.69,7.9 C1813.1 176.15,7.19 175.92,6.96 v1(175.92,6.7)
  vias: v1(172.11,11.45) v1(172.64,12.06) v1(172.74,11.45) v1(173.28,12.06) v1(173.38,11.45) v1(173.91,12.06) v1(174.01,11.45) v1(174.55,12.06) v1(174.65,11.45)
+V3.3DX_RT_TCP0: length 1.6
  BOTTOM w0.254: C2014.1 177.19,104.32 v1(177.06,104.44) 177.04,104.47 176.87,104.47 U2006.D3
  vias: v1(175.03,103.32)
+VCC0P9_LC_TCP0: length 1.2
  TOP w0.254: C5932.2 183.18,98.15 v2(183.63,97.7)
  BOTTOM w0.2: U5900.J3 v2(183.63,97.7)
+VCC0P9_LVR_TCP0: length 3.6
  BOTTOM w0.106: U5900.M6 U5900.L6
  BOTTOM w0.109: U5900.M6 185.04,99.14 184.3,99.87 C5934.2 183.18,100.33 C5933.2
+VCC0V9_SVR_TCP0: length 2.8
  BOTTOM w0.2: v2(186.22,96.39) 186.23,96.39 U5900.G9 ; U5900.E9 v2(186.25,95.11) ; U5900.F6 v2(184.95,96.41) U5900.G6 ; U5900.G3 v2(184.28,97.06) ; U5900.E3 v2(183.65,95.11)
  vias: v1(178.08,100.35) v1(178.28,101.9) v1(178.94,101.9)
+VCC0V9_SVR_TCP0_PHASE:
  vias: v1(181.89,99.49)
+VCC1.05_MIPI60: length 148.9
  TOP w0.254: v1(56.03,49.03) 56.72,48.35 56.72,43.51 55.42,42.22 54.42,42.22 52.28,40.08 R7701.1 ; v1(122.53,87.91) 122.53,86.92 121.23,85.62 117.17,85.62 116.28,86.51 115.87,86.51 115.31,87.07 115.31,89.15 v1(113.47,90.99) 113.27,91.2 v1(113.27,91.66) ; CON7703.44 42.81,49.98 43.84,51.01 v1(43.84,51.48) ; v1(52.39,50.98) 52.39,50.97 51.8,50.38 51.39,50.38 50.54,51.23 49.71,51.23 48.94,50.47 48.94,50.24 48.69,49.98 CON7703.43
  IN1 w0.254: v1(113.27,91.66) 112.85,91.66 112.09,92.42 106.67,92.42 106.37,92.12 105.68,92.12 104.42,93.38 99.95,93.38 99.3,92.73 97.33,92.73 96.45,93.6 93.25,93.6 92.27,94.57 v1(92.27,95.53) ; v1(89.61,95.14) 89.58,95.14 88.73,94.29 88.73,92.75 87.89,91.91 87.89,87.81 86.46,86.37 86.46,85.6 84.45,83.6 84.45,82.3 82.17,80.02 82.17,78.76 81.81,78.41 81.25,78.41 79.65,76.81 79.65,75.21 78.35,73.91 77.67,73.91 77.04,73.28 75.62,73.28 73.84,71.5 71.64,71.5 70.94,70.79 68.8,70.79 68.47,70.46 68.47,65.95 65.51,62.99 65.51,61.56 64.56,60.6 63.47,60.6 59.06,56.19 52.89,56.19 v1(52.7,56)
  IN2 w0.254: v1(43.84,51.48) 43.9,51.42 46.68,51.42 47.25,50.85 49.81,50.85 50.38,51.42 51.95,51.42 v1(52.39,50.98)
  IN3 w0.254: v1(92.27,95.53) 91.54,95.53 91.39,95.37 90.57,95.37 90.34,95.14 v1(89.61,95.14)
  BOTTOM w0.254: v1(52.7,56) 52.7,55.5 52.39,55.18 v1(52.39,50.98) 54.61,50.98 56.03,49.56 v1(56.03,49.03) ; R7700.2 122.53,89.98 C7700.1 v1(122.53,87.91)
+VCC1.05_OUT_FET: length 111.6
  TOP w0.254: v1(56.61,50.17) 55.74,50.17 55.31,49.73 55.31,44.33 52.46,41.48 R7710.1
  IN1 w0.508: v1(114.02,96.01) 113.98,96.05 100.26,96.05 v1(98.15,93.94)
  IN2 w0.254: v1(98.15,93.94) 98.35,93.74 98.35,88.77 100.96,86.15 100.96,85.67 100.71,85.42 99.46,85.42 99.2,85.68 98.37,85.68 96.2,83.51 96.2,82.15 95.8,81.75 95.8,80.35 93.56,78.12 92.8,78.12 92.5,77.99 90.7,76.18 90.7,74.65 89.84,73.8 89.84,71.17 88.48,69.81 87.11,69.81 86.76,69.47 86.27,69.47 83.51,66.71 83.51,65.35 81.42,63.26 81.42,62.82 76.81,58.21 75.88,58.21 71.61,53.94 70.84,53.94 66.5,49.6 58.82,49.6 57.79,50.64 57.08,50.64 v1(56.61,50.17)
  IN2 w0.508: v1(114.02,96.01) 115.32,94.71 119.02,94.71 119.84,93.9
  BOTTOM w0.254: v2(138.24,93.55) 138.24,93.55 138.36,93.43 138.36,93.34 138.69,93.01 R1242.2
  vias: v1(120.17,93.52) v1(120.62,93.98) v1(123.72,90.52) v1(124.18,90.98) v1(124.97,85.88) v1(137.17,97.9) v1(137.62,98.35) v1(137.72,97.28)
+VCC1.05_OUT_PCH: length 0.4
  BOTTOM w0.203: U400.DA31 137.24,72.26
+VCC3P3_ANA_TCP0: length 2.4
  BOTTOM w0.109: C5918.2 181.44,98.07 182.25,98.07 182.4,97.92 182.96,97.92 U5900.L2
+VCC3P3_LC_TCP0: length 9.3
  TOP w0.254: C5922.1 184.21,93.8 184.21,95.02 v2(184.3,95.11)
  BOTTOM w0.2: U5900.E5 v2(184.3,95.11)
  BOTTOM w0.203: v1(182.61,90.55) 182.67,90.61 R5941.2 ; R5937.2 R5939.2 180.76,91.07 181,90.82 v1(181,90.47) v1(181,89.84) 181,89.07 181.33,88.75 183.44,88.75 184.31,89.62 R5943.2
+VCC3V3_SX_TCP0: length 9.4
  TOP w0.254: C5921.1 185.06,93.73 184.64,94.15 184.58,94.3 184.58,94.64 184.95,95.01 v2(184.95,95.12)
  TOP w0.381: v2(184.29,97.72) 184.6,97.72 184.93,98.04 C5919.1 184.93,98.85 185.01,98.94 R5936.1 184.62,99.3 v2(184.34,99.02)
  BOTTOM w0.2: v2(184.95,95.12) 184.95,95.12 U5900.E6
  BOTTOM w0.203: U5900.M5 184.58,98.82 184.37,99.02 v2(184.34,99.02) 184.32,99.02 184.12,98.82 U5900.M4 ; R5933.2 183.12,90.78 183.12,90.21 R5934.2 182.41,90.05 181.96,90.5 v1(181.96,90.55)
  BOTTOM w0.254: U5900.J5 v2(184.29,97.72)
  vias: v1(176.81,102.74) v1(177.47,102.74) v1(178.08,104.59)
+VCC3V3A_SX_TCP0: length 4.5
  TOP w0.381: v2(185.58,97.69) 185.58,98.11 C5925.2 185.74,99.25 R5936.2 186.07,99.03 C5923.2 188.03,99.03 C5924.2
  BOTTOM w0.2: U5900.J7 185.61,97.69 v2(185.58,97.69)
+VCC_TS: length 22.7
  TOP w0.254: v1(34.3,36.03) 34.3,36.41 33.4,37.31 v1(32.94,37.31)
  BOTTOM w0.254: CON3400.40 29.34,45.25 29.46,45.37 R3400.1 29.87,46.33 v1(29.44,46.76) ; v1(32.76,45.72) 33.24,45.24 34.29,45.24 34.54,44.99 34.54,41.52 34.9,41.16 34.9,38.4 34.54,38.05 34.54,36.27 v1(34.3,36.03) 34.17,36.16 34.17,37.72 32.64,39.25 R3401.1 ; R3403.1 32.1,37.53 32.72,37.53 v1(32.94,37.31)
  vias: v1(30.43,50.11)
+VCC_TS_R: length 4.8
  TOP w0.254: R3419.2 30.99,53.15 30.99,54.41 30.72,54.67 C1917.1 30.09,54.96 U1908.D3
  TOP w0.508: R3419.2 v1(30.45,53.41)
+VCCDPHY_1P24: length 4.2
  BOTTOM w0.203: C1647.1 148.2,72.97 146.07,72.97 145.84,73.21 145.54,73.21 144.75,74 U400.DV28
+VCCDSW_1P05: length 1.3
  TOP w0.109: v2(137.79,69.16) 137.8,69.15 C1648.2
  BOTTOM w0.109: U400.DD38 137.87,69.16 v2(137.79,69.16)
+VCCIN: length 39.3
  TOP w0.254: PR8832.1 106.85,68.76 107.82,68.76 108.13,69.06 108.13,69.47 v2(108.52,69.86)
  BOTTOM w0.203: U400.BD9 120.21,82.68 ; U400.BD9 120.5,82.39 ; U400.BD9 120.21,82.11 ; U400.BD9 119.93,82.39 ; 127.71,81.93 U400.CA10 ; U400.CA10 127.99,81.65 ; U400.CA10 128.27,81.93 ; 125.46,68.9 U400.BT39 ; U400.BT39 125.18,69.19 ; U400.BT39 125.74,69.19 ; U400.BT39 125.46,69.47 ; U400.BA10 118.84,82.21 ; U400.BA10 119.12,81.93 ; U400.BA10 118.84,81.65 ; 119.06,68.9 U400.BB39 ; U400.BB39 119.06,69.47 ; U400.BB39 119.34,69.19 ; U400.BB39 118.77,69.19 ; U400.BJ10 122.78,81.93 ; U400.BJ10 122.5,82.21 ; U400.BJ10 122.22,81.93 ; U400.BJ10 122.5,81.65 ; U400.BE10 120.95,81.93 ; U400.BE10 120.67,81.65 ; U400.BE10 120.67,82.21 ; U400.BE10 120.39,81.93 ; 119.47,81.93 U400.BC10 ; U400.BC10 120.04,81.93 ; U400.BC10 119.75,82.21 ; U400.BH9 122.04,82.68 ; U400.BH9 121.76,82.39 ; U400.BH9 122.04,82.11 ; U400.BG40 121.63,68.72 ; U400.BG40 121.06,68.72 ; U400.BG40 121.34,69.01 ; U400.V31 108.95,72.71 ; U400.V31 108.34,72.71 ; U400.V31 108.65,72.41 ; U400.BJ40 122.26,69.01 ; U400.BJ40 121.98,68.72 ; U400.BJ40 122.54,68.72 ; U400.BG10 121.87,81.93 ; U400.BG10 121.58,81.65 ; U400.BG10 121.3,81.93 ; U400.BG10 121.58,82.21 ; 125.7,81.19 U400.BT12 ; U400.BT12 125.42,81.47 ; U400.BT12 125.7,81.75 ; U400.BT12 125.98,81.47 ; 127.25,81.47 U400.BY12 ; U400.BY12 127.53,81.19 ; U400.BY12 127.81,81.47 ; U400.BY12 127.53,81.75 ; 120.85,82.39 U400.BF9 ; U400.BF9 121.13,82.11 ; U400.BF9 121.13,82.68 ; U400.BF9 121.41,82.39 ; 128.45,81.19 U400.CB12 ; U400.CB12 128.16,81.47 ; U400.CB12 128.73,81.47 ; U400.CB12 128.45,81.75 ; U400.BH12 122.04,81.75 ; U400.BH12 122.32,81.47 ; U400.BH12 121.76,81.47 ; U400.BH12 122.04,81.19 ; U400.BM39 123.91,69.19 ; U400.BM39 123.35,69.19 ; U400.BM39 123.63,69.47 ; U400.BM39 123.63,68.9 ; 124.96,81.93 U400.BR10 ; U400.BR10 125.24,81.65 ; U400.BR10 125.53,81.93 ; 126.62,81.19 U400.BV12 ; U400.BV12 126.9,81.47 ; U400.BV12 126.62,81.75 ; U400.BV12 126.33,81.47 ; U400.AY39 118.14,69.47 ; U400.AY39 118.42,69.19 ; U400.AY39 118.14,68.9 ; U400.BB9 119.3,82.68 ; U400.BB9 119.02,82.39 ; U400.BB9 119.58,82.39 ; U400.BB9 119.3,82.11 ; 123.13,81.93 U400.BL10 ; U400.BL10 123.41,81.65 ; U400.BL10 123.7,81.93 ; 108.34,73.63 U400.V29 ; U400.V29 108.95,73.63 ; U400.V29 108.65,73.94 ; 122.89,68.72 U400.BL40 ; U400.BL40 123.17,69.01 ; U400.BL40 123.46,68.72 ; U400.BH39 121.8,69.47 ; U400.BH39 121.8,68.9 ; U400.BH39 122.08,69.19 ; U400.BH39 121.52,69.19 ; 119.23,68.72 U400.BC40 ; U400.BC40 119.51,69.01 ; U400.BC40 119.8,68.72 ; 123.81,68.72 U400.BN40 ; U400.BN40 124.37,68.72 ; U400.BN40 124.09,69.01 ; U400.BP12 125.07,81.47 ; U400.BP12 124.79,81.75 ; U400.BP12 124.5,81.47 ; U400.BP12 124.79,81.19 ; U400.BD39 119.97,69.47 ; U400.BD39 119.97,68.9 ; U400.BD39 119.69,69.19 ; U400.BA40 118.6,69.01 ; U400.BA40 118.88,68.72 ; U400.BA40 118.32,68.72 ; 122.43,69.19 U400.BK39 ; U400.BK39 123,69.19 ; U400.BK39 122.72,68.9 ; U400.BK39 122.72,69.47 ; U400.BU10 126.44,81.93 ; U400.BU10 125.88,81.93 ; U400.BU10 126.16,81.65 ; 125.92,69.01 U400.BU40 125.64,68.72 ; U400.BR40 125.29,68.72 ; U400.BR40 125,69.01 ; U400.BR40 124.72,68.72 ; 124.55,68.9 U400.BP39 ; U400.BP39 124.83,69.19 ; U400.BP39 124.26,69.19 ; U400.BP39 124.55,69.47 ; 120.15,68.72 U400.BE40 120.71,68.72
  vias: v1(92.97,98.24) v1(113.51,98.17) v2(103.09,76.34) v2(103.15,75.41) v2(103.17,73.61) v2(103.09,72.68) v2(103.74,76.34) v2(103.74,75.43) v2(103.74,73.6) v2(103.74,72.68) v2(103.87,86.83) v2(104.42,86.83) v2(104.39,76.34) v2(104.39,75.43) v2(104.39,73.6) v2(104.39,72.68) v2(105.04,76.34) v2(105.04,75.43) v2(105.04,73.6) v2(105.04,72.68) v2(105.69,76.34) v2(105.69,75.43) v2(105.69,73.6) v2(105.69,72.68) v2(106.38,76.34) v2(106.4,75.43) v2(106.4,74.51) v2(106.4,73.6) v2(106.4,72.68) v2(107.66,76.89) v2(107.69,75.96) v2(107.69,74.11) v2(108.31,76.89) v2(108.34,75.96) v2(108.34,74.11) v2(109.58,76.08) v2(110.15,76.07) v2(110.71,76.07) v2(111.29,76.06) v2(111.87,76.07) v2(112.44,76.06) v2(113,76.06) v2(113.58,76.06) v2(114.16,76.08) v2(118.58,69.37) v2(118.67,72.39) v2(118.96,82.71) v2(118.9,81.18) v2(119.01,69.75) v2(119.24,72.38) v2(119.43,80.93) v2(119.49,69.37) v2(119.82,82.72) v2(119.81,72.38) v2(119.97,69.75) v2(120.39,72.38) v2(120.67,81.4) v2(120.67,80.85) v2(120.7,82.73) v2(120.86,69.75) v2(120.95,72.35) v2(121.37,69.37) v2(121.53,72.35) v2(121.61,82.72) v2(121.6,81.46) v2(121.61,80.89) v2(121.78,69.75) v2(122.24,69.37) v2(122.64,69.75) v2(123.15,69.37) v2(123.39,81.23) v2(123.56,69.75) v2(123.81,80.87) v2(124.06,69.37) v2(124.55,69.75) v2(124.74,80.91) v2(125.03,69.37) v2(125.44,69.75) v2(125.68,80.85) v2(125.89,69.37) v2(126.12,81.18) v2(126.51,78.39) v2(127.07,78.38) v2(127.51,81.02) v2(127.63,78.38) v2(127.79,79.63) v2(128.47,80.92) v3(92.06,99.16) v3(92.86,99.15) v3(93.78,95.46) v3(94.51,95.44) v3(95.25,95.44) v3(96.01,95.4) v3(96.77,98.24) v3(96.77,97.5) v3(97.2,102.21) v3(97.51,98.22) v3(97.51,97.48) v3(97.63,102.83) v3(98.04,102.21) v3(98.25,98.22) v3(98.25,97.48) v3(98.4,102.89) v3(98.78,102.21) v3(98.98,98.22) v3(98.98,97.48) v3(99.18,102.89) v3(99.52,102.21) v3(99.92,102.89) v3(100.25,102.21) v3(100.68,102.89) v3(100.99,102.21) v3(101.47,102.89) v3(101.72,102.21) v3(102.21,102.89) v3(102.46,102.21) v3(102.94,102.89) v3(103.2,102.21) v3(105.87,98.24) v3(105.87,97.5) v3(106,92.76) v3(106.6,98.22) v3(106.6,97.48) v3(107.34,98.22) v3(107.34,97.48) v3(108.07,98.22) v3(108.07,97.48) v3(112.48,94.38) v3(112.5,93.6) v3(112.94,92.96) v3(113.21,94.39) v3(113.28,93.64) v3(113.7,92.96) v3(113.93,94.39) v3(114,93.64) v3(114.42,92.96) v3(114.67,94.39) v3(114.74,93.64)
+VCCIN_AUX: length 24.8
  BOTTOM w0.109: U400.CY1 136.22,86.88 136.09,87 v2(136.07,87)
  BOTTOM w0.203: 133.76,81.93 U400.CP10 133.2,81.93 ; 129.82,81.65 U400.CF10 ; U400.CF10 129.54,81.93 ; U400.CF10 130.1,81.93 ; 130.73,81.65 U400.CH10 ; U400.CH10 130.45,81.93 ; U400.CH10 131.02,81.93 ; 131.37,81.93 U400.CK10 ; U400.CK10 131.65,81.65 ; U400.CK10 131.93,81.93 ; 116.73,81.93 U400.AU10 ; U400.AU10 117.29,81.93 ; U400.AU10 117.01,81.65 ; 110.32,81.93 U400.AC10 ; U400.AC10 110.6,81.65 ; U400.AC10 110.89,81.93 ; U400.CD12 129.64,81.47 ; U400.CD12 129.36,81.19 ; U400.CD12 129.36,81.75 ; 117.92,81.65 U400.AW10 117.64,81.93 ; v2(131.44,87) 131.27,86.83 U400.CJ1 ; U400.AT12 116.83,81.47 ; U400.AT12 116.55,81.19 ; U400.AT12 116.55,81.75 ; U400.AT12 116.27,81.47 ; U400.BY39 127.29,69.47 ; U400.BY39 127.01,69.19 ; U400.BY39 127.29,68.9 ; v2(126.19,86.48) 126.22,86.48 126.32,86.38 U400.BV1 ; U400.BW40 126.83,69.01 ; U400.BW40 127.12,68.72 ; U400.BW40 126.55,68.72 ; 131.19,81.19 U400.CJ12 ; U400.CJ12 131.19,81.75 ; U400.CJ12 131.47,81.47 ; U400.CJ12 130.91,81.47 ; 116.38,81.93 U400.AR10 116.09,81.65 ; v2(128.88,86.81) 128.79,86.73 U400.CC1 ; 110.15,81.19 U400.AB12 ; U400.AB12 110.15,81.75 ; U400.AB12 110.43,81.47 ; U400.CG12 130.56,81.47 ; U400.CG12 130.28,81.75 ; U400.CG12 129.99,81.47 ; U400.CG12 130.28,81.19 ; U400.AE10 111.05,81.93 v2(111.04,81.94) ; U400.CM10 132.85,81.93 ; U400.CM10 132.28,81.93 ; U400.CM10 132.56,81.65 ; U400.CT10 134.68,81.93 ; U400.CT10 134.39,81.65 ; U400.CT10 134.11,81.93 ; U400.CR12 134.22,81.47 ; U400.CR12 133.94,81.19 ; U400.CR12 133.94,81.75 ; 134.85,81.75 U400.CU12 134.57,81.47 ; U400.CL12 132.11,81.75 ; U400.CL12 131.82,81.47 ; U400.CL12 132.39,81.47 ; U400.CL12 132.11,81.19 ; 126.38,68.9 U400.BV39 ; U400.BV39 126.38,69.47 ; U400.BV39 126.66,69.19 ; U400.AK2 U400.AK1 114.18,86.62 v2(114.18,86.82)
  BOTTOM w0.254: v2(113.96,89.08) 113.84,89.21 113.84,90.35 PR9115.1 ; v2(133.65,86.48) 133.66,86.48 133.67,86.48 133.68,86.48 133.74,86.42 U400.CP1
  vias: v1(123.47,97.31) v1(126.49,72.37) v1(126.47,71.71) v1(126.45,70.49) v1(126.97,74) v1(127.08,70.49) v1(127.12,72.37) v1(127.11,71.71) v1(127.6,74) v1(128.24,74) v1(128.89,73.98) v1(129.53,73.98) v1(130.16,73.98) v1(130.65,77.84) v1(131.37,79.78) v1(131.31,77.8) v1(131.48,79.13) v1(131.97,79.55) v1(132.09,78.93) v1(132.13,73.92) v1(132.35,78.36) v1(132.77,73.92) v2(110.56,81.15) v2(116.08,80.87) v2(116.6,81.02) v2(117.61,80.83) v2(117.97,81.24) v2(126.43,69.75) v2(126.83,69.37) v2(127.24,69.75) v2(129.84,81.46) v2(129.93,80.83) v2(131.34,80.83) v2(131.67,81.31) v2(132.07,80.83) v2(132.47,81.21) v2(133.31,80.83) v2(133.86,80.86) v3(121.59,100.15) v3(121.59,99.41) v3(121.58,98.68) v3(121.92,100.81) v3(122.38,99.57) v3(122.43,98.8) v3(123.11,99.54) v3(123.17,98.8) v3(123.9,99.48) v3(123.91,98.75) v3(124.74,99.44) v3(124.74,98.7) v3(124.79,97.91) v3(125.55,99.45) v3(125.55,98.7) v3(125.54,97.96) v3(126.35,99.45) v3(126.31,98.7) v3(126.31,97.94) v3(127.07,99.46) v3(127.07,98.73) v3(127.07,97.97) v3(127.81,99.49)
+VCCIO_OUT: length 39.7
  TOP w0.254: v2(104.44,88.4) 104.46,88.4 104.47,88.42 104.52,88.42 106.22,90.11 R1035.1 R1032.1 R1036.1 R1033.1
  IN2 w0.381: v1(92.53,78.51) 92.53,78.51 92.56,78.51 92.58,78.53 93.4,78.53 95.39,80.52 95.39,81.92 95.79,82.32 95.79,83.44 95.42,83.82 95.42,84.88 97.25,86.71 99.72,86.71 v1(100.24,86.2)
  IN3 w0.381: v1(100.24,86.2) 100.24,86.75 100.96,87.47 101.39,87.47 102.3,88.38 104.42,88.38 v2(104.44,88.4)
  BOTTOM w0.254: U400.V15 109.28,79.77 109.78,79.27 109.78,78.56 v2(109.47,78.26)
  BOTTOM w0.508: 93.67,70.77 94.95,70.77 95.55,70.18 97.57,70.18 97.79,70.4 98.62,70.4 99.51,71.29 99.51,73.8 99.46,73.85 99.46,75.21 99.49,75.23 v1(99.52,75.23)
  vias: v1(92.94,75.21) v1(93.8,70.43)
+VCCLDOSTD_OUT_0P85: length 4
  BOTTOM w0.109: C1644.2 148.02,65.2 147.81,65.18 147.06,65.11 147.05,65.1 147.01,65.09 146.72,64.89 146.58,64.84 146.44,64.84 146.16,64.95 145.42,65.35 145.37,65.38 145.33,65.43 145.21,65.61 145.2,65.62 145.16,65.67 144.67,66.11 U400.DV46
+VCCRTC: length 24.7
  TOP w0.381: C1651.2 138.26,70.87 137.86,71.28 v2(137.86,71.28)
  IN3 w0.381: v1(159.3,68.14) 158.69,68.14 158.7,68.14 158.54,67.99 157.78,67.99 157.62,67.83 157,67.83 155.42,69.42 151.38,69.42 151.05,69.75 150.08,69.75 149.5,70.33 149.02,70.33 148.88,70.47 148.1,70.47 147.83,70.2 142.85,70.2 142.68,70.03 142.16,70.03 142.11,70.08 138.98,70.08 138.32,70.73 138.32,70.82 v2(137.86,71.28)
  BOTTOM w0.254: v2(137.86,71.28) 137.85,71.28 137.85,71.28 137.85,71.1 U400.DC35
+VCCST: length 175.9
  TOP w0.254: U2001.D2 121.82,92.15 ; U2001.D1 122.01,91.75 ; R1561.1 125.24,81.85 124.78,82.3 124.78,84.19 125,84.41 126.55,84.41 127.06,84.93 127.06,89.39 v2(126.79,89.66) ; R604.2 108.29,80.6 108.13,80.44 108.13,80.01 107.88,79.76 106.79,79.76 106.55,79.99 R600.2 106.26,80.44 105.69,79.88 104.38,79.88 101.53,82.72 101.53,84.83 102.11,85.41 102.11,86.84 100.88,88.08 100.88,90.26 99.1,92.05 99.1,93.37 v1(99.16,93.43) 99.42,93.69 R704.2 101.52,93.69 R703.2
  IN1 w0.381: v1(80.75,111.55) 81.75,110.55 81.99,110.55 82.42,110.12 82.42,109.41 81.87,108.86 81.87,108.3 83.23,106.93 83.23,105.99 84.1,105.13 85.37,105.13 87.68,102.82 87.68,102.16 88.9,100.94 88.9,99.86 92.63,96.12 97.16,96.12 97.54,95.74 97.54,93.72 97.94,93.32 99.05,93.32 v1(99.16,93.43) 101.08,95.35 114.99,95.35 117.24,93.1 v1(117.24,91.67)
  IN1 w0.508: v1(167.13,41.86) 167.39,42.12 168.58,42.12 169.93,40.76 170.97,40.76 173.69,38.05 ; v1(134.93,100.39) 134.93,100.52 135.46,101.04 141.81,101.04 142.39,100.45 v2(142.39,100.1)
  IN2 w0.508: 160.27,74.01 160.27,72.3 159.89,71.92 159.89,71.06 161.54,69.41 161.54,66.55 162.32,65.77 162.32,64.68 162.14,64.5 162.14,61.52 163.68,59.99 163.68,58.71 164.27,58.11 164.27,57.2 164.1,57.02 164.1,55.45 164.89,54.65 164.89,51.53 165.59,50.84 165.59,50.15 166.47,49.27 166.47,49.07 167.22,48.32 167.22,47.82 v1(167.75,47.29) ; 159.71,77.17 159.71,81.02 157.65,83.08 157.65,86.12 156.94,86.83 156.94,89.61 154.28,92.28 150.19,92.28 146.78,95.68 145.51,95.68 144.85,96.34 144.85,96.85 142.39,99.31 v2(142.39,100.1)
  IN3 w0.381: 189.99,25.14 191.77,23.36 195.99,23.36
  vias: v1(181.13,34.12) v1(200.94,16.94) v2(123.92,89.53) v2(123.92,88.95) v2(124.41,89.23) v2(200.18,17.93) v2(200.53,17.5)
+VCCST_S2: length 2.5
  TOP w0.254: U2001.D3 121.28,93.01 121.74,93.01 v1(122.06,93.34) 122.31,93.58 C2006.1
+VCCSTG:
  vias: v1(88.03,93.71) v1(88.03,93.06) v1(116.2,90.73) v1(116.2,90.09) v1(116.94,95.37) v1(118.54,95.38) v1(119.17,95.38)
+VCCSTG_OUT_FUSE: length 4.1
  BOTTOM w0.203: v2(112.44,82.4) 112.43,82.39 U400.AG10 ; 115.18,82.21 U400.AN10 114.9,81.93 ; 114.44,82.39 U400.AM9 ; U400.AM9 114.72,82.11 ; U400.AM9 115.01,82.39 ; U400.AM9 114.72,82.68 ; U400.AD12 U400.AF12 111.98,81.32 v2(111.68,81.02)
  BOTTOM w0.305: v2(111.98,81.9) 111.98,81.91 U400.AF9
  vias: v2(114.75,81.94)
+VCCSTG_OUT_LGC: length 16.7
  IN2 w0.089: v1(97.71,74.89) 97.71,74.98 100.24,77.51 100.97,77.51 103.89,80.44 106.09,80.44 106.47,80.82 106.47,82.29 v2(106.03,82.74)
  BOTTOM w0.109: R700.1 96.8,76.09 97.89,76.09 98.11,75.87 98.11,75.28 v1(97.71,74.89) ; v2(106.03,82.74) 105.69,82.39 U400.M9
+VCCSTG_TERM: length 13.4
  IN2 w0.254: v1(93.09,79.07) 94.41,80.39 v1(94.41,80.68)
  BOTTOM w0.254: v1(93.09,79.07) 93.57,78.59 93.57,77.69 93.97,77.29 95.3,77.29 v1(95.53,77.06) 95.87,76.72 R610.2 96.28,76.59 95.88,76.2 R700.2 95.91,75.93 R616.2 R607.2 ; v1(94.41,80.68) 94.49,80.68 94.72,80.9 R614.2 94.72,81.55 93.93,82.34 R605.2 93.73,82.82 93.48,82.82 92.88,83.41 R602.2
+VIN: length 63
  TOP w0.254: v1(87.07,111.2) 86.73,111.54 C2021.1 86.16,111.47 U2010.D3
  TOP w3.607: 153.16,105.86 130.4,105.86 128.34,107.92 128.34,107.97 124.45,111.87 113.67,111.87 ; 170.61,88.42 159.17,99.86
  IN2 w1.524: 45.21,100.88 46.34,100.88
  BOTTOM w0.508: EC2.1 94.88,18.78 v1(94.97,18.87)
  vias: v1(28.11,105.23) v1(28.11,104.59) v1(28.11,103.96) v1(28.11,103.32) v1(28.11,102.69) v1(28.75,105.28) v1(28.75,104.59) v1(28.75,103.96) v1(28.75,103.32) v1(31.37,55.45) v1(31.82,52.86) v1(32,55.45) v1(32.45,52.86) v1(32.64,55.45) v1(32.64,22.5) v1(32.64,21.59) v1(33.09,52.86) v1(33.27,55.45) v1(33.65,22.5) v1(33.65,21.59) v1(33.72,52.86) v1(33.91,55.45) v1(34.36,52.86) v1(34.67,22.5) v1(34.67,21.59) v1(87.07,110.54) v1(87.35,111.78) v1(87.75,111.22) v1(87.75,110.56) v1(88.09,111.78) v1(88.39,111.22) v1(88.39,110.56) v1(176.48,89.08) v1(176.48,88.44) v1(177.11,89.08) v1(177.11,88.44) v1(177.75,89.08) v1(177.75,88.44) v1(178.38,89.08) v1(178.38,88.44) v1(179.02,89.08) v1(179.02,88.44) v3(25.56,85.62) v3(25.92,86.28) v3(26.38,86.91) v3(51.44,18.03) v3(52.18,18.03) v3(52.91,18.03) v3(53.65,18.03) v3(54.39,18.03) v3(55.19,18.04) v3(55.92,18.04) v3(56.66,18.04) v3(57.39,18.04) v3(58.13,18.04) v3(66.37,111.25) v3(66.39,111.99) v3(66.52,105.46) v3(67.13,111.99) v3(67.1,111.25) v3(67.26,105.46) v3(67.87,111.99) v3(67.84,111.25) v3(67.99,105.46) v3(108.2,111.75) v3(108.2,110.99) v3(108.31,110.24) v3(108.94,111.75) v3(108.94,110.97) v3(109.05,110.21) v3(109.71,111.95) v3(116.69,17.96) v3(117.44,17.96) v3(118.17,17.96) v3(118.91,17.96) v3(138.52,18.04) v3(139.25,18.04) v3(140.02,18.04)
+VIN_1.8VPCU:
  vias: v1(118.21,14.63)
+VIN_3VPCU:
  vias: v1(137.18,13.17) v1(137.82,13.17) v1(138.43,13.03)
+VIN_5VPCU: length 6.9
  IN3 w0.254: v1(170.11,11.95) 170.11,14.78 v3(168.47,16.42)
  BOTTOM w0.254: v1(170.11,11.95) 170.11,10.95 PR8613.1
  vias: v1(166.6,15.64) v3(165.19,15.8) v3(166.26,16.42) v3(167,16.42) v3(167.73,16.42) v3(169.43,16.45)
+VIN_BLIGHT:
  vias: v1(26.59,31.37) v1(27.15,33.53) v1(27.15,32.89) v1(27.15,32.26) v1(27.18,31.6) v1(29.85,49.09) v1(29.85,48.45) v1(30.48,49.09) v1(30.48,48.45)
+VIN_BLIGHT_L:
  vias: v1(26.46,29.64) v1(26.84,24.76) v1(27.31,25.23) v1(27.66,24.69) v1(28.12,25.14)
+VIN_DDR: length 18.7
  TOP w0.203: v1(103.3,17.9) 103.81,18.41 104.82,18.41 105.03,18.21 105.03,16.89 106.59,15.32 106.59,14.11 106.84,13.87 107.98,13.87 108.15,13.7 108.15,12.11 108.07,12.04 PR8704.2
  IN3 w0.254: v1(103.3,17.9) 103.3,17.85 100.63,15.19 96.53,15.19 v3(96.34,15)
  vias: v1(94.84,13.41) v3(94.14,15) v3(94.14,14.26) v3(94.88,15) v3(94.88,14.26) v3(95.61,15) v3(95.61,14.26) v3(96.34,14.26)
+VIN_FBVDDQ_MEM:
  vias: v1(32,93.19) v3(31.62,89.58) v3(31.62,88.85) v3(31.62,88.11)
+VIN_GPU:
  vias: v1(50.19,103.58) v1(50.82,103.58) v1(51.46,103.58) v1(52.09,103.58) v1(53.19,102.19) v1(53.82,102.19) v1(76.07,111.02) v1(76.71,111.02) v1(76.71,110.36) v1(76.71,109.7) v1(76.71,109.07) v1(77.34,111.02) v3(69.09,111.99) v3(69.09,111.25) v3(69.82,111.99) v3(69.82,111.25) v3(70.58,111.99) v3(70.58,111.25) v3(71.35,111.99) v3(71.35,111.25)
+VIN_VCC_CORE: length 20.2
  BOTTOM w0.508: 100.49,110.96 98.49,112.96 82.64,112.96 82.13,112.45 PR8804.1
  vias: v1(106.47,108.99) v3(99.45,108.36) v3(99.62,107.59) v3(100.2,108.36) v3(100.35,107.59) v3(100.96,108.36) v3(101.09,107.59) v3(101.7,108.35) v3(109.05,106.96) v3(109.05,106.19) v3(109.83,106.95) v3(109.83,106.21) v3(110.57,107.01) v3(110.59,106.27)
+VIN_VCC_CORE_R: length 8.9
  TOP w0.254: U2010.D1 U2010.D2 85.92,111.07 C2021.2 86.23,110.36 86.72,109.87 90.6,109.87 92.05,111.33 PR8914.1
  vias: v1(96.19,109.85)
+VIN_VCCIN_AUX:
  vias: v1(117.12,109.38) v3(114.78,109.65) v3(115.54,109.65) v3(118.74,109.65) v3(122.45,109.65)
+VIN_VCCIN_AUX_R:
  vias: v1(113.36,107.64)
AGND: length 15.6
  TOP w0.203: v1(197.46,40.89) 197.09,40.52 U3600.31 ; v1(196.8,34.41) 196.55,34.67 U3600.19 ; v1(194.03,34.34) 194.15,34.46 U3600.13
  TOP w0.254: C3700.1 202.29,36.54 v1(202.78,36.05) ; v1(207.19,28.5) 206.82,28.86 EC3603.1
  TOP w0.381: v2(197.18,32.79) 197.11,32.85 C3613.1 ; v1(197.46,40.89) 197.53,40.89 197.93,41.29 C3605.2 ; EC3704.1 201.58,42.62 v1(201.39,42.62) 201.2,42.62 EC3607.1 ; v1(200.8,35.28) 200.39,35.69 C3603.2 ; v1(203.5,41.65) EC3606.1 ; v1(202.46,33.56) C3702.1 ; v1(212.37,41.93) 211.91,42.39 EC3703.1 ; C3608.2 197.31,42.92 v2(197.71,42.92)
  BOTTOM w0.305: EC3702.1 203.53,41.68 v1(203.5,41.65)
  BOTTOM w0.381: EC3700.1 210.06,28.38 v1(210.26,28.57) ; v1(207.19,28.5) 207.07,28.39 EC3701.1 ; C3701.1 200.44,34.92 v1(200.8,35.28)
  vias: v1(200.03,33.48) v1(200.51,33.04) v1(201.16,33.56) v1(204.43,34.57) v1(204.47,33.49)

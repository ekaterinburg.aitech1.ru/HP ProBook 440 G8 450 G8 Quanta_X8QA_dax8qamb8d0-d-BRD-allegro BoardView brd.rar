# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PROCPWRGD: length 2
  TOP w0.109: v2(123.42,82.72) 122.93,82.23 R1549.2
  BOTTOM w0.109: U400.BM9 123.74,82.39 v2(123.42,82.72)
PSI: length 82.9
  TOP w0.109: PR9810.1 35.15,107.08 34.97,107.26 34.97,107.77 35.25,108.05 38.1,108.05 40.07,106.08 40.64,104.7 40.64,104.46 40.84,103.97 40.84,102.05 v1(41.02,101.88) v1(41.55,101.34)
  IN3 w0.089: v1(84.35,87.49) 84.35,88.77 85.85,90.28 86.42,91.66 86.42,97.98 85.55,98.85 84.25,98.85 81.91,101.19 80.39,101.19 79.78,101.8 57.66,101.8 56.46,102.99 48.96,102.99 46.99,101.03 41.87,101.03 v1(41.55,101.34)
  BOTTOM w0.109: R6951.1 84.35,88.13 v1(84.35,87.49) 83.75,88.08 83.02,88.08 82.11,87.17 80.91,87.17 80.51,87.57 80.51,88.16 79.73,88.94 77.08,88.94 U6600.A4
PVADPTR: length 255.7
  TOP w0.254: v1(64.21,16.71) 64.21,16.2 PD8202.2 63.49,16.25 61.2,16.25 59.46,14.51 59.46,13.92 58.28,12.73 PR8210.2 57.61,12.73 56.47,13.87 55.55,13.87 55.51,13.9 53.52,13.9 53.19,13.56 53.19,12.06 v1(50.93,9.81) 50.76,9.64 PR8413.2 51.15,8.61 51.15,8.33 51.71,7.77 PR8240.1 ; v1(162.07,38.34) 162.06,38.34 162.06,39.73 162.4,40.07 162.4,41.04 161.94,41.5 161.94,42.92 161.75,43.11 161.75,47.19 162.06,47.5 162.06,51.47 165.1,54.51 166.12,54.51 167.51,55.9 170.16,55.9 170.37,55.7 175.32,55.7 175.53,55.91 178.47,55.91 178.92,56.36 179.98,56.36 180.24,56.1 182.05,56.1 182.52,56.57 v1(182.52,56.67)
  IN1 w0.254: v1(162.07,38.34) 162.07,37.83 163.1,36.8 166.62,36.8 169.13,34.29 171.17,34.29 172.64,32.81 173.45,32.81 173.58,32.94 174.09,32.94 174.45,32.59 174.45,32.1 175.41,31.14 176.86,31.14 180,27.99 180.07,27.99 180.93,27.14 180.93,24.88 181.14,24.68 181.14,23.98 182.99,22.12 182.99,19.92 183.54,19.38 183.54,18.31 182.5,17.27 180.89,17.27 180.58,17.57 173.63,17.57 173.05,18.16 170.5,18.16 169.67,17.81 167.83,17.81 167.43,18.21 165.79,18.21 165.1,17.52 155.61,17.52 154.91,16.82 152.74,16.82 152.45,16.54 148.34,16.54 147.9,16.1 145.4,16.1 144.9,16.61 144.3,16.61 143.81,16.13 136.14,16.13 135.17,17.1 132.39,17.1 131.8,16.51 125.27,16.51 124.43,15.67 115.14,15.67 114.53,15.06 110.77,15.06 109.48,13.77 107.16,13.77 106.4,14.53 98.14,14.53 97.1,15.57 94.85,15.57 93.45,16.96 92.78,16.96 92.38,16.56 89.63,16.56 89.38,16.81 88.26,16.81 87.91,16.46 86.99,16.46 86.64,16.81 84.55,16.81 84,16.25 81.18,16.25 80.03,17.4 80.03,18.29 79.47,18.84 73.53,18.84 70.99,16.3 65.48,16.3 65.07,16.71 v1(64.21,16.71)
  IN2 w0.254: v1(176.78,86.15) 176.78,85.73 178.36,84.14 178.36,81.41 182.6,77.17 182.6,75.28 183.38,74.5 183.38,72.94 183.77,72.56 183.77,71.92 184.35,71.34 184.35,69.82 184.88,69.29 184.88,67.06 183.33,65.51 183.33,57.87 182.52,57.05 v1(182.52,56.67)
PVCORE_PG: length 123.7
  TOP w0.109: PR9109.1 118.81,106.73 119.52,106.73 v1(119.92,106.33) ; PR8825.1 80.51,106.19 v1(80.11,105.79) ; R1513.2 161.68,67.39 v1(162.14,66.93)
  IN1 w0.079: v1(119.92,106.33) 120.5,106.91 121.49,106.91 121.69,107.11 122.81,107.11 v1(123.21,107.52)
  IN2 w0.089: v1(162.14,66.93) 162.54,67.33 162.54,67.96 162.3,68.2 162.3,69.43 161.24,70.5 161.24,71.04 161.83,71.64 161.83,73.13 162.46,73.76 162.46,75.69 163.08,76.3 163.08,76.81 162.06,77.84 162.06,78.3 161.12,79.24 161.12,81.29 159.85,82.56 159.85,86.3 158.34,87.81 158.34,89.31 154.29,93.36 149.9,93.36 146.86,96.39 146.86,96.62 143.97,99.51 143.97,101.65 143.62,102 137.45,102 136.71,102.74 135.08,102.74 132.81,105 129.87,105 128.65,106.22 127.45,106.22 127.33,106.35 124.25,106.35 123.21,107.39 v1(123.21,107.52)
  IN3 w0.089: v1(80.11,105.79) 80.68,105.79 83.98,109.09 88.31,109.09 89.75,110.53 92,110.53 92.82,109.71 96.52,109.71 97.09,110.29 105.76,110.29 107.34,108.7 111.34,108.7 111.99,108.05 122.68,108.05 v1(123.21,107.52)
PVT_CS#: length 8.9
  TOP w0.109: v2(201.17,27.53) 201.17,27.15 202.12,26.19 202.12,24.85 202.18,24.79 202.18,23.73 R4701.2
  BOTTOM w0.109: v2(201.17,27.53) 200.96,27.53 200.05,28.45 TP5617.1 200.05,29.03 199.98,29.1 R5629.2 199.74,29.51 199.41,29.18 U5605.1
PVT_CS#_L: length 4.4
  TOP w0.076: U4700.L10 198.37,20.57 198.7,20.9 199.21,20.9 199.57,21.26
  TOP w0.109: R4701.1 201.24,22.93 199.57,21.26
PVT_DIO2: length 4.2
  TOP w0.109: R5633.1 200.58,26.98 TP5612.1 200.88,26.67 201.35,26.67 201.91,26.11 201.91,24.62 201.83,24.53 R4705.2
PVT_DIO2_L: length 4
  TOP w0.109: R4705.1 201.54,23.62 201.45,23.62 201.22,23.39 201.22,23.21 199.22,21.22 U4700.M11
PVT_DIO3: length 12.2
  TOP w0.109: v2(201.08,26.25) 200.99,26.15 200.99,25.37 R4706.2 ; R5634.2 191.51,29.33 193.32,29.33 v1(193.42,29.23) 193.45,29.26 197.09,29.26 197.86,28.5 198.78,28.5 199.59,27.68 v2(199.59,27.48)
  IN1 w0.079: v2(199.59,27.48) 200.83,26.25 v2(201.08,26.25)
PVT_DIO3_L: length 5
  TOP w0.076: 199.02,22.48 199.02,22.41 198.7,22.1 198.7,21.71 198.36,21.38 U4700.L11
  TOP w0.109: R4706.1 199.9,24.72 199.79,24.61 199.79,23.72 199.13,23.06 v1(199.13,22.76) 199.02,22.64 199.02,22.48
PVT_HOLD: length 4.7
  TOP w0.109: v2(189.68,27.87) 189.68,28.52 TP5613.1 190.47,29.31 R5634.1 191.03,28.09 R5631.2
  BOTTOM w0.109: U5605.7 189.72,27.91 v2(189.68,27.87)
PVT_MOSI: length 12.7
  TOP w0.109: v2(197.96,24.38) 197.96,24.95 198.21,25.2 R4703.2
  BOTTOM w0.109: U5603.5 191.41,25.37 192.89,23.9 197.46,23.9 197.53,23.98 199.67,23.98 TP5615.1 199.47,24.38 v2(197.96,24.38)
PVT_MOSI_L: length 3.2
  TOP w0.109: R4703.1 198.35,24.72 198.35,24.23 197.86,23.75 v1(197.86,22.78) 197.86,22.5 197.71,22.35 U4700.K12
PVT_SCLK: length 14.4
  TOP w0.109: v2(200.45,25.58) 200.15,25.58 199.72,25.15 R4702.2
  BOTTOM w0.109: U5603.6 191.21,26.64 191.68,26.17 191.68,25.82 193.11,24.39 197.02,24.39 197.51,24.88 199.6,24.88 199.92,25.19 201.27,25.19 TP5614.1 200.94,25.58 v2(200.45,25.58)
PVT_SCLK_L: length 3.5
  TOP w0.109: U4700.L12 198.36,22.15 198.63,22.42 198.63,23.04 199.51,23.92 199.51,24.52 199.33,24.7 R4702.1
PVT_SPI_MISO: length 1.4
  TOP w0.109: v2(201.54,25.91) 201.52,25.88 R4704.2
  BOTTOM w0.109: R5630.1 201.91,25.53 201.54,25.9 201.54,25.9 v2(201.54,25.91)
PVT_SPI_MISO_L: length 4.5
  TOP w0.109: R4704.1 201.45,24.82 201.45,23.92 200.63,23.11 v1(200.38,23.11) 200.12,22.86 200.12,22.43 199.57,21.87 U4700.M12
PVT_SPI_MISO_R: length 5
  BOTTOM w0.109: U5605.2 200.05,27.91 200.99,26.97 TP5616.1 202.08,26.34 202.16,26.26 R5630.2
PWM1: length 6.1
  TOP w0.203: PU8800.14 87.59,107.53 87.87,107.81 v1(88.07,107.81)
  IN3 w0.203: v1(88.07,107.81) 88.52,108.26 88.52,108.3 89.89,109.67 v1(91.09,109.67)
  BOTTOM w0.203: v1(91.09,109.67) 91.09,109.12 PR8902.1
PWM1_R: length 1.5
  BOTTOM w0.203: PU8900.22 92.2,107.6 92.02,107.78 PR8902.2
PWM2: length 18.4
  TOP w0.203: v1(88.02,108.45) 87.51,107.93 PU8800.15
  IN3 w0.203: v1(88.02,108.45) 88.25,108.45 89.92,110.12 91.8,110.12 91.83,110.08 ; 102.4,109.85 102.73,109.52 v1(103.04,109.52)
  IN3 w0.254: 102.4,109.85 97.28,109.85 96.7,109.27 92.64,109.27 91.83,110.08
  BOTTOM w0.203: v1(103.04,109.52) 103.04,108.85 PR8909.1
PWM2_R: length 1.6
  BOTTOM w0.254: PR8909.2 103.65,108.55 104.24,107.95 PU8901.22
PWM_EC_IN: length 5.3
  TOP w0.076: v2(194.14,16.34) 194.57,16.34 194.9,16.02 U4700.F3
  BOTTOM w0.076: C4713.1 195.25,15.69 194.6,16.34 v2(194.14,16.34) 193.77,15.97 193.34,15.97 193.27,15.9 R4732.1 193.03,15.63 192.42,16.23 R4731.2
PWM_EC_OUT: length 221.3
  TOP w0.109: v1(85.05,16.29) 85.05,15.78 85.95,14.88 85.95,10.47 v1(86.96,9.46) ; R3432.2 33.48,39.01 34.29,39.01 34.61,38.69 34.61,38.01 v1(34.99,37.63) 35.81,36.8 35.81,35.32 35.64,35.15 35.64,33.57 36.11,33.09 36.11,31.87 v1(35.83,31.59)
  TOP w0.14: U4700.K5 198.04,16.99 v2(198.69,16.99)
  IN1 w0.076: v2(198.69,16.99) 199.11,16.57 199.11,15.29
  IN1 w0.079: v1(86.96,9.46) 86.96,9.38 87.83,8.51 95.97,8.51 96.49,7.99 98.37,7.99 99.45,6.92 101.85,6.92 102.28,6.49 103.66,6.49 104.64,5.51 114.37,5.51 115.91,7.05 130.21,7.05 130.87,7.71 132.56,7.71 133.24,7.03 136.3,7.03 136.84,7.57 139.59,7.57 140.63,6.53 142.2,6.53 142.64,6.97 143.08,6.97 143.52,6.53 145.22,6.53 145.63,6.95 146.25,6.95 146.66,6.53 150.69,6.53 151.3,7.15 157.63,7.15 158.18,6.6 160.42,6.6 160.68,6.86 161.84,6.86 162.71,7.73 164.64,7.73 165.16,8.25 168.47,8.25 172.57,4.16 177.12,4.16 178.42,5.46 180.89,5.46 182.79,7.36 185.59,7.36 185.91,7.68 185.91,8.04 186.08,8.2 187.09,8.2 188.06,7.23 189.1,7.23 189.55,6.77 193.63,6.77 193.76,6.91 194.57,6.91 194.79,6.69 195.26,6.69 195.82,6.13 196.35,6.13 196.57,6.35 196.57,6.83 196.39,7.01 196.39,8.77 197.86,10.25 197.86,11.22 199.44,12.8 199.44,13.87 199.11,14.2 199.11,15.29
  IN2 w0.089: v1(85.05,16.29) 84.87,16.11 82.27,16.11 81.09,17.29 72.46,17.29 69.97,14.81 65.15,14.81 63.53,13.18 60.82,13.18 58.81,15.19 48.64,15.19 45.87,17.96 37.24,17.96 35.61,19.58 33.8,19.58 32,21.38 32,28.9 34.26,31.16 35.41,31.16 v1(35.83,31.59)
PWM_EC_OUT_R: length 1.5
  TOP w0.109: U3405.1 31.38,39.01 32.15,39.01 32.31,38.84 R3432.1
PWM_LED#: length 190
  TOP w0.076: v2(196.74,20.89) U4700.H10
  TOP w0.109: v1(86.34,16.25) 86.18,16.09 86.18,10.85 v1(87.58,9.46)
  IN1 w0.076: 196.7,20.5 196.7,20.85 v2(196.74,20.89)
  IN1 w0.079: v1(87.58,9.46) 88.36,8.67 96.03,8.67 96.55,8.15 98.45,8.15 99.53,7.07 101.92,7.07 102.34,6.65 103.72,6.65 104.7,5.67 114.28,5.67 115.83,7.21 130.12,7.21 130.78,7.87 132.63,7.87 133.3,7.19 136.24,7.19 136.78,7.73 139.73,7.73 140.76,6.69 142.14,6.69 142.58,7.13 143.14,7.13 143.58,6.69 145.15,6.69 145.57,7.11 146.31,7.11 146.73,6.69 150.62,6.69 151.24,7.31 157.76,7.31 158.29,6.78 160.35,6.78 160.63,7.06 161.81,7.06 162.3,7.55 162.3,7.92 162.86,8.48 168.53,8.48 172.59,4.42 177.15,4.42 178.35,5.62 180.82,5.62 183.38,8.17 185.83,8.17 186.01,8.36 187.15,8.36 188.13,7.38 189.16,7.38 189.62,6.93 193.57,6.93 193.7,7.06 194.64,7.06 194.85,6.85 195.9,6.85 196.23,7.18 196.23,8.84 197.64,10.24 197.64,12.98 198,13.35 198,13.9 198.09,13.99 198.09,14.48 196.9,15.67 196.9,16.96 195.68,18.18 195.68,19.04 196.7,20.06 196.7,20.5
  IN2 w0.089: v1(44.84,15.04) 45.45,14.42 49.58,14.42 49.99,14.83 58.67,14.83 60.67,12.82 63.68,12.82 65.3,14.45 70.12,14.45 70.78,15.11 75.05,15.11 75.51,14.66 79.13,14.66 80.17,15.7 85.79,15.7 v1(86.34,16.25)
  BOTTOM w0.109: Q5006.2 44.88,12.87 v1(44.37,13.39) 44.25,13.5 44.25,14.66 44.63,15.04 v1(44.84,15.04)
PWR_BTN_OUT#: length 104.6
  TOP w0.109: R4819.1 167.38,36.16 R4817.2 166.85,36.8 v1(166.83,36.83) 166.58,37.07 166.58,39.3 166.92,39.64 v1(166.96,39.64) 166.96,40.14 168.48,41.66 168.48,41.94 169.4,42.86 169.4,44.51 170.09,45.2 v1(170.19,45.2)
  TOP w0.14: v2(193.49,20.89) 193.49,20.24 U4700.D9
  IN2 w0.089: v2(141.18,68.77) 141.54,69.14 141.96,69.14 142.23,68.86 142.23,67.43 142.04,67.25 142.04,66.69 141.87,66.52 140.59,66.52 140.27,66.2 140.27,63.87 140.69,63.45 140.69,61.08 141.83,59.94 141.83,58.46 142.06,58.24 142.06,57.33 140.86,56.13 140.86,54.58 146.22,49.22 147.14,49.22 149.03,47.33 150.19,47.33 151.44,46.07 153.39,46.07 156.28,43.17 156.95,43.17 157.15,42.97 158.29,42.97 158.54,42.72 158.54,41.98 159.85,40.67 160.89,40.67 161.59,39.97 162.18,39.97 162.35,40.15 165.33,40.15 165.84,39.64 v1(166.96,39.64) ; v2(193.49,20.89) 193.38,20.89 193.01,21.26 192.53,21.26 192.16,20.89 190.7,20.89 190.2,21.38 190.2,22.03 188.52,23.71 188.52,24.16 188,24.69 187.63,24.84 187.48,24.99 186.88,24.99 185.6,26.27 184.21,29.63 184.21,30.79 181.63,33.37 181.34,33.37 179.69,35.02 179.69,35.98 179.3,36.37 179.3,37.21 178.26,38.24 176.62,38.24 176.33,38.53 176.33,43.69 174.83,45.2 172.95,45.2 172.68,44.93 172,44.93 171.87,44.8 170.59,44.8 v1(170.19,45.2)
  BOTTOM w0.109: U400.DK41 140.87,68.47 v2(141.18,68.77)
PWR_BUT_OUT: length 1.5
  TOP w0.109: R7504.2 21.51,41.22 21.59,41.3 U7500.7
PWR_GOOD_3: length 355.6
  TOP w0.109: v1(157.27,78.72) 157.7,78.72 159.4,80.43 161.23,80.43 161.63,80.82 162.87,80.82 v1(163.16,80.53) ; U4700.M4 199.29,16.4 199.29,16.37 199.55,16.11 199.57,16.11 199.91,16.11 200.28,15.74 201.42,15.74 C4807.1 201.29,15.24 v2(201.19,15.34) ; v1(183.84,6.32) 182.52,6.32 181.3,7.54 179.32,7.54 178.37,8.48 175.94,8.48 175.72,8.25 174.37,8.25 173.2,9.42 170.71,9.42 170.57,9.56 167.27,9.56 166.57,10.26 166.57,10.44 165.94,11.07 165.94,11.18 165.23,11.88 164.62,11.88 164.07,12.43 164.07,14.97 163.57,15.47 163.57,17.27 v1(162.81,18.03)
  IN1 w0.079: v1(183.84,6.32) 185.76,6.32 186.25,5.83 186.95,5.83 187.49,5.29 192.11,5.29 192.2,5.2 194.4,5.2 195.22,4.37 195.22,3.87 195.57,3.52 195.91,3.52 196.35,3.97 196.87,3.97 197.2,4.3 199.26,4.3 200.32,4.74 201.98,6.4 201.98,6.88 202.29,7.19 202.29,9 201.39,9.9 201.39,12.3 201.45,12.36 201.45,13.16 201.21,13.4 201,13.4 200.71,13.68 200.71,14.03 201.19,15.19 v2(201.19,15.34)
  IN2 w0.089: v1(157.27,78.72) 157.38,78.62 157.38,76.04 157.46,75.95 157.46,74.92 158.31,74.06 158.31,72.89 157.62,72.19 157.62,71.57 155.75,69.7 155.75,69.17 154.49,67.91 154.49,67.23 156.85,64.87 156.85,64.45 157.88,63.42 157.88,61.51 157.81,61.44 157.81,60.99 158.58,60.23 158.58,59.31 157.75,58.48 157.75,57.85 158.17,57.43 158.17,55.22 158.26,55.13 158.26,54.21 159.5,52.97 159.81,52.97 160.35,52.43 160.35,51.85 160.05,51.56 160.05,50.63 v1(160.55,50.13) ; v1(163.16,80.53) 163.24,80.61 163.24,84.69 160.25,87.68 160.25,88.39 154.58,94.05 150.21,94.05 147.6,96.67 147.6,99.08 146.73,99.95 146.73,100.51 146.35,100.89 145.01,100.89 143.71,102.18 137.53,102.18 136.79,102.92 135.15,102.92 132.89,105.18 129.94,105.18 128.72,106.4 127.53,106.4 127.15,106.78 v1(125.78,106.78)
  IN3 w0.089: v1(160.55,50.13) 163.02,47.66 163.02,46.86 163.65,46.23 166.04,46.23 166.42,45.84 166.42,45.29 168.08,43.63 168.08,41.59 169.98,39.69 170.8,39.69 171.68,38.81 171.68,36.76 172.64,35.8 172.64,35.23 174.65,33.21 174.65,31.84 177.58,28.91 177.58,27.61 178.03,27.16 178.03,24.81 178.14,24.7 178.14,21.21 177.43,20.49 176.44,20.49 175.56,19.61 164.39,19.61 v1(162.81,18.03) 161.87,17.09 157.23,17.09 155.67,18.64 141.65,18.64 141.63,18.66 136.35,18.66 135.54,17.85 135.22,17.85 134.97,18.09 134.97,18.55 134.72,18.81 120.1,18.81 119.54,19.38 112.62,19.38 110.64,17.4 105.46,17.4 105.41,17.35 104.39,17.35 104.06,17.68 104.06,18.27 103.7,18.64 102.98,18.64 102.17,17.83 102.17,17.61 100.44,15.88 93.86,15.88 93.49,15.52 89,15.52 88.92,15.44 88.03,15.44 88,15.47 86.01,15.47 85.85,15.31 80.14,15.31 79.23,14.41 75.67,14.41 74.48,15.59 71.75,15.59 70.04,13.89 67.49,13.89 67.2,14.18 63.12,14.18 62.24,13.3 58.56,13.3 58.33,13.07 57.99,13.07 56.91,14.15 53.69,14.15 53.56,14.28 47.74,14.28 45.8,12.34 44.86,12.34 43.93,11.41 v1(43.93,11.37)
  BOTTOM w0.109: v1(157.27,78.72) 156.16,79.83 D1500.1 ; v1(125.78,106.78) 125.78,106.55 125.12,105.89 R3309.1 ; v1(43.93,11.37) 43.99,11.31 43.99,10.69 43.86,10.56 PR8117.1 43.68,10.64 43.39,10.93 42.35,10.93 41.9,11.38 PR8115.2 41.9,11.66 41.65,11.91 41.2,11.91 PC8104.2 41.33,13.03 41.33,17.01 41.76,17.44 PU8100.1
PWR_LEVEL: length 15.6
  TOP w0.109: v2(74.03,85.99) 74.03,87.82 77.39,91.18 77.39,92.38 77.04,92.73 77.04,93.37 76.71,93.7 76.71,94.07 75.84,94.94 75.84,95.53 75.33,96.04 R6950.2 75.33,96.39 75.66,96.72 v1(75.66,97.41) 75.66,97.72 75.49,97.89 D6902.2
  BOTTOM w0.109: v2(74.03,85.99) U6600.D7
PWRBTN#: length 60.2
  TOP w0.076: U4700.G5 v2(196.09,16.99)
  TOP w0.109: R4818.1 R4819.2 R4816.2 168.29,35.56 C4808.2 168.96,36.23 168.96,36.95 168.45,37.46 167.51,37.46 167.23,37.74 167.23,38.21 v1(167.55,38.53) 167.55,40.41 168.71,41.57 168.71,41.85 170.15,43.28 170.72,43.28 170.79,43.35 v1(170.78,43.35)
  IN1 w0.079: v1(170.78,43.35) 170.79,43.35 170.79,43.36 170.84,43.36 172.29,44.8 175.16,44.8 178.92,41.03 178.92,40.05 182.55,36.43 182.55,33.06 184.47,31.14 184.47,30.46 188.35,26.58 188.73,26.58 192.12,23.19 192.12,20.98 192.45,20.65 192.45,16.23 193.37,15.31 195.91,15.31 196.44,15.85 196.44,16.64 v2(196.09,16.99)
R_INB0_SCL: length 1.7
  BOTTOM w0.109: R1901.1 148.28,104.34 148.53,104.59 CON1900.2
R_INB0_SDA: length 1.6
  BOTTOM w0.109: R1902.1 149.33,104 CON1900.3
R_INB1_SCL: length 3.6
  BOTTOM w0.109: R1903.1 151.82,103.97 v1(152.14,104.29) 152.5,104.65 153.54,104.65 154.13,105.24 CON1900.9
R_INB1_SDA: length 4
  BOTTOM w0.109: CON1900.8 153.33,104.94 153.26,104.87 152.12,104.87 151.78,104.54 150.88,104.54 R1904.1
R_SPK+: length 95.6
  TOP w0.203: v1(193.83,43.14) v1(193.83,42.52) 193.83,42.26 194.15,41.94 U3600.38
  IN3 w0.762: 177.49,79.35 178.07,78.77 179.13,78.33 182.95,74.51 182.95,72.98 184.56,71.36 185.41,71.36 188.06,68.71 188.06,68.27 ; 194.86,48.13 193.29,45.78 193.29,43.76 ; 190.53,63.26 191.41,61.14 193.01,59.54 194.03,59.54 ; 147.6,103.15 146.91,103.83 145.22,103.83 144.77,103.65 144.42,103.3
  IN3 w1.016: 144.42,103.3 143.97,102.84 142.82,102.84 141.6,101.62 141.6,100.81 ; 194.03,59.54 194.86,58.7 194.86,48.13 ; 177.49,79.35 173.05,83.79 173.05,84.42 171.67,85.8 171.25,85.8 154.84,102.21 152.73,102.21 152.37,101.85 150.51,101.85 149.21,103.15 147.6,103.15 ; 190.53,63.26 189.3,64.49 189.3,67.03 188.06,68.27
  vias: v1(141.12,100.12) v1(141.75,100.12)
R_SPK-: length 101.8
  TOP w0.203: v1(194.46,43.14) v1(194.46,42.52) 194.46,42.24 194.55,42.15 U3600.37
  IN3 w0.762: 194.31,44.24 194.31,45.06 194.87,45.62 194.87,46.3 196,47.44 196,60.09 197.09,61.17 197.59,62.4 197.59,63.45 197.47,64.08 197.1,64.97 196.06,66.01 194.53,66.65 192.28,66.65 191.26,67.66 190.54,67.66 185.82,72.39 184.99,72.39 183.96,73.41 183.96,74.94 179.22,79.68 178.96,79.68 ; 148.16,104.42 147.8,104.42 147.37,104.85 144.76,104.85 144.36,104.68 144.14,104.47 143.72,104.29 143.56,104.29
  IN3 w1.016: 143.56,104.29 142.47,104.29 139.6,101.42 139.6,100.81 ; 178.96,79.68 174.32,84.32 174.32,84.94 172.19,87.07 171.77,87.07 155.19,103.66 150.59,103.66 149.83,104.42 148.16,104.42
  vias: v1(139.2,100.11) v1(139.83,100.11)
REC_MUTE_LED: length 76
  TOP w0.109: R5007.1 128.66,10.23 130.45,10.23 130.71,9.98 130.71,9.88 131.53,9.05 133.18,9.05 133.81,9.68 133.81,11.43 133.86,11.48 133.86,11.84 134.93,12.92 134.93,17.41 v1(135.12,17.6) 135.12,17.98 v1(135.38,18.23) ; v1(173.89,32.48) 173.4,32.48 173.12,32.2 Q5001.3
  IN3 w0.089: v1(173.89,32.48) 173.89,32.1 177.22,28.77 177.22,27.46 177.67,27.02 177.67,24.66 177.79,24.54 177.79,21.35 177.28,20.85 176.27,20.85 175.39,19.96 163.35,19.96 160.65,17.26 157.31,17.26 155.75,18.82 141.83,18.82 141.81,18.84 135.98,18.84 v1(135.38,18.23)
RECORD_MUTE_LED_CNTRL: length 44.3
  TOP w0.109: v1(172.69,33.65) 172.13,33.09 R5016.1 ; v1(185.01,42.67) 185.21,42.67 v1(185.54,42.34) 186.05,41.84 186.31,41.84 187.31,40.84 R3616.2
  IN1 w0.079: v1(185.01,42.67) 185.01,43.59 184.58,44.02 184.06,44.02 183.5,44.59 182.3,44.59 182.29,44.6 181.45,44.6 180.82,45.23 180.82,45.55 180.18,46.2 178.77,46.2 177.12,47.84 176.8,47.84 175.84,48.8 174.54,48.8 174.11,48.37 173.56,48.37 173.33,48.59 172.61,48.59 172.15,48.13 171.42,48.13 171.24,48.31 169.69,48.31 169.24,47.85 169.24,47.62 168.23,46.62 166.76,46.62 166.14,46 165.89,46 v1(165.53,45.64)
  IN3 w0.089: v1(165.53,45.64) 166.19,44.98 166.23,44.98 167.72,43.48 167.72,41.44 169.83,39.34 170.66,39.34 171.33,38.66 171.33,36.61 172.27,35.67 172.27,34.65 172.69,34.24 v1(172.69,33.65)
REGN6V: length 5.3
  TOP w0.178: PU8200.24 60.54,5.9 60.61,5.83
  TOP w0.254: PD8203.1 62.56,3.33 62.41,3.48 PC8210.1 60.81,4.38 60.81,5.63 60.61,5.83
REQ_WLAN#: length 7.4
  TOP w0.109: Q4104.3 184.1,69.96 v1(184.1,70.28) 184.07,70.28 R4117.1 184.01,71.44 R4113.2 185.3,71.44 C4109.1 185.25,71.05 v1(184.83,70.63)
  BOTTOM w0.109: v1(184.83,70.63) 185.12,70.63 185.59,71.1 CON4100.53
RFFE_SCLK: length 6.7
  BOTTOM w0.109: R4228.2 192.83,42.71 192.83,43.08 193.54,43.78 196.66,43.78 197.04,44.16 CON4203.3
RFFE_SCLK_R: length 79.8
  TOP w0.109: v1(208.2,3.81) 208.44,4.05 208.44,5.04 R4230.1 208.22,7.49 207.69,8.02 207.03,8.02 206.78,8.28 205.2,8.28 v1(205.15,8.23)
  IN1 w0.079: v1(205.15,8.23) 205.59,8.66 205.59,11.36 205.5,11.58 204.49,12.59 204.49,14.7 204.73,14.94 204.73,16.24 205.19,16.69 205.19,22.59 202.77,25.01 200.24,25.01 199.36,25.88 199.36,25.88 198.17,27.08 195.22,27.08 193.86,28.44 193.42,28.44 192.69,29.17 192.29,29.17 190.77,30.69 190.77,30.69 189.73,31.73 189.73,33.85 188.59,35 188.59,36.3 187.54,37.34 187.54,42 v1(187.78,42.24)
  IN3 w0.089: v1(188.66,2.66) 188.66,2.34 189.59,1.41 206.01,1.41 207.41,2.82 207.81,3.21 207.81,3.41 v1(208.2,3.81)
  BOTTOM w0.109: CON4202.56 v1(188.66,2.66) ; R4228.1 190.71,41.86 C4218.2 189.85,42.72 188.26,42.72 v1(187.78,42.24)
RFFE_SDATA: length 4.8
  BOTTOM w0.109: CON4203.2 195.84,44.18 195.66,44 193.42,44 192.3,42.87 R4229.2
RFFE_SDATA_R: length 82
  TOP w0.109: v1(205.2,8.94) 205.64,8.51 v1(207.24,8.51) 207.52,8.51 208.67,7.36 208.67,5.42 208.66,5.41 208.66,3.02 208.25,2.61 207.8,2.61 v1(207.52,2.33)
  IN1 w0.079: v1(205.2,8.94) 205.43,9.17 205.43,11.32 205.36,11.5 204.33,12.52 204.33,14.77 204.57,15.01 204.57,16.3 205.03,16.76 205.03,22.53 202.7,24.85 200.17,24.85 198.1,26.92 195.15,26.92 193.79,28.28 193.35,28.28 192.62,29.01 192.23,29.01 189.57,31.67 189.57,33.79 188.43,34.93 188.43,36.23 187.39,37.27 187.39,42.96 187.78,43.36 v1(187.78,43.38)
  IN3 w0.089: v1(188.05,2.66) 189.48,1.24 206.42,1.24 v1(207.52,2.33)
  BOTTOM w0.109: v1(188.05,2.66) 188.16,2.55 CON4202.58 ; v1(187.78,43.38) 187.78,43.36 188.03,43.1 189.42,43.1 189.69,43.37 C4219.2 190.69,42.87 R4229.1
RFID_BEEP: length 49.6
  TOP w0.109: Q4400.3 186.31,32.62 186.05,32.88 186.05,33.34 185.8,33.6 185.8,35.56 v1(186.25,36.01) ; v2(209.6,14.96) 211.25,14.96 211.88,15.59 212.42,15.59 212.84,15.17 212.84,14.17 211.43,12.76 211.43,10.93 211.36,10.85 R4404.1 210.77,10.85 210.71,10.79 U4400.1
  IN2 w0.089: v2(209.6,14.96) 208.37,16.18 208.37,18.77 207.97,19.17 207.97,20.95 207.51,21.41 206.91,21.41 204.24,24.08 202.3,24.08 201.17,25.21 200.2,25.21 198.63,26.79 198.63,27.18 197.64,28.17 197.36,28.17 197.32,28.16 194.06,28.16 192.81,29.42 192.51,29.42 189.62,32.31 189.62,33.84 187.45,36.01 v1(186.25,36.01)
RFID_BEEP_EN#: length 103.5
  TOP w0.109: Q4400.2 186.45,33.27 186.02,33.69 186.02,34.36 v1(186.23,34.57) 186.02,34.77 186.02,35.23 186.36,35.57 v1(186.69,35.57) ; v2(140.57,75.01) 140.96,74.62 142.54,74.62 142.69,74.47 144.6,74.47 144.73,74.34 146.92,74.34 146.95,74.31 148.41,74.31 148.61,74.51 149.82,74.51 150.12,74.8 R1414.1
  IN1 w0.079: v1(184.77,46.06) 184.77,47.46 184.61,47.62 184.15,47.62 184.03,47.5 183.35,47.5 182.13,48.72 179.73,48.72 178.63,49.83 177.46,49.83 176.62,50.67 174.93,50.67 174.54,51.06 172.73,51.06 171.82,50.15 169.05,50.15 168.45,49.56 166.52,49.56 166.35,49.39 165.44,49.39 164.41,48.36 164.01,48.36 163.47,47.82 163.07,47.82 161.48,46.23 161.48,45.89 159.94,44.35 157.44,44.35 v1(157.22,44.58)
  IN2 w0.089: v1(157.22,44.58) 157.15,44.64 155.82,44.64 154.18,46.28 154.18,46.59 153.36,47.41 152.04,47.41 151.35,48.11 150.29,48.11 148.85,49.55 147.9,49.55 147.44,50.01 146.44,50.01 142.05,54.4 142.05,56.5 142.91,57.37 142.91,58.39 142.54,58.76 142.54,60.62 142.7,60.78 142.7,61.65 142.19,62.16 142.19,64.46 142.06,64.59 142.06,65.2 142.28,65.42 142.69,65.42 143.08,65.81 143.08,66.35 143.63,66.9 143.63,68.11 143.05,68.68 143.05,71.75 142.55,72.25 142.2,72.25 141.49,72.95 140.66,72.95 140.36,73.26 140.36,74.8 v2(140.57,75.01)
  IN3 w0.089: v1(186.69,35.57) 186.77,35.65 186.77,37.87 187.29,38.39 187.29,39.81 185.49,41.61 185.49,45.06 184.77,45.78 v1(184.77,46.06)
  BOTTOM w0.109: U400.DK25 140.57,75.26 v2(140.57,75.01)
RFID_CODEC_WAKE#: length 107.5
  TOP w0.109: v1(146.43,51.71) 146.43,51.89 R4413.1 146,52.17 146,51.1 146.48,50.62 Q4401.3 ; v1(193.43,32.54) 193.48,32.54 v1(194,32.03) 194.17,31.85 195.5,31.85 R3610.1 ; R1407.1 148.56,74.78 148.32,74.54 147.04,74.54 147.01,74.57 144.83,74.57 144.69,74.7 142.76,74.7 142.37,75.09 v2(142.35,75.09)
  IN2 w0.089: v2(142.35,75.09) 142.35,75.09 142.95,74.49 142.95,73.72 144.06,72.61 144.06,66.14 144.48,65.72 144.48,63.71 143.6,62.83 143.6,58.22 143.92,57.9 143.92,57.25 143.42,56.75 142.8,56.75 142.4,56.35 142.4,54.55 144.09,52.86 145.09,52.86 146.09,51.86 146.28,51.86 v1(146.43,51.71) 146.66,51.48 146.66,51.29 147.99,49.96 148.94,49.96 150.44,48.46 151.49,48.46 152.19,47.77 153.51,47.77 155.12,46.15 155.92,46.15 156.24,45.84 156.29,45.71 156.74,45.26 157.08,45.26 157.77,44.57 157.77,44.27 158.9,43.14 158.9,42.12 159.99,41.03 161.04,41.03 161.73,40.33 162.03,40.33 162.21,40.5 165.48,40.5 165.95,40.03 166.52,40.03 166.69,40.21 167.19,40.21 168.65,38.75 169.27,38.75 169.66,39.14 171.12,39.14 172.08,38.18 172.08,37.59 172.47,37.2 172.47,36.21 173.03,35.65 v1(173.03,35.42)
  BOTTOM w0.109: v2(142.35,75.09) 142.35,75.09 142.35,75.38 U400.DN25 ; v1(173.03,35.42) 172.79,35.19 172.79,34.74 173.45,34.09 174.5,34.09 175.12,34.71 179.18,34.71 180.98,36.5 180.98,37.82 181.38,38.22 181.38,38.69 182.73,40.05 184.16,40.05 185.52,38.68 185.52,35.13 186.34,34.31 190.85,34.31 192.62,32.54 v1(193.43,32.54)
RFID_MOS_BEEP: length 2
  TOP w0.109: R4411.1 189.67,32.47 189.42,32.47 v1(189.23,32.28) 188.89,32.62 Q4400.4
RFID_PRESENT: length 131.5
  TOP w0.109: v1(212.39,16.23) 212.39,15.95 213.08,15.26 213.08,14.08 211.66,12.67 211.66,10.79 211.63,10.76 R4405.2
  IN1 w0.079: v1(155.92,45.59) 156.24,45.59 156.36,45.47 159.16,45.47 159.53,45.84 160.76,45.84 161.01,46.09 161.01,46.43 162.88,48.3 163.28,48.3 163.81,48.83 164.21,48.83 165.24,49.86 166.15,49.86 166.33,50.03 168.26,50.03 168.86,50.64 170.07,50.64 171.09,51.66 171.65,51.66 171.78,51.54 174.17,51.54 174.41,51.78 175.57,51.78 175.99,51.36 176.77,51.36 177.81,50.32 178.81,50.32 179.93,49.19 183.16,49.19 183.19,49.17 184.24,49.17 184.7,48.7 184.7,48.19 v1(185.82,47.08)
  IN2 w0.089: v1(185.82,47.08) 185.82,44.97 187.36,43.43 187.36,39.55 189.08,37.83 189.08,36.18 191.22,34.03 191.22,32.47 193.02,30.66 193.33,30.66 193.94,30.05 197.67,30.05 197.93,29.79 198.05,29.74 199.08,28.71 201.3,28.71 202.43,27.58 203.27,27.58 204.07,26.78 204.69,26.78 206.17,25.29 208.14,25.29 209.24,24.19 209.24,23.62 209.57,23.29 210.15,23.29 211.35,22.1 211.35,17.4 212.39,16.36 v1(212.39,16.23) ; v2(141.75,75.06) 142.13,74.67 142.47,74.67 142.75,74.39 142.75,73.63 143.85,72.52 143.85,66.03 143.46,65.63 143.19,65.63 142.93,65.37 142.93,64.94 143.5,64.37 143.5,64.03 143.42,63.95 143.42,58.15 143.75,57.82 143.75,57.32 143.35,56.92 142.72,56.92 142.23,56.43 142.23,54.47 146.48,50.21 147.48,50.21 147.92,49.78 148.87,49.78 150.36,48.28 151.42,48.28 152.12,47.59 153.43,47.59 155.43,45.59 v1(155.92,45.59)
  BOTTOM w0.109: v2(141.75,75.06) 141.75,75.34 U400.DM25
ROM_CS: length 24.1
  TOP w0.109: R6831.2 54.53,93.9 56.54,91.89 59.51,91.89 59.76,92.15 TP6902.1 61.54,92.15 63.19,90.5 63.19,88.59 63.7,88.08 69.04,88.08 69.9,87.22 v2(69.9,86)
  BOTTOM w0.109: U6600.D12 69.5,85.6 v2(69.9,86)
ROM_CS_R: length 5.1
  TOP w0.109: R6831.1 54.07,97.66 TP6800.1 54.48,97.94 54.81,97.61 55.93,97.61 56.06,97.74 U6801.1 56.79,98.31 56.92,98.45 R6826.2
ROM_SCLK: length 16.6
  TOP w0.109: R6838.2 65.58,95.18 v1(65.75,95) 66.49,94.26 v1(67.36,94.26)
  BOTTOM w0.109: U6600.C12 69.92,86.84 69.92,87.45 70.06,87.59 70.06,90.26 70.61,90.81 70.61,92.17 70.2,92.58 R6913.2 70.21,92.67 R6904.1 70.41,93.68 70.62,93.89 70.62,95.23 70.37,95.49 69.81,95.49 69.63,95.31 69.5,95 69.36,94.86 67.78,94.86 67.36,94.43 v1(67.36,94.26)
ROM_SCLK_R: length 2.9
  TOP w0.109: U6801.6 63.42,95.2 TP6806.1 R6838.1
ROM_SI: length 15.9
  TOP w0.109: v2(66.98,92.68) v1(66.39,93.27) 65.73,93.93 R6828.1
  BOTTOM w0.109: v2(66.98,92.68) 67.26,92.68 67.64,92.3 67.64,91.11 68.55,90.19 68.55,88.72 69.06,88.21 69.06,87.62 U6600.B12 69.67,87.39 69.67,87.61 69.84,87.77 69.84,90.48 68.76,91.56 68.76,92.23 R6911.2 69.19,93.29 69.2,93.3 R6902.1
ROM_SI_R: length 2.6
  TOP w0.109: U6801.5 TP6805.1 R6828.2
ROM_SO: length 25
  TOP w0.109: v1(65.34,92.45) 64.29,92.45 64.08,92.66 59.76,92.66 59.38,92.28 56.49,92.28 54.81,93.95 54.81,95.73 TP6803.1 55.55,96.47 U6801.2
  BOTTOM w0.109: v1(65.34,92.45) 65.91,92.45 67.13,93.68 R6903.1 68.05,92.67 R6912.2 68.53,92.18 68.53,91.31 69.48,90.36 U6600.A12
RSMRST#: length 309.1
  TOP w0.109: v1(38.05,49.6) 38.5,50.04 R7724.1 ; v1(186.79,10.7) 186.79,10.64 187.41,10.02 Q4703.6 ; R4808.2 201.62,20.96 201.55,21.03 v1(201.01,21.03) v2(200.53,20.55) ; R7705.1 50.72,48.94 50.32,48.54 50.32,48.03 50.54,47.8 51,47.8 v1(51.43,48.23) 51.84,48.64 51.84,49.7 52.98,50.85 58.32,50.85 58.62,51.15 59.08,51.15 60.12,50.11 68.6,50.11 v1(69.52,49.19) 70.13,49.19 70.89,48.44 77.8,48.44 85.29,55.93 v1(85.85,55.93)
  IN1 w0.079: v2(141.84,71.38) 141.84,71.16 142.11,70.89 142.78,70.89 143.22,70.44 143.74,70.44 144.59,69.59 146.3,69.59 146.74,69.15 148.18,69.15 148.98,68.35 150.61,68.35 151.08,67.88 154.49,67.88 154.73,68.12 155.02,68.12 155.45,67.69 156.04,67.69 157,66.73 160.09,66.73 160.62,67.26 161.16,67.26 161.66,67.76 v1(162.16,67.76) ; v1(167.68,37.9) 167.19,37.41 163.31,37.41 162.54,38.18 162.54,38.59 162,39.13 160.8,39.13 159.81,40.12 156.59,40.12 150.25,46.46 v1(150.25,46.58)
  IN2 w0.089: v1(51.43,48.23) 51.03,48.64 50.42,48.64 50.04,48.26 47.32,48.26 45.51,50.06 38.52,50.06 v1(38.05,49.6) ; v1(184.94,32.93) 186.18,31.69 186.18,30.03 186.53,29.17 188.81,26.89 188.94,26.89 189.38,26.45 189.38,25.84 190.31,24.91 190.31,24.49 191.46,23.34 193.27,23.34 193.48,23.12 194.85,23.12 196.29,21.69 197.23,21.69 198.33,20.59 198.94,20.59 199.06,20.47 199.06,20.24 199.26,20.04 199.85,20.04 200.36,20.55 v2(200.53,20.55)
  IN3 w0.089: v1(186.79,10.7) 187.53,11.44 191.03,11.44 191.4,11.81 192.77,11.81 192.86,11.9 196.9,11.9 197.39,12.39 201.22,12.39 201.7,12.88 201.7,12.98 202.66,13.94 202.66,15.9 202.86,16.09 202.92,16.24 202.92,16.48 202.28,17.12 202.28,17.24 202.03,17.5 202.03,18.01 200.81,19.23 200.81,19.88 v2(200.53,20.55)
  BOTTOM w0.109: U400.DM35 141.84,71.33 v2(141.84,71.38) ; v1(167.68,37.9) 167.16,37.38 167.16,34.26 168.17,33.25 170.9,33.25 171.51,32.64 173.33,32.64 174.15,33.46 177.12,33.46 177.66,34 179.37,34 180.07,34.69 181.18,34.69 181.56,34.31 181.56,33.96 181.89,33.63 184.24,33.63 v1(184.94,32.93) ; v1(162.16,67.76) 161.68,67.29 161.68,65.73 162.13,65.28 162.13,61.71 162.74,61.1 162.74,54.34 161.3,52.89 161,52.89 159.74,51.64 159.74,50.95 159.03,50.24 158.13,50.24 157.45,50.92 156.13,50.92 155.67,50.46 155.26,50.46 155.04,50.68 153.86,50.68 152.54,49.35 152.54,48.3 151.65,47.41 151.65,46.61 151.49,46.45 150.82,46.45 150.7,46.58 v1(150.25,46.58) 149.16,46.58 148.84,46.26 119.13,46.26 115.88,43.02 108.27,43.02 101.17,50.11 81.78,50.11 80.86,49.19 v1(69.52,49.19) ; v1(85.85,55.93) 86.89,55.93 89.43,58.47 89.43,62.35 89.79,62.71 89.79,64.75 R1005.1 91.51,65.13 Q1000.3
RSMRST#_R: length 3.8
  TOP w0.109: U4700.M10 199.18,20.57 200.18,21.56 201.67,21.56 R4808.1 R4809.1
RSMRST_PG: length 188.5
  TOP w0.076: U4700.H9 v2(196.09,20.24)
  IN1 w0.079: v1(181.56,13.51) 179.17,13.51 178.74,13.94 171.83,13.94 171.04,14.73 164.26,14.73 163.85,15.14 163.45,15.14 162.25,13.94 157.4,13.94 157.1,13.64 157.1,13.13 156.75,12.78 153.35,12.78 152.66,13.47 146.06,13.47 145.39,14.15 144.3,14.15 143.43,13.28 141.15,13.28 140.82,13.61 140.82,13.8 140.47,14.15 137.03,14.15 136.57,13.69 132.1,13.69 131.6,13.18 128.62,13.18 127.73,14.07 125.93,14.07 125.45,13.59 122.88,13.59 121.53,12.23 117.58,12.23 116.81,13 113.59,13 111.63,11.05 110.77,11.05 110.21,10.49 109.75,10.49 109.34,10.89 106.63,10.89 104.67,12.85 99.53,12.85 99.36,12.68 93.41,12.68 92.1,13.99 86.64,13.99 86.15,14.48 79.65,14.48 78.46,13.28 75.97,13.28 75,14.25 71.93,14.25 71.37,13.69 60.42,13.69 59.89,14.22 43.61,14.22 42.16,12.77 38.22,12.77 37.51,13.49 37.51,14.84 v1(38.71,16.03)
  IN3 w0.076: 193.5,15.63 193.92,15.2 194.95,15.2 196.22,15.72 196.58,16.09 196.58,17.25 195.68,18.16 195.68,19.12 196.09,19.53 v2(196.09,20.24)
  IN3 w0.089: v1(181.56,13.51) 182.47,13.51 184.09,15.12 184.09,15.41 184.8,16.13 186.71,16.13 187.05,15.79 187.48,15.79 188.06,15.21 189.46,15.21 189.56,15.32 189.56,15.47 190.11,16.01 190.61,16.22 191.91,16.22 192.51,15.63 193.5,15.63
  BOTTOM w0.109: PU8100.7 38.57,16.17 v1(38.71,16.03) 38.71,15.01 37.95,14.25 36.55,14.25 36.32,14.02 36.32,12.88 36.48,12.73 PR8116.2 36.04,11.96 PR8118.2
RSVD_TP_2: length 1.2
  TOP w0.109: TP1021.1 114.68,81.04 v2(114.26,81.46)
  BOTTOM w0.109: U400.AL10 v2(114.26,81.46)
RSVD_TP_3: length 1.8
  TOP w0.109: TP1022.1 116.01,81.56 v2(115.62,81.95)
  BOTTOM w0.109: U400.AM12 115.18,81.47 115.62,81.9 v2(115.62,81.95)
RSVD_TP_4: length 1.2
  TOP w0.109: TP1024.1 112.72,81.76 v2(112.89,81.93)
  BOTTOM w0.109: U400.AH12 112.89,81.93 v2(112.89,81.93)
RSVD_TP_5: length 1.7
  TOP w0.109: v2(113.35,81.46) 113.42,81.38 113.42,80.45 TP1026.1
  BOTTOM w0.109: U400.AJ10 v2(113.35,81.46)
RSVD_TP_6: length 3.4
  BOTTOM w0.109: TP1027.1 115.44,88.59 115.44,86.8 U400.AR1
RSVD_TP_7: length 5.5
  BOTTOM w0.109: TP1003.1 97.25,64.79 97.25,63.7 97.66,63.29 100.17,63.29 100.62,63.74 U400.A51
RSVD_TP_8: length 5.8
  BOTTOM w0.109: TP1001.1 96.82,63.61 97.73,62.7 99.88,62.7 100.6,63.42 100.86,63.42 U400.B51
RSVD_TP_9: length 7.8
  BOTTOM w0.109: U400.C1 101.73,86.6 98.85,89.48 96.66,89.48 TP1005.1
RSVD_TP_10: length 7.5
  BOTTOM w0.109: TP1006.1 97.68,89.76 98.89,89.76 102.06,86.6 102.06,85.85 U400.D2
RSVD_TP_11: length 1.3
  TOP w0.109: v2(133.75,69.65) 133.75,70.37 TP1007.1
  BOTTOM w0.109: U400.CP39 133.7,69.6 v2(133.75,69.65)
RSVD_TP_12: length 2.1
  TOP w0.109: v2(135.11,69.8) 135.33,70.02 TP1008.1
  BOTTOM w0.109: U400.CU40 135.07,69.76 v2(135.11,69.8)
RSVD_TP_13: length 6.7
  BOTTOM w0.109: U400.DV4 144.5,84.89 145.04,84.89 145.9,85.75 145.9,85.85 146.51,86.46 148.66,86.46 149.41,85.71 TP1009.1
RSVD_TP_14: length 4.9
  BOTTOM w0.109: TP1010.1 146.63,87.03 145.56,85.95 145.56,85.83 U400.DW3
RSVD_TP_15: length 4.5
  BOTTOM w0.109: U400.DU1 143.84,86.9 145.07,88.12 TP1013.1
RSVD_TP_16: length 6.5
  BOTTOM w0.109: U400.DT2 143.83,85.71 144.17,86.05 144.17,86.84 145.52,88.2 145.52,89.51 146.01,90 TP1014.1
RSVD_TP_17: length 5.1
  BOTTOM w0.109: U400.DW2 144.95,86 146.35,87.4 148.06,87.4 TP1015.1
RSVD_TP_18: length 6.6
  BOTTOM w0.109: U400.DV2 144.33,85.72 146.33,87.73 147.49,87.73 148.6,88.84 148.6,89.23 TP1016.1
RSVD_TP_19: length 5.9
  BOTTOM w0.109: TP1017.1 98.62,90.07 99.07,90.07 102.38,86.75 U400.E1
RSVD_TP_20: length 8.1
  BOTTOM w0.109: U400.F1 102.99,86.42 102.99,87.25 100.61,89.62 100.61,90.87 100.36,91.13 99.11,91.13 TP1018.1
RSVD_TP_21: length 4.3
  BOTTOM w0.109: TP1019.1 143.72,88 143.19,87.47 U400.DR1
RSVD_TP_22: length 7.2
  BOTTOM w0.109: TP1020.1 144.07,91.77 144.37,91.47 144.37,90.93 144.19,90.75 144.19,90.29 143.97,90.07 143.97,87.65 143.52,87.2 143.52,86.06 143.21,85.76 U400.DR2
RSVD_TP_23: length 7.7
  BOTTOM w0.109: U400.DR53 143.23,62.53 143.83,61.94 145.64,61.94 146.21,62.5 147.58,62.5 147.89,62.19 148.23,62.19 148.56,61.86 148.64,61.68 148.64,61.49 149.3,60.83 TP1023.1
RSVD_TP_24: length 4.6
  BOTTOM w0.109: TP1025.1 148.22,86.23 146.68,86.23 145.03,84.58 U400.DW5
RTC_DET#: length 39.8
  TOP w0.109: R820.1 138.83,75.59 141.07,75.59 141.19,75.47 144.67,75.47 145.16,74.97 v2(145.79,74.97) ; v1(159.29,71.52) 159.29,70.27 159.76,69.8 159.76,67.84 160.02,67.59 160.4,67.59 161.14,66.85 161.14,65.02 v1(161.03,64.92) 160.84,64.73 160.84,64 160.34,63.5 159.03,63.5 158.72,63.8 Q1400.3
  IN1 w0.079: v2(145.79,74.97) 145.46,74.65 145.46,73.81 146.42,72.86 149.42,72.86 150.47,71.81 150.73,71.81 151.5,71.03 151.69,71.03 151.69,71.03 156.71,71.03 157.2,71.52 v1(159.29,71.52)
  BOTTOM w0.079: U400.DT19 143.45,77.93 143.99,77.39 143.99,77.16 144.32,76.83 144.32,76.4 144.65,76.07 144.65,75.88 145.56,74.97 v2(145.79,74.97)
RTC_REST1#_CL: length 1.4
  TOP w0.109: U7500.3 22.51,43.21 22.55,43.25 R7506.2
RTC_RST2_CL1: length 12
  TOP w0.109: U7500.6 21.25,42.24 20.77,41.75 R7503.1 20.49,41.75 20.05,41.31 v1(20.05,40.66) 20.05,39.38 v1(20.6,38.83) ; R7509.1 18.9,32.76 19.12,32.99 v1(19.51,32.99)
  IN1 w0.079: v1(19.51,32.99) 20.37,33.85 20.37,35.56 20.6,35.79 v1(20.6,38.83)
RTC_RST2_CL2: length 1.6
  TOP w0.109: R7516.1 20.69,34.92 v1(20.8,35.02) 21.02,35.25 Q7507.2
RTC_RST2_CL3: length 4
  TOP w0.109: Q7508.2 20.4,35.87 v1(19.53,35) 20.04,34.49 20.04,32.92 19.91,32.79 R7518.1
RTC_RST#: length 257.4
  TOP w0.109: Q7508.3 19.04,36.7 18.67,37.08 18.23,37.08 17.7,37.62 15.52,37.62 15.21,37.31 10.08,37.31 v1(9.49,37.9) ; v2(155.06,67.24) 155.2,67.37 155.2,67.48 155.5,67.79 R1421.1 R1416.2 156.28,68.3 C1400.1
  IN1 w0.079: v2(142.4,70.54) 143.04,69.9 143.6,69.9 144.39,69.11 146.13,69.11 146.55,68.69 147.99,68.69 148.79,67.89 150.42,67.89 150.92,67.38 153.37,67.38 153.61,67.14 154.96,67.14 v2(155.06,67.24) 155.09,67.21 155.87,67.21 156.81,66.27 160.28,66.27 160.81,66.8 161.35,66.8 161.85,67.3 162.75,67.3 163.26,67.81 164.25,67.81 164.65,67.41 165.72,67.41 165.82,67.51 v1(165.93,67.51) ; v1(9.49,37.9) 9.49,41.05 12.49,44.05 12.92,44.05 14.32,45.46 14.32,48.26 17.42,51.36 17.42,51.81 18.45,52.84 20.67,52.84 21.26,53.42 23.23,53.42 28.13,58.32 28.95,58.32 29.11,58.47 35.18,58.47 40.29,53.36 42,53.36 42.41,53.77 v1(43.33,53.77)
  BOTTOM w0.109: U400.DN37 142.17,70.31 v2(142.4,70.54) ; v1(9.49,37.9) 9.55,37.84 11.35,37.84 12.57,39.06 15.03,39.06 15.41,38.69 CON7700.9 ; v1(165.93,67.51) 165.98,67.46 166.6,67.46 166.86,67.2 166.86,66.27 166.76,66.17 166.76,58.42 167.26,57.91 167.26,54.56 166.24,53.54 165.5,53.54 164.51,52.55 163.9,52.55 162.96,51.62 162.96,50.41 160.86,48.31 159.65,48.31 158.76,47.42 158.76,45.52 153.49,40.24 118.8,40.24 117.85,39.3 103.46,39.3 100.41,36.25 50.85,36.25 46.87,40.24 46.87,47.18 42.7,51.36 42.7,53.13 v1(43.33,53.77)
RTC_SR01#_CL: length 18.2
  TOP w0.109: U7500.2 23.11,42.24 23.49,41.86 R7502.2 23.62,41.83 23.96,41.49 23.96,38.64 v1(23.49,38.17) 23.37,38.05 23.37,37.39 22.68,36.7 22.68,36.29 22.46,36.07 21.82,36.07 21.38,36.5 21.38,36.6 20.54,37.44 20.12,37.44 19.65,37.91 18.55,37.91 18.03,38.43 15.19,38.43 14.94,38.18 Q7506.2
RTC_X1: length 13.1
  TOP w0.109: R1423.1 148.81,55.19 148.67,55.34 148.54,55.34 147.86,56.01 v1(147.86,56.01) 147.57,56.3 147.33,56.3 146.31,57.32 146.31,60.07 145.17,61.21 145.17,63.23 143.34,65.06 143.34,65.15 v2(143.35,65.15)
  BOTTOM w0.109: U400.DR47 143.31,65.15 v2(143.35,65.15)
RTC_X1_R: length 6.2
  TOP w0.109: R1423.2 147.8,54.99 147.5,54.68 147.5,54.02 v1(147.57,53.95) 148.29,53.23 C1403.2 148.88,53.23 149.05,53.39 R1425.1 149.5,52.45 Y1400.1
RTC_X2: length 13.6
  TOP w0.109: R1428.1 149.35,55.54 149.19,55.71 148.86,55.71 148.69,55.88 148.69,56.6 148.49,56.8 147.53,56.8 146.8,57.53 146.8,60.28 145.67,61.41 145.67,63.44 144.1,65 v2(144.1,65.05)
  BOTTOM w0.109: U400.DT47 144.06,65.05 v2(144.1,65.05)
RTC_X2_R: length 3.9
  TOP w0.109: R1428.2 149.8,54.73 149.5,54.43 R1425.2 150,53.84 v1(150.34,54.18) 150.37,54.16 R1427.1 150.97,53.46 C1405.2
SC_PWRSV#: length 259.3
  TOP w0.109: v1(111.99,6.83) 112.6,7.44 112.6,8.15 114.32,9.88 114.32,10.56 112.88,12.01 112.88,14.27 113.11,14.5 113.11,15.42 v1(113.87,16.18) ; R1525.2 153.07,72.01 153.34,71.74 153.34,71.72 v2(153.34,71.72)
  IN2 w0.089: v2(153.34,71.72) 152.28,70.66 151.71,70.66 151.21,70.16 151.21,68.27 151.72,67.75 151.72,65.69 152.32,65.09 152.32,64.48 149.52,61.68 149.52,58.87 149.93,58.45 149.93,58.18 151.32,56.79 152.95,56.79 154.87,54.88 156.63,54.88 156.95,54.56 156.95,53.73 158.23,52.45 v1(158.23,52.12)
  IN3 w0.089: v1(111.99,6.83) 111.12,7.69 108.94,7.69 108.74,7.49 105.64,7.49 105.38,7.74 104.57,7.74 104.34,7.52 103.41,7.52 102.69,7.81 101.9,8.6 99.35,8.6 98.4,9.55 94.07,9.55 93.42,10.21 86.65,10.21 86,9.55 74.83,9.55 74.62,9.34 61.64,9.34 61.1,8.8 61.1,8.09 59.76,6.75 52.69,6.75 52.09,7.34 51.45,7.61 50.53,7.61 50,7.08 48.14,7.08 47.37,6.31 42.8,6.31 42.62,6.49 42,6.49 41.65,6.14 41.15,6.14 40.62,6.67 40.14,6.67 39.87,6.4 34.84,6.4 33.76,5.33 29.79,5.33 v1(29.69,5.43) ; v1(113.87,16.18) 113.87,16.57 115.69,18.4 119.7,18.4 119.94,18.16 120.47,18.16 121.23,17.4 121.23,17.19 121.49,16.94 123.11,16.94 123.54,16.51 124.05,16.51 125.01,17.47 125.01,17.62 125.5,18.1 131.88,18.1 132.49,17.49 134.32,17.49 134.92,16.89 135.84,16.89 136.54,16.2 139.07,16.2 139.23,16.04 143.85,16.04 144.37,16.56 148,16.56 148.96,17.52 150.53,17.52 150.92,17.12 151.26,17.12 151.9,17.75 155.29,17.75 157.58,15.47 159.56,15.47 159.93,15.83 162.32,15.83 163.38,16.9 163.88,16.9 165.88,18.9 175.86,18.9 176.74,19.78 177.72,19.78 178.57,20.63 178.95,20.63 179.61,21.29 179.61,24.07 179.4,24.28 179.4,26.82 178.32,27.89 178.32,29.25 175.72,31.86 175.72,34.24 172.8,37.17 172.8,38.7 171.1,40.4 170.58,40.4 168.92,42.06 168.92,43.98 167.79,45.11 167.79,45.97 167.31,46.45 167,46.45 165.95,47.51 165.51,47.51 163.65,49.38 162.98,49.38 160.79,51.57 159.36,51.57 158.8,52.12 v1(158.23,52.12)
  IN3 w0.102: v2(139.99,72.41) 140.41,71.99 145.4,71.99 145.82,72.41 146.3,72.41 146.4,72.51 149.93,72.51 150.39,72.06 150.96,72.06 151.25,72.35 151.56,72.35 151.83,72.08 152.97,72.08 v2(153.34,71.72)
  BOTTOM w0.109: U400.DG31 v2(139.99,72.41) ; v1(29.69,5.43) 29.59,5.53 CON4400.3
SCL_BAT_CHG: length 168.9
  TOP w0.076: U4700.C12 193.14,21.87 192.75,22.27 192.63,22.31 192.26,22.31 192.12,22.45 192.12,22.47 192.12,22.48
  TOP w0.109: v2(177.57,18.3) 177.91,18.64 179.12,18.64 179.91,17.85 180.61,17.85 181.07,17.4 181.22,17.33 181.85,17.33 182.53,16.65 184.63,16.65 185.53,17.55 185.53,22.02 186.51,23 186.51,24.41 187.12,25.02 187.48,25.02 187.9,25.44 R4721.2 189.06,25.44 191.65,22.86 191.74,22.86 192.12,22.48 ; v1(53.06,7.14) 52.69,7.51 PR8224.2 ; v1(85.34,11.07) 85.34,14.98 84.45,15.86 v1(84.45,16.1) 84.58,16.23 v1(84.58,17.38)
  IN1 w0.079: v1(115.93,20.33) 115.43,19.84 104.88,19.84 103.85,18.81 96.62,18.81 95.92,18.11 95.57,18.11 95.4,17.94 85.14,17.94 v1(84.58,17.38) ; v1(85.34,11.07) 84.96,11.45 84.45,11.45 84.33,11.33 84.33,10.79 84.09,10.56 81.27,10.56 80.74,11.08 75.24,11.08 74.76,10.6 59.09,10.6 58.7,10.21 57.25,10.21 56.61,9.57 54.73,9.57 53.06,7.9 v1(53.06,7.14)
  BOTTOM w0.109: PR8419.2 84.14,16.67 84.58,17.12 v1(84.58,17.38) 84.58,17.7 85.16,18.28 86.92,18.28 PD8401.2 ; v2(177.57,18.3) 176.69,18.3 176.21,17.81 172.67,17.81 171.67,18.82 154.16,18.82 153.8,19.18 116.29,19.18 115.93,19.53 v1(115.93,20.33)
SD_CD#_R: length 16.7
  TOP w0.109: CON7600.9 204.5,14.1 204.88,14.48 v2(205.05,14.48)
  IN1 w0.079: v2(205.05,14.48) 205.44,14.09 205.94,14.09 206.58,14.73 207.08,14.73 207.62,15.26 207.62,19.94 207.69,20.01 207.69,20.95 207.21,21.44 v1(207.21,22.04)
  BOTTOM w0.109: R7611.2 203.44,24.28 204.02,24.28 v1(204.46,23.84) 206.36,21.94 207.11,21.94 v1(207.21,22.04)
SD_CMD_R: length 11.7
  TOP w0.109: R7610.2 202.8,27.29 203.29,27.79 203.43,27.79 203.53,27.68 203.53,27.34 203.42,27.23 203.31,27.23 203.2,27.12 203.2,26.9 203.31,26.79 203.42,26.79 203.53,26.68 203.53,24.73 203.64,24.62 204.13,24.62 204.24,24.51 204.24,24.29 204.13,24.18 203.64,24.18 203.53,24.07 203.53,23.85 203.64,23.74 203.98,23.74 204.09,23.63 204.09,23.42 203.98,23.31 203.64,23.31 203.53,23.2 203.53,23.01 203.12,22.6 203.12,21.08 204,20.2 CON7600.3
SD_MMC_CD#: length 37.5
  TOP w0.109: v1(181.56,43.91) 181.38,43.73 v1(181.38,43.3) 181.38,42.8 180.53,41.94 180.53,40.75 180.33,40.55 U7600.30
  IN3 w0.089: v2(200.46,24.08) 200.13,24.41 200.01,24.41 198.44,25.98 197.2,25.98 196.62,26.57 196.26,26.57 196.08,26.75 192.98,26.75 192.76,26.97 192.76,27.3 192.55,27.51 192.03,27.51 190.26,29.28 190.17,29.28 189.69,29.77 189.69,30.02 187.89,31.82 187.89,33.31 185.66,35.53 185.66,35.76 182.1,39.31 182.1,42.94 181.56,43.48 v1(181.56,43.91)
  BOTTOM w0.109: R7611.1 201.98,24.57 200.67,24.57 200.46,24.36 v2(200.46,24.08)
SD_MMC_CLK: length 47
  TOP w0.109: CON7600.5 203.72,18.4 203.49,18.63 203.24,18.63 202.89,18.97 202.89,19.97 203,20.08 203.24,20.08 203.35,20.19 203.35,20.41 203.24,20.52 203,20.52 202.89,20.63 202.89,23.07 203,23.18 203.19,23.18 203.3,23.29 203.3,23.51 203.19,23.62 203,23.62 202.89,23.73 202.89,23.95 203,24.06 203.19,24.06 203.3,24.16 203.3,24.38 203.19,24.49 203,24.49 202.89,24.6 202.89,25.04 202.99,25.14 203.22,25.14 203.31,25.23 203.31,26.3 202.94,26.67 202.59,26.67 202.21,27.05 202.21,27.91 201.38,28.74 199.83,28.74 199.32,29.25 198.13,29.25 197.38,30 196.14,30 195.85,30.28 193.08,30.28 192.82,30.54 192.82,30.72 192.71,30.83 192.5,30.83 192.39,30.72 192.39,30.54 192.28,30.43 192.06,30.43 191.95,30.54 191.95,30.72 191.84,30.83 191.62,30.83 191.51,30.72 191.51,30.54 191.4,30.43 191.03,30.43 190.54,30.91 185.44,30.91 182.98,33.37 177.9,33.37 v1(177.76,33.23) 177.42,33.23 177.34,33.14 177.34,32.51 177.16,32.33 176.93,32.33 176.82,32.45 C7606.1 176.82,33.52 176.22,34.11 176.02,34.11 175.66,33.75 175.41,33.75 175.21,33.96 175.21,34.19 R7605.2
SD_MMC_CLK_C: length 2.8
  TOP w0.109: R7605.1 175.41,35.86 v1(175.41,36.43) 175.41,36.68 176.22,37.49 U7600.17
SD_MMC_CMD: length 36.1
  TOP w0.109: R7610.1 202.49,28.07 201.51,29.06 199.96,29.06 199.46,29.56 198.27,29.56 197.56,30.27 196.31,30.27 195.99,30.59 193.43,30.59 192.8,31.23 185.57,31.23 183,33.8 183,34.43 182.88,34.54 182.65,34.54 182.54,34.43 182.54,33.8 182.43,33.69 182.2,33.69 182.08,33.8 182.08,34.45 181.97,34.57 181.74,34.57 181.63,34.45 181.63,33.8 181.51,33.69 179.37,33.69 179.19,33.87 v1(178.92,33.87) 178.7,33.87 178.53,33.7 178.29,33.7 178.18,33.81 178.18,34.18 178.07,34.29 177.85,34.29 177.74,34.18 177.74,33.75 177.65,33.65 177.42,33.65 177.34,33.73 177.34,34.21 177.26,34.29 177.26,36.35 177.37,36.45 177.37,36.95 177.02,37.31 U7600.19
SD_MMC_DATA0: length 46.9
  TOP w0.109: CON7600.7 203.54,16.6 203.35,16.79 203.35,17.07 202.88,17.54 202.88,18.69 202.66,18.9 202.66,25.12 203.07,25.52 203.07,25.96 202.88,26.15 202.8,26.15 201.89,27.06 201.89,27.78 201.25,28.42 199.69,28.42 199.18,28.93 198.07,28.93 197.31,29.68 195.91,29.68 195.63,29.97 191.03,29.97 190.4,30.6 185.3,30.6 182.85,33.05 178.33,33.05 177.12,31.84 176.96,31.84 176.8,32 176.67,32 176.51,31.84 176.51,31.65 176.64,31.52 176.64,31.36 176.5,31.22 176.35,31.22 176.13,31.43 v1(175.79,31.43) 175.42,31.43 174.64,32.21 174.64,32.94 C7608.1 174.79,33.62 R7608.2
SD_MMC_DATA0_C: length 3.3
  TOP w0.109: R7608.1 174.79,36.67 175.52,37.39 U7600.16
SD_MMC_DATA1: length 48.3
  TOP w0.109: R7609.2 174.34,35.22 174.34,33.64 C7609.1 173.95,33.11 174.33,32.73 174.33,31.86 v1(174.4,31.79) 175.3,30.9 176.63,30.9 178.47,32.74 182.72,32.74 185.16,30.29 190.25,30.29 190.85,29.69 195.48,29.69 195.69,29.47 197.18,29.47 197.94,28.71 199.07,28.71 199.68,28.1 201.12,28.1 201.57,27.65 201.57,27.07 202.33,26.31 202.33,25.02 202.44,24.92 202.44,18.83 202.66,18.61 202.66,17.45 203.12,16.99 203.12,16.58 204.01,15.7 CON7600.8
SD_MMC_DATA1_C: length 3.7
  TOP w0.109: R7609.1 174.22,36.53 174.86,37.16 v1(174.86,37.74) 174.86,38.79 175.02,38.95 U7600.15
SD_MMC_DATA2: length 44.6
  TOP w0.109: CON7600.1 204.19,22.61 204.87,23.29 204.87,24.13 205.13,24.38 205.74,24.38 206.45,25.09 207.49,25.09 207.59,25.19 207.59,25.4 207.38,25.61 205.99,25.61 205.9,25.7 205.9,27.27 205.59,27.58 204.54,27.58 203.22,28.9 202.56,28.9 201.75,29.72 200.22,29.72 199.74,30.2 198.55,30.2 197.64,31.1 196.48,31.1 196.36,31.22 193.74,31.22 193.11,31.85 186.2,31.85 185.42,32.63 185.42,33.09 185.16,33.35 185.16,35.3 185.01,35.46 v1(184.57,35.46) 184.57,36.4 184.41,36.57 183.98,36.57 183.87,36.45 183.87,35.44 183.75,35.33 183.53,35.33 183.41,35.44 183.41,36.45 183.3,36.57 183.07,36.57 182.95,36.45 182.95,35.67 182.84,35.56 C7602.1 181.79,36.04 181.06,36.04 180.9,36.2 180.5,36.2 180.06,35.76 R7603.2
SD_MMC_DATA2_C: length 2.9
  TOP w0.109: U7600.21 177.82,37.26 178.03,37.05 178.03,36.7 178.29,36.44 178.82,36.44 179.03,36.23 R7603.1
SD_MMC_DATA3: length 45
  TOP w0.109: CON7600.2 203.74,21.1 203.5,21.33 203.5,22.38 204.56,23.43 204.56,24.6 204.7,24.74 205.48,24.74 205.59,24.84 205.59,25.06 205.48,25.17 205.16,25.17 205.03,25.31 205.03,25.52 205.11,25.61 205.48,25.61 205.59,25.72 205.59,27.14 205.46,27.27 204.39,27.27 203.08,28.58 202.44,28.58 201.63,29.39 200.08,29.39 199.59,29.88 198.41,29.88 197.69,30.6 196.44,30.6 196.14,30.91 193.58,30.91 192.95,31.54 185.71,31.54 184.47,32.78 184.47,33.29 184.81,33.63 184.81,34.74 184.65,34.9 184.23,34.9 184.11,34.79 184.11,33.63 184,33.51 183.77,33.51 183.66,33.63 183.66,34.78 183.54,34.9 v1(183.16,34.9) 183.16,34.9 180.9,34.9 180.64,34.64 180.64,34.24 180.41,34.01 179.53,34.01 179.03,34.5 C7603.1 178.31,34.74 178.31,34.74 R7604.2
SD_MMC_DATA3_C: length 2.5
  TOP w0.109: U7600.20 177.42,37.21 177.76,36.87 v1(177.76,36.32) R7604.1
SD_MMC_WP: length 2.9
  TOP w0.109: U7600.29 180.27,40.15 181.2,41.09 R7613.2 181.79,41.25 v1(181.96,41.43)
SD_PWR_EN#_R: length 3.9
  BOTTOM w0.079: 146.55,71.19 145.76,71.34 145.07,71.63 144.71,71.63 U400.DV32
  BOTTOM w0.109: TP609.1 147.66,71.19 146.55,71.19
SDA_BAT_CHG: length 167
  TOP w0.076: U4700.B12 192.28,21.87 192.03,22.12 191.92,22.16 191.81,22.16 191.7,22.12 191.62,22.03 191.57,21.93 191.57,21.79 191.37,21.59 191.07,21.59 190.79,21.87 190.79,21.93
  TOP w0.109: 190.79,22.48 190.79,22.9 189.12,24.56 R4722.2 188.53,24.56 188.48,24.61 187.26,24.61 186.89,24.24 186.89,22.87 185.89,21.87 185.89,17.39 184.78,16.28 182.38,16.28 181.69,16.97 181.15,16.97 180.86,17.09 180.46,17.49 179.71,17.49 178.96,18.24 v2(178.29,18.24) ; PR8223.2 54.06,6.78 v1(53.69,7.14) ; v1(84.71,11.07) 84.71,15.08 83.89,15.91 v1(83.89,17.32)
  TOP w0.112: 190.79,21.93 190.79,22.48
  IN1 w0.079: v1(84.71,11.07) 84.71,10.69 84.24,10.23 81.13,10.23 80.61,10.75 75.38,10.75 74.9,10.27 59.32,10.27 58.85,9.8 58.54,9.8 57.88,9.14 54.79,9.14 53.69,8.05 v1(53.69,7.14) ; v1(115.26,20.37) 115.09,20.19 104.76,20.19 103.71,19.14 96.48,19.14 95.79,18.44 95.38,18.44 95.21,18.27 84.84,18.27 v1(83.89,17.32)
  BOTTOM w0.109: v2(178.29,18.24) 178.06,18.24 177.76,17.95 177.63,17.89 176.82,17.89 176.38,17.45 172.51,17.45 171.55,18.41 170.33,18.41 169.77,17.86 169.43,17.86 169.35,17.89 169.2,18.04 169.15,18.16 169.15,18.17 168.87,18.45 154,18.45 153.64,18.81 116.14,18.81 115.26,19.68 v1(115.26,20.37) ; PR8418.2 81.24,16.83 PD8400.2 81.88,17.47 83.73,17.47 v1(83.89,17.32)
SEN_A0: length 1.4
  TOP w0.254: v2(37.96,88.1) 38.07,88.22 R7004.2
  BOTTOM w0.254: VRAM7000.J10 37.96,88.12 v2(37.96,88.1)
SEN_A2: length 1.2
  TOP w0.109: R7006.2 37.97,70.28 v2(37.97,70.92)
  BOTTOM w0.254: v2(37.97,70.92) 37.97,70.87 VRAM7001.J10
SG_IN: length 8.9
  BOTTOM w0.079: 145.46,80.72 145.21,80.72 144.98,80.95 144.76,80.95 144.61,81.1 144.61,81.34 144.45,81.5 142.61,81.5 U400.DN10
  BOTTOM w0.109: R1143.2 R1144.1 149.27,79.86 149.14,79.99 148.04,79.99 147.31,80.72 145.46,80.72
SKTOCC#: length 19.6
  BOTTOM w0.109: U400.D52 102.16,63.11 102.16,62.18 101.95,61.97 97.94,61.97 96.21,63.7 96.21,66.04 96.57,66.39 96.57,67.71 95.65,68.63 93.27,68.63 92.94,68.3 92.94,67.51 94.1,66.34 v1(94.1,66.04) R1007.1

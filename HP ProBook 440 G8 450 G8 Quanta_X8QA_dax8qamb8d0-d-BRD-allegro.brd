# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXN9_SSD_C: length 18
  IN3 w0.089: v1(19.01,7.98) 18.72,7.69 18.72,7.5 18.55,7.33 17.05,7.33 15.77,8.62 15.22,8.62 14.55,7.96 11.9,7.96 11.55,8.3 11.55,9.1 v1(11.31,9.34)
  BOTTOM w0.109: C4304.1 20.06,8.41 18.91,8.41 18.81,8.32 18.81,8.18 v1(19.01,7.98) ; v1(11.31,9.34) 11.49,9.16 11.49,7.04 11.99,6.54 11.99,5.14 12.24,4.89 12.46,4.89 12.6,4.75 CON4300.11
PCIE_TXN10_SSD: length 158.1
  IN1 w0.079: v1(20.84,16.82) 20.84,16.72 21.03,16.53 22.52,16.53 29.09,23.11 29.09,25.14 30.02,26.06 30.02,29.8 32.46,32.25 32.46,32.82 33.1,33.46 48.75,33.46 55.75,40.46 61.87,40.46 67.6,46.19 67.6,47 68.97,48.37 68.97,49.59 78.14,58.76 78.14,59.21 78.56,59.63 78.56,60.24 80.58,62.26 80.58,62.89 83.09,65.41 83.09,65.69 85.37,67.97 85.37,69.91 86.09,70.62 87.04,70.62 87.45,70.21 87.83,70.21 89.83,72.2 90.33,72.2 90.9,72.78 90.9,73.63 92.15,74.88 92.15,75.26 92.75,75.86 92.91,75.86 94.2,77.15 95.58,77.15 95.98,76.75 99.11,76.75 99.25,76.88 106.58,76.88 106.96,76.5 108.54,76.5 109.75,75.3 120.5,75.3 125.48,80.27 125.71,80.27 126.43,80.99 126.49,81.14 126.49,81.69 126.53,81.73 126.53,83.38 126.42,83.49 126.22,83.49 126.16,83.44 v2(126.16,83.28)
  BOTTOM w0.109: v1(20.84,16.82) 21.11,16.55 21.18,16.55 21.18,16.54 21.37,16.54 21.75,16.16 21.75,15.17 21.33,14.74 21.33,13.49 21.73,13.09 21.84,12.82 21.84,11.94 20.79,10.89 16.83,10.89 16.71,10.77 16.71,10.49 16.8,10.39 C4307.2 ; U400.BV8 126.38,83.28 v2(126.16,83.28)
PCIE_TXN10_SSD_C1: length 4.6
  BOTTOM w0.109: CON4300.23 14.2,7.75 14.34,7.89 14.68,7.89 15.71,8.92 16.59,8.92 16.86,9.19 16.86,9.36 C4307.1
PCIE_TXN11_SSD: length 149.9
  IN1 w0.079: v1(18.14,12.7) 18.47,13.02 18.54,13.02 18.72,13.2 18.72,13.9 20.36,15.54 20.36,17.35 22.34,19.33 22.34,20.87 23.24,21.77 23.24,22.53 28.96,28.25 28.96,30.18 29.27,30.49 30.16,30.49 31.69,32.02 31.69,32.66 32.88,33.86 48.6,33.86 55.59,40.85 61.7,40.85 67.03,46.17 67.03,48.21 77.66,58.84 77.66,59.64 77.94,59.91 77.94,60.52 79.18,61.76 79.18,63.02 80.67,64.51 81.06,64.51 84.93,68.38 84.93,70.13 86.19,71.4 87.79,71.4 88.87,72.48 88.87,73.54 91.71,76.37 92.8,76.37 94.24,77.81 95.78,77.81 95.91,77.94 97.67,77.94 98,77.6 106.56,77.6 106.88,77.29 108.41,77.29 109.24,76.46 121.03,76.46 125.31,80.74 125.31,81.55 125.95,82.19 125.95,82.49 v2(126.16,82.7)
  BOTTOM w0.109: C4309.2 17.13,12.53 17.24,12.64 17.51,12.64 17.84,12.97 18.03,12.97 18.14,12.86 v1(18.14,12.7) ; v2(126.16,82.7) 126.31,82.7 U400.BV9
PCIE_TXN11_SSD_C: length 4.3
  BOTTOM w0.109: CON4300.35 14.23,10.75 14.37,10.89 14.63,10.89 15.74,12 15.74,12.34 16.03,12.64 16.24,12.64 16.35,12.53 C4309.1
PCIE_TXN12_SSD: length 149.5
  IN1 w0.079: v1(18.57,16.07) 18.9,16.4 19.37,16.4 19.76,16.79 19.76,17.54 21.78,19.56 21.78,23.07 24.47,25.76 24.47,26.97 28.39,30.89 28.39,34.26 29.92,35.79 30.33,35.79 30.55,35.56 30.55,35.15 31.28,34.42 48.39,34.42 55.39,41.42 59.44,41.42 76.17,58.16 76.17,59.91 78.63,62.37 78.63,63.25 80.62,65.24 80.62,65.59 84.35,69.33 84.35,70.35 87.62,73.61 87.62,74.4 88.32,75.11 89.63,75.11 91.84,77.32 92.2,77.32 92.78,77.9 93.34,77.9 94,78.56 95.63,78.56 96.47,79.4 98.97,79.4 99.82,78.56 106.52,78.56 106.9,78.18 108.45,78.18 109.6,77.03 120.75,77.03 124.36,80.64 124.36,81.73 124.86,82.24 124.86,83.5 124.94,83.57 125.11,83.57 v2(125.3,83.39)
  BOTTOM w0.109: v2(125.3,83.39) 125.64,83.04 U400.BT8 ; v1(18.57,16.07) 18.35,16.3 18.25,16.3 17.92,15.96 17.7,15.96 17.59,15.85 C4311.2
PCIE_TXN12_SSD_C: length 5.1
  BOTTOM w0.109: CON4300.47 14.16,13.75 14.29,13.89 14.67,13.89 15.16,14.38 15.64,14.38 16.2,14.94 16.2,15.88 16.3,15.98 16.42,15.98 C4311.1
PCIE_TXP5_LAN_C: length 167.5
  TOP w0.109: v1(9.2,16.04) 9.2,16.3 9.3,16.4 9.66,16.4 9.88,16.18 CON7602.22
  IN1 w0.079: v2(127.92,83.29) 127.84,83.37 127.84,83.49 127.94,83.59 128.22,83.59 128.34,83.47 128.34,82.19 128.88,81.66 128.88,79.96 127.98,79.07 127.98,78.16 127.72,77.89 126.27,77.89 125.55,77.17 124.14,77.17 121.14,74.17 109.11,74.17 108.65,74.64 107.08,74.64 106.67,75.04 99.98,75.04 99.53,74.59 98.39,74.59 97.95,74.14 97.4,74.14 97.28,74.03 93.95,74.03 90.98,71.06 90.28,71.06 88.32,69.1 87.49,69.1 87.17,68.78 87.17,68.09 84.36,65.29 84.36,64.15 80.11,59.9 80.11,58.66 78.13,56.68 78.13,55.59 70.66,48.12 70.66,47.52 62.5,39.36 56.21,39.36 48.48,31.63 37.47,31.63 36.69,30.86 33.26,30.86 31.12,28.72 31.12,25.58 30.19,24.66 30.19,20.67 23.3,13.78 21.92,13.78 21.47,13.33 21.47,12.54 20.55,11.62 17.7,11.62 16.5,12.82 16.5,13.81 15.66,14.64 13.66,14.64 13.15,15.15 10.63,15.15 10.17,15.61 9.19,15.61 9.1,15.65 8.94,15.75 8.79,15.91 8.79,16.35 8.84,16.41 9.09,16.41 9.2,16.29 v1(9.2,16.04)
  BOTTOM w0.109: v2(127.92,83.29) 127.92,83.42 128.01,83.51 128.22,83.51 128.45,83.28 U400.CB8
PCIE_TXP6_SD: length 86.9
  TOP w0.109: U7600.3 178.22,42.68 178.03,42.87 178.03,47.54 177.91,47.66 177.91,49.68 178.2,49.96 178.88,49.96 179.14,50.23 179.14,50.43 v1(179.42,50.7) ; C1304.2 133.98,89.8 133.91,89.87 133.91,90.21 134.1,90.4 135.08,90.4 135.46,90.02 135.46,88.54 135.31,88.39 135.31,82.64 135.66,82.29 135.66,81.52 135.56,81.42 v2(135.3,81.42)
  IN3 w0.089: v2(135.3,81.42) 135.3,81.31 135.38,81.23 135.53,81.23 136.1,80.66 136.1,80.04 136.86,79.28 137.69,79.28 137.78,79.37 139.48,79.37 139.57,79.28 142.59,79.28 143.58,80.27 146.22,80.27 146.73,79.76 146.73,79.68 147.38,79.03 149.25,79.03 150.57,77.71 153,77.71 153.28,77.99 154.91,77.99 155.04,78.12 157.85,78.12 159.14,76.82 159.14,76.31 159.51,75.94 161.58,75.94 161.94,75.59 161.94,74.71 162.61,74.03 162.61,73.28 164.26,71.63 164.26,71.18 166.31,69.13 167.01,69.13 170.27,65.88 170.27,65.17 174.05,61.39 174.34,61.39 175.68,60.05 175.68,57.96 178.45,55.2 178.45,54.84 180.35,52.93 180.35,51.81 179.7,51.16 179.15,51.16 179.04,51.05 179.04,50.87 179.22,50.7 v1(179.42,50.7)
PCIE_TXP6_SD_C: length 8.6
  TOP w0.109: C1304.1 134.1,88.63 134.1,88.03 134.34,87.79 134.34,86.24 133.8,85.7 132.88,85.7 131.29,84.11 131.29,83.85 130.75,83.3 v2(130.75,83.29)
  BOTTOM w0.109: U400.CG8 130.53,83.29 v2(130.75,83.29)
PCIE_TXP7_WLAN: length 14.7
  BOTTOM w0.109: C1302.1 169.17,75.5 169.51,75.36 169.74,75.14 172.93,75.14 173.82,74.25 173.82,73.86 174.26,73.41 177.06,73.41 177.72,72.75 178.38,72.75 178.81,72.33 179.81,72.33 180.35,72.87 180.83,72.87 181.1,72.6 181.1,71.82 CON4100.35
PCIE_TXP7_WLAN_C: length 62.5
  TOP w0.102: 129.4,85.04 129.4,85.01 129.41,85 129.41,84.74 129.26,84.59 129.26,83.1 129.48,82.88 129.64,82.88 v2(129.79,82.73)
  TOP w0.109: 129.4,85.04 129.4,86.31 129.92,86.83 129.92,90.86 v1(129.72,91.06)
  IN3 w0.089: v1(129.72,91.06) 130.01,90.77 130.01,90.62 130.21,90.42 130.75,90.42 131.13,90.79 131.13,91.84 131.48,92.2 137.12,92.2 137.55,91.77 144.06,91.77 144.24,91.59 145.39,91.59 145.65,91.34 146.7,91.34 147.27,91.57 148.25,92.56 154.35,92.56 157.07,89.84 157.07,89.02 161.52,84.58 163,84.58 163.35,84.23 163.35,83.72 165.74,81.33 166.7,81.33 169.82,78.2 170.33,78.2 170.52,78.01 170.52,77.83 170.38,77.68 170.26,77.68 v2(170.15,77.8)
  BOTTOM w0.109: v2(129.79,82.73) 129.46,82.39 U400.CD9 ; v2(170.15,77.8) 170.13,77.8 169.7,77.37 169.7,76.83 169.34,76.47 169.34,76.35 C1302.2
PCIE_TXP8_WWAN: length 157.1
  TOP w0.109: v1(132.44,91.05) 132.1,90.72 132.1,90.38 132.26,90.23 C1300.2
  IN3 w0.089: v1(132.44,91.05) 132.19,91.05 132.08,91.16 132.08,91.39 132.23,91.54 133.13,91.54 133.45,91.22 133.45,88.76 135.83,86.38 136.57,86.38 137.11,85.85 137.94,85.85 138.27,85.52 143.99,85.52 145.49,84.02 147.23,84.02 147.9,83.35 148.87,83.35 149.58,82.65 152.73,82.65 153.15,82.23 156.26,82.23 156.66,81.82 157.69,81.82 160.35,79.17 161.96,79.17 162.61,78.52 163.2,78.52 164,77.72 164.38,77.72 164.51,77.59 164.62,77.32 164.62,76.97 168.18,73.41 168.18,71.95 168.9,71.23 169.28,71.23 170.03,71.98 170.53,71.98 172.47,70.04 172.47,66.64 174.25,64.86 174.25,64.75 176.17,62.84 176.32,62.84 176.83,62.34 182.08,62.34 183.5,60.92 183.5,56.34 184.21,55.62 184.76,55.62 185.41,54.98 185.41,54.04 186.99,52.45 186.99,48.26 187.62,47.64 187.62,44.46 188.25,43.83 188.25,41.73 189.56,40.42 189.56,38.39 189.27,38.11 189.27,35.05 190.34,33.97 190.34,32.14 192.45,30.03 193.06,30.03 194.2,28.88 197.56,28.88 197.9,28.74 199.15,28.74 201.19,26.71 201.32,26.71 202.08,25.94 202.08,25.59 203.69,23.97 203.69,23.76 206.69,20.76 206.69,20.17 208.17,18.69 208.17,17.34 208.87,16.64 208.87,12.9 208.38,12.41 208.38,11.48 207.11,10.2 204.57,10.2 202.84,8.47 201.2,8.47 201.02,8.29 191.65,8.29 191.26,7.9 191.26,7.41 191.15,7.3 v1(190.91,7.3)
  BOTTOM w0.109: CON4202.49 190.41,8.29 190.55,8.15 190.55,7.99 190.77,7.78 191.06,7.78 191.16,7.67 191.16,7.41 191.05,7.3 v1(190.91,7.3)
PCIE_TXP8_WWAN_C: length 12.1
  TOP w0.102: 130.67,85.04 130.67,85.01 130.66,85 130.66,84.42 130.39,84.15 130.39,82.43 130.6,82.22 131.17,82.22 131.24,82.25 131.29,82.29 131.29,82.78 131.19,82.88 131.19,83.06 131.29,83.16 131.29,83.46 131.37,83.54 131.57,83.54 131.67,83.44 v2(131.67,83.34)
  TOP w0.109: C1300.1 132.48,89.61 132.38,89.71 132,89.71 131.92,89.63 131.92,89.11 132.04,88.98 132.04,86.7 130.67,85.33 130.67,85.04
  BOTTOM w0.109: v2(131.67,83.34) 131.49,83.34 U400.CJ8
PCIE_TXP9_SSD: length 154.2
  IN1 w0.079: v2(127.07,83.89) 127.43,83.54 127.43,83.14 127.58,82.99 127.58,82.14 128.03,81.69 128.03,80.41 125.33,77.71 124.04,77.71 120.9,74.57 109.33,74.57 108.5,75.41 106.93,75.41 106.54,75.8 99.22,75.8 99.04,75.98 96.86,75.98 95.83,74.94 94.24,74.94 90.76,71.46 90.13,71.46 88.16,69.49 87.22,69.49 86.89,69.16 86.33,69.16 86.09,68.92 86.09,67.6 83.92,65.43 83.92,65.11 81.48,62.67 81.48,62.03 79.49,60.04 79.49,58.67 77.44,56.62 77.44,55.79 68.42,46.77 68.42,45.95 62.21,39.74 56.05,39.74 48.34,32.04 35.08,32.04 34.29,31.24 33.1,31.24 30.74,28.87 30.74,25.75 29.81,24.82 29.81,21.19 23.16,14.54 22.61,14.54 v1(22.31,14.23)
  BOTTOM w0.109: v2(127.07,83.89) 127.33,83.89 U400.BY7 ; C4306.2 21.08,8.84 21.16,8.75 21.43,8.75 21.64,8.96 21.64,9.99 23.21,11.57 23.21,12.62 23.44,12.85 23.44,14.29 23.16,14.57 22.64,14.57 v1(22.31,14.23)
PCIE_TXP9_SSD_C: length 18
  IN3 w0.089: v1(18.25,7.98) 18.53,7.7 18.53,7.58 18.47,7.53 17.13,7.53 15.85,8.81 15.14,8.81 14.48,8.15 11.97,8.15 11.75,8.38 11.75,9.01 v1(12.08,9.34)
  BOTTOM w0.109: CON4300.13 12.6,5.25 12.46,5.11 12.34,5.11 12.22,5.23 12.22,6.63 11.71,7.13 11.71,8.98 v1(12.08,9.34) ; v1(18.25,7.98) 18.5,7.98 18.59,8.07 18.59,8.41 18.82,8.64 20.2,8.64 20.3,8.74 C4306.1
PCIE_TXP10_SSD: length 158.1
  IN1 w0.079: v1(20.84,16.06) 21.15,16.37 22.59,16.37 29.26,23.04 29.26,25.07 30.19,25.99 30.19,29.73 32.63,32.18 32.63,32.75 33.17,33.3 48.82,33.3 55.82,40.29 61.94,40.29 67.77,46.12 67.77,46.26 67.77,46.26 67.77,46.93 69.14,48.3 69.14,49.52 78.31,58.69 78.31,59.14 78.73,59.56 78.73,60.17 80.75,62.19 80.75,62.82 83.26,65.34 83.26,65.62 85.54,67.9 85.54,69.84 86.15,70.46 86.97,70.46 87.39,70.04 87.9,70.04 89.9,72.03 90.4,72.03 91.07,72.71 91.07,73.56 92.32,74.81 92.32,75.19 92.82,75.69 92.98,75.69 94.27,76.98 95.51,76.98 95.91,76.58 99.18,76.58 99.32,76.72 106.51,76.72 106.89,76.33 108.47,76.33 109.68,75.13 120.57,75.13 125.55,80.1 125.78,80.1 126.57,80.89 126.66,81.1 126.66,81.62 126.7,81.66 126.7,83.45 126.49,83.66 126.29,83.66 126.16,83.79 v2(126.16,83.89)
  BOTTOM w0.109: v1(20.84,16.06) 21.1,16.32 21.28,16.32 21.53,16.07 21.53,15.26 21.11,14.83 21.11,13.4 21.54,12.96 21.62,12.77 21.62,12.03 20.7,11.11 16.74,11.11 16.49,10.86 16.49,10.54 16.34,10.39 C4308.2 ; U400.BV7 126.17,83.88 v2(126.16,83.89)
PCIE_TXP10_SSD_C1: length 4.6
  BOTTOM w0.109: C4308.1 16.13,9.64 16.52,9.64 16.64,9.52 16.64,9.28 16.5,9.14 15.62,9.14 14.59,8.11 14.34,8.11 14.2,8.25 CON4300.25
PCIE_TXP11_SSD: length 149.9
  IN1 w0.079: v1(18.14,13.46) 18.41,13.19 18.47,13.19 18.55,13.27 18.55,13.97 20.19,15.61 20.19,17.42 22.17,19.4 22.17,20.94 23.07,21.83 23.07,22.6 28.79,28.32 28.79,30.25 29.2,30.66 30.09,30.66 31.52,32.09 31.52,32.73 32.81,34.02 48.53,34.02 55.52,41.01 61.63,41.01 66.86,46.24 66.86,48.28 77.49,58.91 77.49,59.7 77.77,59.98 77.77,60.59 79.01,61.83 79.01,63.09 80.6,64.68 80.99,64.68 84.76,68.45 84.76,70.2 86.12,71.56 87.72,71.56 88.7,72.55 88.7,73.61 91.64,76.54 92.73,76.54 94.17,77.98 95.72,77.98 95.84,78.1 97.74,78.1 98.07,77.77 106.63,77.77 106.95,77.46 108.48,77.46 109.31,76.62 120.96,76.62 125.14,80.8 125.14,81.62 125.78,82.26 125.78,82.65 125.69,82.73 v2(125.32,82.73)
  BOTTOM w0.109: v1(18.14,13.46) 18.14,13.26 18.07,13.19 17.75,13.19 17.42,12.87 17.21,12.87 17.13,12.95 C4310.2 ; U400.BT9 125.66,82.39 v2(125.32,82.73)
PCIE_TXP11_SSD_C: length 4.3
  BOTTOM w0.109: C4310.1 16.35,12.96 16.25,12.86 15.94,12.86 15.52,12.44 15.52,12.09 14.54,11.11 14.36,11.11 14.22,11.25 CON4300.37
PCIE_TXP12_SSD: length 149.6
  IN1 w0.079: v1(18.57,16.83) 18.84,16.57 19.3,16.57 19.59,16.86 19.59,17.61 21.61,19.63 21.61,23.14 24.31,25.83 24.31,27.04 28.22,30.96 28.22,34.33 29.85,35.95 30.4,35.95 30.72,35.63 30.72,35.22 31.35,34.59 48.32,34.59 55.32,41.59 59.37,41.59 76,58.22 76,59.98 78.46,62.44 78.46,63.32 80.45,65.31 80.45,65.66 84.18,69.4 84.18,70.42 87.45,73.68 87.45,74.47 88.25,75.27 89.56,75.27 91.77,77.48 92.13,77.48 92.71,78.07 93.27,78.07 93.93,78.73 95.56,78.73 96.4,79.57 99.04,79.57 99.89,78.73 106.59,78.73 106.97,78.35 108.52,78.35 109.67,77.2 120.68,77.2 124.19,80.71 124.19,81.8 124.69,82.31 124.69,83.57 124.87,83.74 125.04,83.74 v2(125.27,83.97)
  BOTTOM w0.109: v2(125.27,83.97) 125.43,83.97 U400.BT7 ; C4312.2 17.58,16.3 17.69,16.18 17.82,16.18 18.16,16.52 18.26,16.52 v1(18.57,16.83)
PCIE_TXP12_SSD_C: length 5.1
  BOTTOM w0.109: CON4300.49 14.17,14.25 14.31,14.11 14.58,14.11 15.07,14.6 15.55,14.6 15.98,15.03 15.98,15.97 16.21,16.21 16.4,16.21 C4312.1
PCIE_WAKE#: length 371
  TOP w0.109: v2(140.48,68.81) 141.14,68.15 142.89,68.15 144.94,66.1 146.34,66.1 146.94,65.5 148,65.5 148.67,66.16 149.21,66.16 149.44,66.4 150.41,66.4 150.58,66.23 153.76,66.23 R1515.1 ; v1(186.33,66.73) 186.12,66.94 R4139.2 186.57,67.56 187.29,66.83 188.17,66.83 188.49,67.15 Q4112.3 ; v1(187.45,10.66) 187.62,10.49 187.98,10.49 188.16,10.31 188.16,9.95 188.54,9.57 v1(188.92,9.57) 189.35,9.57 189.66,9.27 190.21,9.27 191,8.48 195.15,8.48 195.55,8.89 195.55,9.34 196.02,9.81 v1(196.02,10.24) ; CON7602.28 9.23,13.18 v1(8.91,12.86)
  IN1 w0.079: v2(140.75,57.52) 141.12,57.15 141.52,57.15 142.29,56.37 143.01,56.37 143.65,55.73 143.65,55.22 143.51,55.08 143.51,54.09 146.96,50.65 147.35,50.65 147.97,50.03 149.11,50.03 149.99,49.15 149.99,48.71 150.58,48.13 152.25,48.13 152.88,47.5 154.15,47.5 154.74,46.91 155.7,46.91 156.22,47.43 157.19,47.43 157.6,47.84 158.82,47.84 159.54,48.56 159.54,49.87 160.26,50.59 161.45,50.59 162.08,51.23 162.08,52.08 164.39,54.39 171.83,54.39 172.16,54.72 173.93,54.72 174.23,55.01 175.54,55.01 v1(175.92,55.39) 176.56,56.03 178.7,56.03 178.81,56.14 180,56.14 180.12,56.03 182.97,56.03 183.2,56.26 183.2,56.84 182.55,57.48 182.03,57.48 181.41,58.1 181.41,59.13 181.98,59.71 181.98,60.93 186.33,65.28 v1(186.33,66.73) ; v1(8.91,12.86) 9.59,12.86 10.49,11.96 11.61,11.96 14.02,9.55 16.51,9.55 17.54,8.51 21.19,8.51 22.52,7.19 26.29,7.19 26.63,6.85 31.02,6.85 32.08,5.79 34.77,5.79 34.97,5.59 35.38,5.59 35.58,5.79 39.27,5.79 39.9,6.42 40.69,6.42 41.22,5.89 42.13,5.89 42.82,5.19 44.25,5.19 44.88,5.83 50.84,5.83 51.17,5.5 51.57,5.5 52.36,6.28 54.05,6.28 56.26,8.49 58.18,8.49 58.84,9.15 59.12,9.15 59.59,9.62 80.82,9.62 80.86,9.58 84.97,9.58 86.31,10.92 88.71,10.92 88.87,10.76 91.78,10.76 92.25,10.29 93.84,10.29 94.35,9.78 98.31,9.78 99.73,8.36 102.24,8.36 102.85,7.75 104.7,7.75 104.92,7.53 113.23,7.53 114,8.29 114.35,8.29 115.06,9.01 125.99,9.01 126.15,9.17 134.72,9.17 134.92,8.97 135.83,8.97 136.13,8.67 141.03,8.67 141.33,8.37 143.01,8.37 143.36,8.72 145.55,8.72 145.73,8.9 146.96,8.9 147.13,8.72 151.18,8.72 151.5,8.41 158.19,8.41 158.65,8.87 160.28,8.87 160.84,9.42 169.01,9.42 171.07,7.36 176.68,7.36 177.05,7.73 180.88,7.73 181.1,7.95 181.1,8.3 181.62,8.82 182.69,8.82 182.98,9.12 185.34,9.12 186.41,10.18 186.97,10.18 v1(187.45,10.66)
  IN2 w0.089: v2(140.75,57.52) 140.47,57.52 140.11,57.88 140.11,63.05 139.71,63.46 139.71,66.27 139.27,66.71 139.27,67.16 139.1,67.33 138.81,67.33 138.49,67.65 138.49,68.03 138.72,68.26 140.23,68.26 140.48,68.51 v2(140.48,68.81) ; v1(196.02,10.24) 196.47,10.69 198.72,10.69 199.92,11.88 200.55,11.88 201.52,12.86 201.52,13.27 202.22,13.97 202.22,15.18 202.79,15.75 202.79,16.03 202.88,16.11 202.94,16.27 202.94,17.88 202.61,18.21 202.61,19.85 201.85,20.61 201.85,20.88 201.54,21.19 198.59,21.19 197.75,22.03 197.75,22.34 197.25,22.83 195.99,22.83 195.05,23.77 191.86,23.77 190.88,24.75 190.88,25.15 189.95,26.07 189.95,26.69 189.18,27.47 189.04,27.47 187.02,29.49 186.75,30.14 186.75,32.05 182.53,36.27 182.53,37.34 181.13,38.74 181.13,40.32 178.38,43.07 178.38,47.82 177.01,49.19 177.01,52.57 175.75,53.83 175.75,55.22 v1(175.92,55.39)
  BOTTOM w0.109: R4206.2 196.37,10.89 196.02,10.55 v1(196.02,10.24) ; U400.DK39 v2(140.48,68.81)
PCIE_WAKE#_C: length 2
  BOTTOM w0.109: CON4202.23 196.92,9.79 197.13,10.01 197.13,10.79 R4206.1
PD_ADP_DIS1: length 79.3
  TOP w0.076: U4700.H7 v2(196.09,18.29)
  IN1 w0.079: v1(175,57.81) 175.17,57.65 176.77,57.65 179.46,60.34 179.46,61.27 185.79,67.6 187.12,67.6 v1(187.17,67.54)
  IN2 w0.089: v1(175,57.81) 175,57.64 173.94,56.57 173.94,54.96 174.42,54.48 174.42,52.6 176.21,50.82 176.21,48.85 177.85,47.21 177.85,42.85 180.52,40.18 180.52,38.32 182,36.84 182,36.04 183.31,34.72 183.31,33.72 185.61,31.43 185.61,29.91 186.05,28.84 188.26,26.63 188.26,25.99 188.42,25.83 188.69,25.72 189.74,24.67 189.74,24.24 190.99,22.98 192.02,22.98 192.86,22.15 193.42,22.15 193.57,21.99 194.07,21.99 195.03,21.04 195.03,19.5 195.44,19.09 195.44,18.63 195.78,18.29 v2(196.09,18.29)
  BOTTOM w0.109: PQ8003.2 196.14,72.31 195.32,71.5 v1(194.97,71.5) 194.59,71.5 PR8013.2 194.1,71.11 193.16,70.18 191.8,70.18 190.78,69.16 189.3,69.16 187.83,67.69 187.32,67.69 v1(187.17,67.54)
PD_I2C_SCL: length 64.1
  TOP w0.109: R1106.2 157.04,75.79 R1130.1 157.45,75.79 160.21,78.55 161.97,78.55 162.39,78.14 v1(163.04,78.14) ; v1(162.79,83.44) 163,83.65 166.49,83.65 167.35,82.78 169.24,82.78 171.66,80.36 181.01,80.36 v1(181.33,80.68)
  IN1 w0.079: v2(195.16,87.74) 195.51,87.4 195.51,85.52 195.32,85.34 195.32,81.51 194.79,80.97 194.03,80.97 193.67,81.33 193.67,81.48 193.44,81.71 189.41,81.71 189.17,81.47 186.93,81.47 186.36,80.9 185.75,80.9 185.14,81.51 184.5,81.51 184.27,81.28 182.19,81.28 181.59,80.68 v1(181.33,80.68)
  IN2 w0.089: v1(162.79,83.44) 162.79,82.76 162.31,82.28 162.31,80.14 163.04,79.41 v1(163.04,78.14)
  BOTTOM w0.109: v1(162.79,83.44) 162.79,83.02 164.96,80.85 164.96,79.56 165.78,78.75 166.3,78.75 166.48,78.58 CON7701.6 ; v2(195.16,87.74) 194.9,87.49 U6100.13
PD_I2C_SCL3: length 103.5
  TOP w0.076: v2(195.44,19.59) U4700.F8
  TOP w0.109: R4739.1 171.68,45.51 v1(171.51,45.34) ; v1(170.83,79.46) 171.01,79.64 188.04,79.64 v1(188.19,79.78) 188.42,79.78 188.87,80.24 189.79,80.24 190.1,80.55 190.1,81.06 190.38,81.34 v2(190.39,81.34)
  IN1 w0.079: v2(195.44,19.59) 194.9,20.14 194.9,21.12 194.39,21.62 193.03,21.62 192.66,21.99 192.66,23.22 188.89,26.99 188.74,26.99 185.12,30.61 185.12,31.41 183.2,33.33 183.2,36.7 179.57,40.32 179.57,41.3 175.58,45.29 171.56,45.29 v1(171.51,45.34)
  BOTTOM w0.109: U6100.32 190.61,81.56 v2(190.39,81.34) ; v1(170.83,79.46) 169.09,77.71 169.09,77.11 168.79,76.81 168.44,76.66 167.65,76.66 167.56,76.58 CON7701.2 166.47,76.58 166.35,76.45 166.35,75.81 166.96,75.2 167.22,75.2 168.17,74.24 168.17,72.7 168.32,72.55 168.32,72.04 169.45,70.91 169.45,69.47 169.32,69.34 169.32,67.42 170.83,65.91 171.61,65.91 172.79,64.73 172.79,64.32 172.24,63.77 172.24,59.84 171.66,59.26 171.66,55.32 172.25,54.73 172.25,50.63 171.96,50.34 171.96,49.25 172.39,48.82 172.39,48.44 171.82,47.87 171.82,46.21 171.51,45.9 v1(171.51,45.34)
PD_I2C_SDA: length 59.6
  TOP w0.109: R1107.2 156.77,77.09 156.92,77.24 R1131.1 157.5,77.51 157.8,77.51 159.86,79.57 161.94,79.57 v1(162.13,79.77) ; v1(181.3,81.3) 181.02,81.3 180.3,80.58 171.77,80.58 169.34,83.01 167.45,83.01 166.58,83.88 163,83.88 v1(162.79,84.08)
  IN1 w0.079: v2(195.16,86.11) 195.16,81.56 194.73,81.13 194.09,81.13 193.83,81.39 193.83,81.55 193.51,81.87 189.34,81.87 189.1,81.63 186.86,81.63 186.31,81.08 185.82,81.08 185.21,81.69 184.43,81.69 184.2,81.46 182.12,81.46 181.96,81.3 v1(181.3,81.3)
  IN2 w0.089: v1(162.79,84.08) 162.36,83.64 162.36,82.61 162.13,82.38 v1(162.13,79.77)
  BOTTOM w0.109: CON7701.7 165.77,79.08 165.19,79.66 165.19,80.95 164.28,81.86 164.28,82.59 v1(162.79,84.08) ; v2(195.16,86.11) 194.97,86.29 U6100.16
PD_I2C_SDA3: length 102.8
  TOP w0.076: v2(195.44,20.24) U4700.F9
  TOP w0.109: v2(189.66,80.8) v1(189.08,80.8) 188.87,80.8 188.64,80.57 188.2,80.57 187.63,80 170.46,80 v1(170.38,79.92) ; v1(171.07,45.82) 170.63,46.26 R4733.1
  IN1 w0.079: v2(195.44,20.24) 195.08,20.6 195.08,21.18 194.43,21.84 193.73,21.84 193.36,22.21 193.36,22.84 185.45,30.75 185.45,31.54 183.53,33.47 183.53,36.83 179.92,40.44 179.92,41.42 175.72,45.62 171.87,45.62 171.67,45.82 v1(171.07,45.82)
  BOTTOM w0.109: v2(189.66,80.8) 190.02,81.16 190.02,81.51 190.21,81.7 U6100.33 ; v1(170.38,79.92) 170.38,79.53 168.72,77.87 168.72,77.26 168.58,77.11 168.37,77.03 167.68,77.03 167.63,77.08 CON7701.3 166.28,77.08 165.98,76.77 165.98,75.64 166.8,74.83 166.95,74.83 167.8,73.98 167.8,72.51 167.95,72.36 167.95,71.89 169.08,70.76 169.08,69.62 168.95,69.49 168.95,67.27 170.68,65.54 171.46,65.54 171.84,65.16 171.84,60.28 170.74,59.18 170.74,57.84 171.29,57.28 171.29,55.16 171.83,54.62 171.83,50.77 171.37,50.32 171.37,46.63 171.07,46.33 v1(171.07,45.82)
PDB: length 13.8
  TOP w0.109: Q3600.3 186.01,45.93 186.59,46.51 186.94,46.51 D3600.2 188.03,46.33 188.03,45.51 188.75,44.8 188.75,43.48 188.21,42.95 R3618.1 188.73,42.8 188.77,42.84 C3624.1 v1(190.42,42.84) 190.68,42.84 191.26,42.26 191.26,41.98 191.54,41.7 R3619.2 192.15,41.7 192.76,41.09 193.27,41.09 193.35,41.02 U3600.40
PEG_RXN1: length 69
  IN3 w0.114: v1(111.95,91.67) 111.76,91.48 111.76,90.75 111.35,90.33 110.78,90.33 110.35,90.76 110.35,92.02 107.18,95.2 98.7,95.2 96.84,93.33 91.12,93.33 88.3,90.51 88.3,87.67 86.66,86.03 86.66,84.66 84.92,82.92 84.92,81.75 83.83,80.66 83.83,77.84 82.98,76.99 82.98,75.06 80.3,72.38 80.3,71.72 78.73,70.15 78.29,70.15 76.23,68.1 74.88,68.1 74.37,67.58 73.8,67.35 73.44,66.99 72.52,66.99 71.87,67.64 71.87,69.04 71.98,69.32 71.98,69.5 v1(72.38,70.25)
  BOTTOM w0.109: C1313.1 109.93,90.27 110.49,90.27 110.61,90.4 111.3,90.4 111.68,90.78 111.75,90.93 111.75,91.18 v1(111.95,91.67) ; U6600.AB9 v1(72.38,70.25)
PEG_RXN1_C: length 4
  BOTTOM w0.109: C1313.2 109.26,88.96 109.26,88.6 108.52,87.86 108.52,86.36 108.41,86.08 108.39,86.07 U400.V2
PEG_RXN2: length 65.4
  IN3 w0.114: v1(109.85,91.67) 109.64,91.67 109.54,91.78 109.54,92.19 107.1,94.63 99.37,94.63 98.55,93.81 98.38,93.4 97.83,92.85 91.24,92.85 88.83,90.43 88.83,86.73 87.31,85.21 87.31,84.04 85.39,82.12 85.39,81.35 84.25,80.21 84.25,77.63 83.93,77.31 83.93,76.13 83.49,75.68 83.49,74.58 81.7,72.79 81.7,72.52 78.9,69.72 78.9,69.26 78.64,69 77.73,69 76.41,67.68 75.16,67.68 74.46,66.97 74.46,66.84 74.11,66.49 72.36,66.49 71.42,67.43 71.42,69.27 71.55,69.4 v1(71.56,69.4)
  BOTTOM w0.109: v1(71.56,69.4) 71.47,69.32 71.32,69.32 71.11,69.53 71.11,69.75 U6600.AC10 ; C1309.1 107.75,89.73 107.64,89.84 107.64,90.14 108.23,90.73 109.07,90.73 109.5,91.16 109.5,91.56 109.61,91.67 v1(109.85,91.67)
PEG_RXN2_C: length 3.8
  BOTTOM w0.109: C1309.2 107.84,88.96 107.84,88.67 107.74,88.57 107.74,87.48 107.87,87.35 107.87,87.12 107.87,87.12 107.87,86.36 107.76,86.08 107.74,86.07 U400.T2
PEG_RXN3: length 64.7
  IN3 w0.114: v1(70.71,69.41) 70.46,69.16 70.46,69.08 70.47,69.06 70.71,68.81 70.71,66.75 72.35,65.11 75.79,65.11 76.01,65.32 76.01,66.18 78.03,68.21 79.13,68.21 81.01,70.1 81.01,70.74 82.52,72.25 82.52,72.52 84.2,74.2 84.2,75.39 84.68,75.87 84.68,77.01 84.98,77.31 84.98,79.5 87.1,81.62 87.87,81.62 89.08,82.83 89.08,84.93 89.57,85.42 89.57,90.16 91.51,92.1 98.26,92.1 99.1,92.93 99.44,93.08 99.83,93.08 100.49,93.74 106.39,93.74 107.56,92.57 107.56,91.84 v1(107.74,91.65)
  BOTTOM w0.109: U6600.AC11 v1(70.71,69.41) ; C1312.2 106.29,89.99 106.29,90.07 107.47,91.25 107.47,91.56 107.56,91.65 v1(107.74,91.65)
PEG_RXN3_C: length 4
  BOTTOM w0.109: U400.R2 107.09,86.07 107.11,86.08 107.22,86.36 107.22,87.11 106.72,87.61 106.72,88.47 106.42,88.78 106.42,88.96 C1312.1
PEG_RXN4: length 59.4
  IN3 w0.114: v1(105.39,91.68) 105.29,91.77 105.29,92.37 104.69,92.97 101.23,92.97 93.94,85.68 92.67,85.68 90.33,83.35 90.33,82.54 87.93,80.13 87.7,80.13 87.21,79.65 87.21,78.36 85.53,76.68 85.53,75.71 85.06,75.24 85.06,73.12 79.36,67.42 78.4,67.42 76.73,65.76 76.73,64.95 76.18,64.4 71.97,64.4 70,66.37 70,67.86 69.56,68.52 69.52,68.64 69.52,69.74 v1(69.07,70.19)
  BOTTOM w0.109: U6600.AB12 69.48,70.6 v1(69.07,70.19) ; C1307.2 105.01,89.86 105.01,90.2 105.2,90.4 105.2,91.49 v1(105.39,91.68)
PEG_RXN4_C: length 4.3
  BOTTOM w0.109: U400.N2 106.44,86.07 106.46,86.08 106.57,86.36 106.57,87.07 105.76,87.88 105.76,88.05 105,88.81 105,88.96 C1307.1
PEG_RXP1: length 69
  IN3 w0.114: v1(111.09,91.67) 111.21,91.79 111.33,91.79 111.47,91.65 111.47,90.87 111.22,90.62 110.9,90.62 110.65,90.88 110.65,92.14 107.3,95.49 98.58,95.49 96.71,93.62 91,93.62 88.01,90.63 88.01,87.79 86.37,86.15 86.37,84.78 84.63,83.04 84.63,81.87 83.54,80.78 83.54,77.96 82.69,77.11 82.69,75.18 80.01,72.5 80.01,71.84 78.61,70.44 78.17,70.44 76.11,68.39 74.76,68.39 74.2,67.83 73.64,67.6 73.32,67.28 72.64,67.28 72.16,67.77 72.16,68.98 72.27,69.25 v1(72.42,69.4)
  BOTTOM w0.109: C1311.1 108.63,89.78 108.63,89.93 108.71,90.01 108.78,90.01 109.36,90.01 109.84,90.49 110.4,90.49 110.52,90.62 111.21,90.62 111.49,90.91 111.52,90.98 111.52,91.7 111.43,91.79 111.21,91.79 v1(111.09,91.67) ; v1(72.42,69.4) 72.36,69.34 72.03,69.34 71.98,69.39 71.98,69.54 71.96,69.56 U6600.AC9
PEG_RXP1_C: length 4
  BOTTOM w0.109: U400.V1 108.14,86.36 108.07,86.43 108.07,86.79 108.13,86.84 108.25,86.84 108.3,86.89 108.3,87.96 109.04,88.69 109.04,89.3 108.96,89.38 108.78,89.38 C1311.2
PEG_RXP2: length 65.4
  IN3 w0.114: v1(71.58,70.2) 71.58,70.17 71.13,69.72 71.13,67.31 72.24,66.2 74.23,66.2 74.75,66.72 74.75,66.85 75.28,67.38 76.53,67.38 77.85,68.7 78.76,68.7 79.2,69.14 79.2,69.6 81.99,72.39 81.99,72.67 83.78,74.46 83.78,75.56 84.22,76.01 84.22,77.19 84.54,77.51 84.54,80.09 85.68,81.23 85.68,82 87.6,83.92 87.6,85.09 89.12,86.61 89.12,90.31 91.36,92.56 97.95,92.56 98.63,93.24 98.8,93.64 99.49,94.33 106.98,94.33 109.24,92.07 109.24,91.83 v1(109.09,91.67)
  BOTTOM w0.109: U6600.AB10 71.58,70.22 v1(71.58,70.2) ; v1(109.09,91.67) 109.27,91.49 109.27,91.25 108.97,90.95 108.13,90.95 107.42,90.23 107.42,89.89 C1308.1
PEG_RXP2_C: length 3.8
  BOTTOM w0.109: C1308.2 107.36,89.38 107.54,89.38 107.62,89.3 107.62,88.76 107.52,88.66 107.52,87.38 107.65,87.26 107.65,87.12 107.65,87.12 107.65,86.89 107.6,86.84 107.48,86.84 107.42,86.79 107.42,86.43 107.49,86.36 U400.T1
PEG_RXP3: length 64.7
  IN3 w0.114: v1(69.93,69.41) 70.16,69.18 70.16,69.09 70.17,69.08 70.17,69.02 70.22,68.89 70.42,68.69 70.42,66.63 72.23,64.81 75.91,64.81 76.3,65.2 76.3,66.06 78.15,67.92 79.25,67.92 81.3,69.97 81.3,70.62 82.81,72.13 82.81,72.4 84.49,74.08 84.49,75.27 84.97,75.75 84.97,76.89 85.28,77.19 85.28,79.38 87.23,81.33 87.99,81.33 89.37,82.71 89.37,84.8 89.86,85.3 89.86,90.04 91.63,91.81 98.38,91.81 99.27,92.69 99.5,92.78 99.95,92.78 100.61,93.44 106.27,93.44 107.27,92.45 107.27,91.94 v1(106.98,91.65)
  BOTTOM w0.109: U6600.AD11 70.32,69.02 v1(69.93,69.41) ; C1310.2 106.07,89.96 106.07,90.17 107.24,91.34 107.24,91.58 107.17,91.65 v1(106.98,91.65)
PEG_RXP3_C: length 4
  BOTTOM w0.109: C1310.1 105.94,89.38 106.12,89.38 106.2,89.3 106.2,88.68 106.5,88.38 106.5,87.51 107,87 107,86.89 106.95,86.84 106.83,86.84 106.77,86.79 106.77,86.43 106.84,86.36 U400.R1
PEG_RXP4: length 59.3
  IN3 w0.114: v1(69.07,69.39) 69.23,69.24 69.23,68.6 69.29,68.4 69.71,67.77 69.71,66.25 71.85,64.1 76.3,64.1 77.02,64.82 77.02,65.64 78.52,67.13 79.48,67.13 85.35,73 85.35,75.12 85.82,75.59 85.82,76.56 87.5,78.24 87.5,79.53 87.82,79.84 88.05,79.84 90.63,82.41 90.63,83.23 92.79,85.39 94.06,85.39 101.35,92.68 104.57,92.68 105,92.25 105,91.79 104.86,91.65 104.78,91.65 v1(104.75,91.68)
  BOTTOM w0.109: U6600.AC12 69.56,69.72 69.56,69.62 69.51,69.5 69.32,69.31 69.15,69.31 v1(69.07,69.39) ; v1(104.75,91.68) 104.78,91.7 104.86,91.7 104.98,91.58 104.98,90.49 104.78,90.29 104.78,89.8 104.67,89.69 104.46,89.69 C1306.2
PEG_RXP4_C: length 4.3
  BOTTOM w0.109: U400.N1 106.19,86.36 106.12,86.43 106.12,86.79 106.18,86.84 106.3,86.84 106.35,86.89 106.35,86.98 105.54,87.79 105.54,87.95 104.77,88.72 104.77,89.3 104.7,89.38 104.52,89.38 C1306.1
PEG_TXN1: length 53.9
  IN3 w0.114: v2(109.65,83.94) 109.22,84.38 109.22,85.18 107.33,87.07 104.9,87.07 104.77,87.2 103.39,87.2 102.79,86.6 101.86,86.6 99.32,84.06 98.99,84.06 97.28,82.34 97.08,82.34 94.02,79.28 94.02,78.93 93.03,77.94 92.6,77.76 92.12,77.28 92.12,76.75 89.83,74.45 89.83,71.82 89.51,71.5 89.51,71.03 87.37,68.9 87.37,68.61 79.52,60.75 76.68,60.75 76.22,60.3 75.51,60.3 v2(75.36,60.14)
  BOTTOM w0.109: v2(75.36,60.14) 75.2,60.3 74.84,60.3 74.59,60.55 74.59,62.83 C6610.1 ; U400.Y7 109.48,83.94 v2(109.65,83.94)
PEG_TXN1_C: length 3.8
  BOTTOM w0.109: C6610.2 74.59,63.76 74.59,63.98 73.91,64.66 73.69,65.19 73.69,65.95 73.93,66.19 73.93,66.49 73.82,66.6 U6600.AG7
PEG_TXN2: length 56.6
  IN3 w0.079: v2(108.78,83.91) 108.59,84.11 108.39,84.11 108.25,84.26 108.25,85.15 107.61,85.78 107.52,85.78 107.5,85.8
  IN3 w0.114: v2(74.09,60.14) 74.23,60.28 74.43,60.28 74.52,60.19 74.52,59.48 75.24,58.76 77.28,58.76 78.41,59.89 79.98,59.89 80.62,60.53 81.31,60.53 84.66,63.87 84.66,64.69 87.82,67.85 88.13,67.85 89.23,68.95 89.23,69.46 90.31,70.54 90.31,71.3 91.12,72.11 91.12,74.15 92.56,75.59 92.56,76.09 94.97,78.5 94.97,79.21 97.15,81.39 98.09,81.39 99.08,82.38 100.02,82.38 100.48,82.85 100.48,84.17 102.14,85.84 103.13,85.84 103.45,86.15 107.15,86.15 107.5,85.8
  BOTTOM w0.109: C6634.1 73.17,62.83 73.17,62.68 73.43,62.41 73.43,60.57 73.71,60.3 73.94,60.3 v2(74.09,60.14) ; U400.V7 108.54,83.91 v2(108.78,83.91)
PEG_TXN2_C: length 4.9
  BOTTOM w0.109: C6634.2 73.05,63.84 73.05,67.13 73.15,67.22 73.15,67.46 U6600.AE7
PEG_TXN3: length 56.6
  IN3 w0.079: v2(107.85,83.9) 107.66,84.09 107.49,84.09 107.35,84.24 107.35,85.19 107,85.54 106.91,85.54 106.86,85.49
  IN3 w0.114: 106.86,85.49 103.88,85.49 103.44,85.05 102.45,85.05 101.45,84.05 101.45,82.8 100.3,81.66 99.51,81.66 97.96,80.11 96.87,80.11 95.76,78.99 95.76,78.27 93.64,76.15 93.64,74.32 92.91,73.59 92.91,72.9 91.23,71.21 91.02,71 91.02,70.24 90,69.22 90,68.69 88.44,67.13 88.12,67.13 87.56,66.58 87.56,65.87 85.65,63.95 85.65,63.35 82.07,59.76 80.98,59.76 79.04,57.82 74.04,57.82 73.3,58.56 73.3,60.14 73.19,60.26 72.93,60.26 v2(72.82,60.14)
  BOTTOM w0.109: v2(107.85,83.9) 107.61,83.9 U400.T7 ; v2(72.82,60.14) 72.64,60.32 72.44,60.32 72.21,60.55 72.21,61.77 C6643.1
PEG_TXN3_C: length 6.4
  BOTTOM w0.109: C6643.2 72.08,62.28 72.18,62.18 72.36,62.18 72.44,62.25 72.44,62.58 71.88,63.14 71.88,65.8 72.31,66.22 72.31,67.05 72.23,67.13 72.23,67.38 72.13,67.48 72.04,67.48 U6600.AF9
PEG_TXN4: length 57.2
  IN3 w0.114: v2(106.96,83.86) 106.93,83.86 106.57,84.22 106.44,84.54 106.43,84.55 106.33,84.76 106.03,84.94 104.52,84.94 103.88,84.29 103.88,83.71 103.5,83.33 102.49,83.33 102.25,83.09 102.25,82.55 100.63,80.93 99.86,80.93 98.32,79.39 97.17,79.39 96.48,78.69 96.48,77.85 95.89,77.27 95.89,75.27 95.5,74.87 94.59,74.87 94.35,74.63 94.35,74.02 93.8,73.47 93.8,72.67 91.73,70.6 91.73,69.94 90.71,68.93 90.71,68.35 89.1,66.74 89.1,65.42 86.23,62.55 85.9,62.55 82.38,59.03 81.54,59.03 79.54,57.03 73.36,57.03 72.01,58.39 72.01,60.03 71.81,60.22 71.63,60.22 v2(71.55,60.14)
  BOTTOM w0.109: v2(71.55,60.14) 71.39,60.3 71.23,60.3 70.95,60.58 70.95,61.61 C6657.1 ; U400.P7 106.66,83.86 v2(106.96,83.86)
PEG_TXN4_C: length 4.7
  BOTTOM w0.109: U6600.AG10 71.43,66.33 71.43,66.15 71.15,65.88 71.15,63.39 70.9,63.14 70.9,62.59 C6657.2
PEG_TXP1: length 53.9
  IN3 w0.114: v2(109.7,84.54) 109.59,84.54 109.51,84.62 109.51,85.3 107.45,87.36 105.02,87.36 104.89,87.49 103.27,87.49 102.66,86.89 101.74,86.89 99.2,84.35 98.87,84.35 97.16,82.64 96.96,82.64 93.72,79.4 93.72,79.05 92.86,78.19 92.44,78.01 91.83,77.4 91.83,76.87 89.53,74.57 89.53,71.94 89.22,71.63 89.22,71.16 87.08,69.02 87.08,68.73 79.4,61.05 76.56,61.05 76.1,60.59 75.46,60.59 v2(75.36,60.69)
  BOTTOM w0.109: U400.Y5 109.14,84.43 109.14,84.55 109.29,84.7 109.63,84.7 109.7,84.63 v2(109.7,84.54) ; C6609.1 74.81,62.83 74.81,60.64 74.93,60.53 75.31,60.53 75.36,60.58 v2(75.36,60.69)
PEG_TXP1_C: length 3.8
  BOTTOM w0.109: C6609.2 74.81,63.76 74.81,64.07 74.1,64.79 73.91,65.23 73.91,65.86 74.15,66.1 74.15,66.49 74.26,66.6 U6600.AG6
PEG_TXP2: length 56.6
  IN3 w0.079: v2(108.77,84.47) 108.57,84.27 108.46,84.27 108.4,84.32 108.4,85.21 107.73,85.89 107.73,85.99 107.71,86
  IN3 w0.114: 107.71,86 107.27,86.45 103.33,86.45 103.01,86.13 102.02,86.13 100.19,84.29 100.19,82.97 99.9,82.67 98.96,82.67 97.97,81.68 97.03,81.68 94.68,79.33 94.68,78.62 92.26,76.21 92.26,75.71 90.83,74.27 90.83,72.23 90.02,71.42 90.02,70.66 88.94,69.58 88.94,69.07 88.01,68.15 87.7,68.15 84.36,64.81 84.36,63.99 81.19,60.82 80.5,60.82 79.86,60.18 78.29,60.18 77.16,59.05 75.36,59.05 74.81,59.6 74.81,60.32 74.55,60.58 74.2,60.58 v2(74.09,60.69)
  BOTTOM w0.109: v2(74.09,60.69) 73.92,60.52 73.8,60.52 73.66,60.66 73.66,62.51 73.39,62.78 73.39,62.83 C6625.1 ; U400.V5 108.32,84.6 108.38,84.67 108.56,84.67 v2(108.77,84.47)
PEG_TXP2_C: length 4.8
  BOTTOM w0.109: U6600.AF7 73.58,67.46 73.45,67.46 73.37,67.38 73.37,67.13 73.28,67.04 73.28,63.42 73.35,63.35 73.46,63.35 C6625.2
PEG_TXP3: length 56.7
  IN3 w0.079: 106.86,85.79 106.95,85.7 107.06,85.7 107.51,85.26 107.51,84.3 107.56,84.25 107.67,84.25 v2(107.87,84.45)
  IN3 w0.114: 106.86,85.79 103.76,85.79 103.32,85.34 102.33,85.34 101.15,84.17 101.15,82.92 100.18,81.95 99.39,81.95 97.84,80.4 96.75,80.4 95.46,79.11 95.46,78.4 93.34,76.27 93.34,74.44 92.62,73.71 92.62,73.02 90.96,71.36 90.73,71.12 90.73,70.36 89.71,69.35 89.71,68.81 88.32,67.42 88,67.42 87.27,66.7 87.27,65.99 85.35,64.07 85.35,63.47 81.94,60.06 80.86,60.06 78.92,58.11 74.17,58.11 73.59,58.68 73.59,60.26 73.31,60.55 72.96,60.55 v2(72.82,60.69)
  BOTTOM w0.109: v2(72.82,60.69) 72.67,60.55 72.53,60.55 72.43,60.64 72.43,61.54 C6640.1 ; U400.T5 107.4,84.54 107.53,84.67 107.68,84.67 107.87,84.48 v2(107.87,84.45)
PEG_TXP3_C: length 6.5
  BOTTOM w0.109: C6640.2 72.66,62.67 72.66,62.67 72.1,63.23 72.1,65.7 72.53,66.13 72.53,67.14 72.45,67.22 72.45,67.46 U6600.AE9
PEG_TXP4: length 57.2
  IN3 w0.114: v2(106.96,84.43) 106.67,84.72 106.55,84.96 106.12,85.23 104.4,85.23 103.59,84.42 103.59,83.83 103.38,83.63 102.37,83.63 101.95,83.21 101.95,82.67 100.51,81.23 99.74,81.23 98.19,79.68 97.05,79.68 96.19,78.81 96.19,77.98 95.6,77.39 95.6,75.39 95.37,75.16 94.47,75.16 94.05,74.75 94.05,74.14 93.51,73.6 93.51,72.79 91.44,70.72 91.44,70.07 90.42,69.05 90.42,68.48 88.81,66.86 88.81,65.54 86.11,62.84 85.78,62.84 82.26,59.32 81.42,59.32 79.42,57.33 73.48,57.33 72.3,58.51 72.3,60.15 71.93,60.51 71.73,60.51 v2(71.55,60.69)
  BOTTOM w0.109: U400.P5 106.4,84.43 106.4,84.58 106.51,84.69 106.73,84.69 106.96,84.46 v2(106.96,84.43) ; C6656.1 71.25,61.9 71.17,61.82 71.17,60.68 71.32,60.53 71.38,60.53 v2(71.55,60.69)
PEG_TXP4_C: length 4.7
  BOTTOM w0.109: U6600.AG9 71.65,66.29 71.65,66.06 71.37,65.78 71.37,63.29 71.13,63.05 71.13,62.59 C6656.2
PEGX_RST#: length 30.3
  IN2 w0.089: v2(74.04,69.4) 74.04,68.84 73,67.8 73,66.24 73.56,65.68 74.16,65.68 v1(74.34,65.51)
  BOTTOM w0.109: Q6902.2 84.65,60.53 85.13,60.05 R6954.2 85.65,59.72 85.5,59.58 R6944.1 81.86,57.62 79.13,57.62 R6611.2 78.12,57.81 C6603.1 v1(77.24,57.8) 77.22,57.8 76.17,58.85 76.17,61.85 76.44,62.11 U6601.4 77.76,62.94 76.82,62.94 74.34,65.43 v1(74.34,65.51) ; U6600.AC7 v2(74.04,69.4)
PEX_CLKREQ#: length 18.3
  IN2 w0.089: v1(75.77,70.28) 75.47,70.28 74.55,69.36 74.55,69.06 73.2,67.71 73.2,66.42 73.71,65.91 74.5,65.91 74.74,65.67 74.81,65.67 v1(74.97,65.51)
  BOTTOM w0.109: v1(74.97,65.51) 74.97,65.43 75.4,65 75.93,65 77.36,63.56 79.34,63.56 v1(80.74,62.16) 81.3,61.6 Q6601.2 81.72,60.82 81.76,60.78 R6602.1 ; v1(75.77,70.28) 74.92,70.28 U6600.AC6
PEX_EN_1: length 25.3
  TOP w0.109: v1(65.25,60.34) 66.09,59.5 v1(66.09,55.78) v1(66.09,54.81) 66.09,54.75 65.39,54.05 61.72,54.05 60.84,54.93 59.79,54.93 v1(59.3,55.42)
  BOTTOM w0.109: PR10508.1 66.17,61.31 65.89,61.03 65.89,61.03 65.72,60.86 PR10506.2 65.25,60.6 v1(65.25,60.34) ; v1(66.09,55.78) PC10504.1 66.09,56.74 66.29,56.94 PU10500.1 ; v1(59.3,55.42) 59.21,55.52 53.85,55.52 53.03,56.33 53.03,57.42 53.21,57.6 PQ10500.2
PEX_FB: length 7.5
  BOTTOM w0.109: v1(73.16,55.73) PC10505.2 PR10510.1 72.92,57.81 70.86,57.81 70.2,57.16 70.2,56.77 69.81,56.38 PR10511.2 69.64,57.04 PU10500.6
PEX_FB_1: length 15.8
  BOTTOM w0.109: PR10505.1 61.42,56.97 62.25,56.13 63.21,56.13 v1(64.18,55.16) 64.46,54.88 73.09,54.88 73.94,55.72 PC10505.1 PR10510.2
PEX_LX:
  vias: v1(65,59.43)
PEX_PG_3: length 2.2
  BOTTOM w0.109: PR10503.1 70.56,58.95 PR10501.2 PU10500.5
PEX_TERMP: length 11.5
  BOTTOM w0.109: R6617.2 v1(67.59,63.47) 67.59,64.03 67.13,64.49 62.53,64.49 60.05,66.97 59.17,66.97 U6600.AF25
PEX_TSTCLK: length 10
  BOTTOM w0.109: U6600.AF22 61.24,67.17 61.64,66.77 61.64,66.42 61.85,66.2 62.69,66.2 63.9,64.99 67.49,64.99 68.8,63.68 68.8,63.4 R6612.2
PEX_TSTCLK#: length 11.5
  BOTTOM w0.109: U6600.AE22 61.24,68.19 61.61,67.82 61.61,67.23 61.81,67.03 62.18,67.03 62.84,66.37 62.84,66.36 63.99,65.21 67.58,65.21 69.02,63.78 69.02,62.84 R6612.1
PEX_VDD: length 7
  BOTTOM w0.254: R6808.2 48.61,58.52 49.25,59.15 54.73,59.15
  vias: v1(56.94,57.76) v1(57.63,57.76) v1(63.59,59.93) v1(64.3,59.94) v2(60.02,70.28) v2(60.86,71.07)
PEX_VDD_PG: length 58
  IN1 w0.079: v1(85.42,98.37) 85.93,98.37 86.56,97.74 86.56,96.63 87.45,95.73 87.45,90.3 84.91,87.76 84.91,84.67 84.01,83.78 84.01,82.44 82.29,80.72 81.2,80.72 80.72,80.24 80.72,78.5 79.77,77.55 79.1,77.55 77.95,76.4 77.95,75.73 77.55,75.33 77.55,74.41 76.86,73.72 75.44,73.72 73.66,71.94 71.83,71.94 71.46,71.94 70.76,71.23 68.62,71.23 68.04,70.64 68.04,66.44 v1(67.28,65.68)
  BOTTOM w0.109: v1(67.28,65.68) 67.71,65.68 69.45,63.94 69.45,62.29 70.05,61.69 70.05,61.11 v1(70.33,60.83) 70.33,60.2 70.58,59.95 PR10503.2 ; U6701.2 85.21,97.04 85.34,97.16 85.34,98.28 v1(85.42,98.37) 84.59,99.2 R6710.2
PEXVDD_EN: length 53.9
  IN1 w0.079: v1(88.78,96.5) 87.63,95.35 87.63,90.23 85.09,87.69 85.09,84.6 84.19,83.7 84.19,82.39 82.34,80.54 81.28,80.54 80.9,80.16 80.9,78.42 79.86,77.39 79.17,77.39 78.15,76.37 78.15,75.68 77.73,75.26 77.73,74.34 76.93,73.54 75.52,73.54 73.73,71.76 71.75,71.76 71.54,71.76 70.83,71.05 68.7,71.05 68.21,70.57 68.21,66.06 67.24,65.09 66.21,65.09 63.87,62.75 v1(63.87,61.19)
  BOTTOM w0.109: v1(63.87,61.19) 63.99,61.31 PR10506.1 ; U6902.4 89.7,97.6 88.78,96.68 v1(88.78,96.5)
PEXVDD_EN1: length 15.9
  IN3 w0.508: v1(87.1,97.04) 86.83,96.77 86.83,91.62 86.48,90.78 86.48,90.24 84.96,88.72 84.96,85.6 84.31,84.95 82.69,84.95 v1(82.4,84.66)
  BOTTOM w0.508: v1(87.1,97.04) U6902.2
  vias: v1(85.11,84.53)
PLAY_MUTE_LED: length 84.8
  TOP w0.109: v1(173.92,34.54) 173.23,34.54 172.77,34.08 171.68,34.08 171.09,33.5 169.92,33.5 169.01,34.41 Q5004.3 ; v1(132.99,12.93) 131.39,11.33 v1(131.19,11.33) 128.2,11.33 R5009.1
  IN2 w0.089: v1(173.92,34.54) 173.92,34.3 174.92,33.3 174.92,31.84 178.84,27.93 178.84,24.47 179.53,23.78 179.53,17.49 180.55,16.47 180.67,16.19 180.67,16.06 179.21,14.6 177.39,14.6 176.08,13.29 172.3,13.29 170.23,11.22 169.57,11.22 169.31,11.48 169.31,11.92 169.04,12.2 163.74,12.2 163.34,12.6 162.28,12.6 162.12,12.44 159.16,12.44 159.05,12.33 157.97,12.33 157.58,12.71 153.71,12.71 153.28,13.15 145.81,13.15 145.22,12.56 144.67,12.56 144.38,12.85 141.37,12.85 141.2,13.02 140.05,13.02 139.85,12.82 138.32,12.82 137.66,12.16 135.63,12.16 135.1,12.7 133.22,12.7 v1(132.99,12.93)
PLAY_MUTE_LED_CNTR: length 27
  TOP w0.109: v1(173.46,34.97) 173.31,34.82 R5018.1 ; v1(191.64,38.93) 191.65,38.92 U3600.3
  BOTTOM w0.109: R3611.1 191.49,38.79 v1(191.64,38.93) 191.82,39.11 191.82,41.04 191.69,41.17 186.89,41.17 186,40.28 182.64,40.28 181.15,38.79 181.15,38.31 180.75,37.91 180.75,36.6 179.09,34.93 174.18,34.93 174.14,34.97 v1(173.46,34.97)
PLT_DET: length 5.1
  TOP w0.076: U4700.D2 194.14,15.04 194.14,14.54 193.74,14.13 193.71,14.13
  TOP w0.109: 193.71,14.13 193.57,14 193.44,13.68 193.44,13.2 193.51,13.04 193.57,12.95 193.83,12.69 v1(193.83,12.62) 194.1,12.34 R4824.1 193.96,11.81 193.81,11.81 193.51,11.51 R4823.1
PLT_ID1: length 10
  TOP w0.109: v2(141.82,80.57) 142.11,80.27 143.29,80.27 144.31,79.26 146.4,79.26 146.8,79.67 146.8,79.79 147.53,80.52 149,80.52 149.27,80.24 R1135.1 R1134.2
  BOTTOM w0.109: U400.DN15 142.17,80.21 v2(141.82,80.57)
PLT_ID2: length 11.4
  TOP w0.109: v2(146.09,81.44) 145.89,81.21 145.32,80.65 142.92,80.65 142.52,81.05 141.04,81.05 140.58,80.59 v2(140.58,80.58)
  BOTTOM w0.109: v2(140.58,80.58) 140.58,80.47 U400.DJ15 ; v2(146.09,81.44) 146.93,81.44 147.31,81.82 148.32,81.82 v1(148.66,82.17) 149.01,81.82 149.14,81.82 149.27,81.69 R1137.1 R1136.2
PLT_ID4: length 8.7
  TOP w0.109: v2(147.31,79.73) 147.47,79.57 147.47,79.22 148.01,78.68 R1142.1 148.44,78.68 148.46,78.66 R1141.2
  BOTTOM w0.079: U400.DM13 141.76,81.02 142.08,81.34 142.39,81.34 142.8,80.93 143.98,80.93 144.11,80.8 144.79,80.8 145.14,80.45
  BOTTOM w0.109: v2(147.31,79.73) 147.04,79.73 146.31,80.45 145.14,80.45
PLTRST#: length 77.8
  TOP w0.109: v1(182.11,30.94) 181.68,30.51 181.09,30.51 v1(180.82,30.78) 180.57,31.03 179.17,31.03 177.33,29.2 174.28,29.2 173.22,30.26 168.52,30.26 160.82,37.96 160.82,38.84 160.47,39.19 160.01,39.19 159.66,38.84 158.98,38.84 157.89,37.74 154.12,37.74 153.36,38.51 153.36,40.59 153.87,41.1 R1509.2 153.87,41.83 Q1502.2 154.01,43.73 154.01,44.86 153.59,45.28 152.88,45.28 152.7,45.11 R1536.1 152.01,45.59 152.26,45.84 153.55,45.84 154,46.29 U1501.1 155.01,46.29 155.17,46.45 155.17,46.78 155.01,46.94 U1501.2
  TOP w0.14: U4700.J5 v2(197.39,16.99)
  IN2 w0.076: 196,15.76 197.23,16.99 v2(197.39,16.99)
  IN2 w0.089: 196,15.76 195.23,14.99 193.68,14.99 193.05,15.62 192.54,15.62 192.12,16.03 192.12,18.16 191.32,18.96 191.22,18.96 190.32,19.86 188.36,19.86 188.22,20 187.16,20 185.98,21.18 185.98,24.39 184.69,25.67 183.44,28.71 182.59,29.55 182.59,30.46 v1(182.11,30.94)
PLTRST#_PCH: length 38.2
  TOP w0.109: R1509.1 152.93,41.58 v1(152.75,41.76) 152.75,41.83 153.71,42.79 153.71,44.43 v1(153.36,44.78)
  IN2 w0.089: v1(153.36,44.78) 152.6,45.54 149.79,45.54 146.79,48.54 146.15,48.54 139.94,54.75 139.94,62.49 139.28,63.14 139.28,64.32 138.85,64.75 138.85,65.57 138.45,65.96 138.45,67.41 138.31,67.55 138.31,68.24 138.84,68.76 v2(139.15,68.76)
  BOTTOM w0.109: U400.DD41 138.77,68.76 v2(139.15,68.76)
PM_EXTTS#0: length 2.8
  TOP w0.109: v1(149.2,22.12) 149.25,22.18 R2801.2
  BOTTOM w0.109: v1(149.2,22.12) 149.68,21.64 JDIM2800.134
PM_EXTTS#1: length 2.9
  TOP w0.109: v1(73.21,22.13) 73.38,21.97 R2901.2
  BOTTOM w0.14: v1(73.21,22.13) 72.72,21.63 JDIM2900.134
PM_PWROK: length 116.4
  TOP w0.109: R4811.1 167.1,45.71 v1(167.18,45.78)
  TOP w0.14: U4700.K4 v2(198.04,16.34)
  IN1 w0.079: v2(198.04,16.34) 198.04,16.86 199.19,18.01 199.19,18.75 200.15,19.71 200.15,20.62 197.45,23.32 195.94,23.32 192.64,26.61 191.62,26.61 190.78,27.46 190.78,28.51 190.21,29.07 189.08,29.07 186.87,31.28 186.87,33.12 184.81,35.19 184.81,37.36 182.82,39.35 182.82,42.18 181.9,43.1 181.2,43.1 176.92,47.37 176.6,47.37 175.65,48.33 174.73,48.33 174.3,47.9 173.94,47.9 173.43,47.39 171.26,47.39 170.46,46.58 169.87,46.58 169.07,45.78 v1(167.18,45.78) ; v2(154.54,76.65) 154.54,76.64 154.54,76.62 154.75,76.41 155.83,76.41 156.76,77.34 158.69,77.34 159.57,76.46 v1(159.6,76.46)
  IN2 w0.089: v2(139.28,81.44) 139.7,81.02 140.26,81.02 140.28,81.05 140.64,81.05 140.77,80.92 142.03,80.92 142.21,81.1 143.99,81.1 144.96,82.07 148.43,82.07 149.96,80.54 150.92,80.54 151.25,80.2 151.25,79.12 151.66,78.71 152.3,78.71 152.5,78.51 153.03,78.51 154.54,77 v2(154.54,76.65) ; v1(159.6,76.46) 159.56,76.42 159.56,72.37 158.86,71.67 158.86,70.9 159.69,70.07 159.69,69.56 160.65,68.61 160.65,65.04 161.24,64.44 161.24,61.15 162.78,59.62 162.78,57.44 163.2,57.02 163.2,55.08 164,54.28 164,51.16 164.69,50.47 164.69,49.75 165.49,48.96 165.49,47.76 165.76,47.5 165.91,47.5 167.18,46.23 v1(167.18,45.78)
  BOTTOM w0.109: v2(139.28,81.44) 138.92,81.8 U400.DF10
PM_SLP_A#: length 231
  TOP w0.109: R1537.2 14.71,38.56 v1(14.79,38.64)
  IN1 w0.079: v1(14.79,38.64) 14.79,38.95 15.64,39.8 16.66,39.8 18.25,41.39 19.41,41.39 19.55,41.53 23.55,41.53 25.51,43.49 28.04,43.49 29.19,44.63 33.33,44.63 33.75,44.21 35.39,44.21 v1(35.99,43.61) ; v1(157.8,46.85) 158.72,46.85 159.85,47.98 160.35,47.98 162.87,50.5 162.87,51.44 165.03,53.6 172.15,53.6 172.49,53.93 174.26,53.93 174.56,54.22 176.17,54.22 176.94,54.99 v1(177.59,54.99)
  IN2 w0.089: v2(146.9,66.22) 146.91,66.22 146.91,65.56 147.49,64.98 147.55,64.84 147.55,64.03 147.38,63.86 146.31,63.86 145.42,62.97 145.42,61.45 146.49,60.38 146.49,57.62 149.61,54.51 150.04,54.51 150.98,53.57 152.63,53.57 153.01,53.18 153.01,51.98 153.31,51.68 153.31,50.65 152.92,50.26 152.92,48.83 153.27,48.48 153.84,48.48 154.11,48.21 156.53,48.21 157.8,46.94 v1(157.8,46.85) 157.8,46.55 158.73,45.62 158.73,44.56 159.69,43.6 160.74,42.55 160.74,42.33 v1(161.14,41.92)
  BOTTOM w0.079: 146.31,67.32 146.04,67.59 144.89,67.59 144.78,67.7 143.63,67.7 143.22,68.1 U400.DR41
  BOTTOM w0.109: v2(146.9,66.22) 146.9,66.23 146.91,66.23 146.91,66.48 146.89,66.49 146.89,66.74 146.31,67.32 ; CON7700.6 16.1,37.19 14.79,38.49 v1(14.79,38.64) ; v1(177.59,54.99) 179.2,56.61 PR8110.2 ; v1(35.99,43.61) 37.3,42.3 38.95,42.3 41.9,39.35 41.9,38.31 45.73,34.49 46,34.49 46.52,33.97 46.52,33.7 47.31,32.9 102.98,32.9 104.02,31.87 119.09,31.87 124.2,36.98 157.09,36.98 158.82,38.71 158.82,39.94 159.42,40.54 159.71,40.54 160.19,41.02 160.6,41.02 161.14,41.56 v1(161.14,41.92)
PM_THRMTRIP#: length 5.3
  TOP w0.109: R604.1 108.29,82.34 108.05,82.57 107.08,82.57 106.55,83.11 106.55,83.97 106.04,84.48 v2(106.04,84.49)
  BOTTOM w0.109: U400.M5 105.89,84.34 v2(106.04,84.49)
PP_DETECT#: length 214.3
  TOP w0.076: U4700.G10 v2(196.09,20.89)
  TOP w0.109: Q3405.3 36.57,34.03 v1(36.57,33.7) 36.55,33.68 v1(36.55,32.64) ; v1(88.44,9.45) 87.62,10.27 87.29,10.27 86.41,11.15 86.41,15.18 86.77,15.54 86.77,16.43 86.52,16.68 86.11,16.68 v1(85.71,16.29)
  IN1 w0.076: 196.49,20.5 196.09,20.89 v2(196.09,20.89)
  IN1 w0.079: 196.49,20.5 196.49,20.14 195.48,19.12 195.48,18.1 196.7,16.88 196.7,15.64 197.91,14.42 197.91,14.07 197.76,13.92 197.38,13.92 196.76,13.29 196.76,12.56 194.34,10.14 194.34,9.53 193.48,8.67 185.88,8.67 185.7,8.49 183.25,8.49 181.86,7.1 179.84,7.1 179.19,6.45 178.74,6.45 177.73,5.44 172.02,5.44 168.67,8.79 162.7,8.79 162.03,8.12 161.58,8.12 161.22,7.75 158.65,7.75 158.52,7.62 151.11,7.62 150.49,7.01 146.86,7.01 146.44,7.42 145.89,7.42 145.37,7.94 143.69,7.94 143.22,7.47 142.47,7.47 142.02,7.02 140.88,7.02 139.86,8.04 136.65,8.04 136.11,7.51 133.43,7.51 132.76,8.18 130.28,8.18 130.08,8.38 126.48,8.38 126.31,8.22 116.39,8.22 114.15,5.98 104.83,5.98 103.85,6.96 102.48,6.96 102.05,7.39 99.66,7.39 98.59,8.46 96.68,8.46 96.16,8.99 88.91,8.99 v1(88.44,9.45)
  IN2 w0.089: v1(36.55,32.64) 36.02,32.1 34.95,32.1 31.82,28.98 31.82,21.26 33.71,19.37 35.57,19.37 37.16,17.78 45.79,17.78 48.56,15.01 58.74,15.01 60.75,13 63.6,13 65.23,14.63 70.05,14.63 72.53,17.11 80.88,17.11 82.08,15.91 85.33,15.91 v1(85.71,16.29)
PP_DETECT#_EDP: length 21.4
  TOP w0.109: U3405.6 29.79,38.49 R3431.2 30.07,38.35 33.88,38.35 v1(33.98,38.45) 34.34,38.1 34.34,37.67 35.59,36.42 35.59,35.89 Q3405.2 34.87,35.02 35.41,34.48 35.41,33.47 35.83,33.05 35.83,32.25 v1(35.2,31.62)
  BOTTOM w0.109: v1(35.2,31.62) 35.1,31.53 30.63,31.53 30.35,31.25 30.03,31.25 29.74,30.97 29.2,30.97 28.92,31.25 CON3400.12
PP_HVA: length 275.3
  TOP w0.076: U4700.H6 196.74,18.29 v2(196.74,18.29)
  TOP w0.109: R4821.1 179.12,3.27 v1(179.02,3.17)
  IN1 w0.079: v1(9.92,35.05) 10.01,35.14 18.61,35.14 19.28,35.81 19.28,38.12 20.46,39.3 22.9,39.3 25.36,41.76 26.22,41.76 26.47,41.5 v1(27.28,41.5)
  IN2 w0.089: v1(179.02,3.17) 179.02,4.2 183.13,8.31 184.38,8.31 184.83,8.76 190.81,8.76 191.94,9.89 193.64,9.89 194.79,11.05 198.58,11.05 199.47,11.93 199.46,11.94 199.46,13 199.95,13.49 200.38,13.49 200.53,13.64 201.39,13.64 201.87,14.12 201.87,15.17 201.52,15.52 201.52,16.04 202.26,16.79 202.26,19.58 201.78,20.06 200.86,20.06 200.25,19.45 198.7,19.45 197.84,18.59 197.04,18.59 v2(196.74,18.29)
  IN3 w0.089: v1(9.92,35.05) 9.87,35 9.87,20.62 7.98,18.73 7.98,9.36 10.24,7.11 16.28,7.11 16.7,6.69 21.47,6.69 22.02,6.14 22.99,6.14 23.59,5.53 23.59,4.93 24.21,4.31 31.9,4.31 32.02,4.43 50.03,4.43 50.91,5.31 51.97,5.31 52.61,4.67 52.88,4.67 54.72,2.82 64.64,2.82 65.58,3.76 66.79,3.76 68.1,2.45 74.36,2.45 75.63,3.72 75.63,7 76.86,8.23 97.63,8.23 98.53,7.33 101.13,7.33 101.6,6.87 105.13,5.4 132.67,5.4 132.95,5.68 136.71,5.68 137.38,6.35 138.06,6.35 138.73,5.68 163.36,5.68 163.63,5.94 168.59,5.94 172.03,2.51 178.36,2.51 v1(179.02,3.17)
  BOTTOM w0.109: v1(27.28,41.5) 27.28,41.04 27.57,40.75 CON3400.31
PRE: length 3
  TOP w0.109: R3504.1 R3505.1 200.69,52 200.89,52.19 200.89,53.19 200.46,53.61 U3501.15
PRIVACY_LED#_R: length 76.2
  TOP w0.076: U4700.D4 v2(193.49,16.34)
  TOP w0.109: R5002.1 130.21,8.29 v1(129.92,8.01)
  IN2 w0.089: v1(129.92,8.01) 130.07,8.16 132.64,8.16 133.49,7.31 136.16,7.31 136.62,7.77 138.09,7.77 138.35,8.03 142.83,8.03 142.89,8.09 144.78,8.09 145.16,8.47 152.23,8.47 152.31,8.39 157.97,8.39 158.45,8.88 160.7,8.88 160.86,9.03 162.06,9.03 162.6,8.49 164.68,8.49 164.92,8.25 169.86,8.25 172.28,5.83 174.64,5.83 174.92,6.12 176.78,6.12 177.12,6.46 177.12,7.17 177.56,7.61 177.56,7.84 181.29,11.56 184.69,11.56 185.23,12.1 187.99,12.1 189.63,13.74 189.63,16.05 189.33,16.36 v2(189.1,16.36)
  IN3 w0.076: 192.99,15.98 193.13,15.98 v2(193.49,16.34)
  IN3 w0.089: v2(189.1,16.36) 190.01,16.36 190.54,16.58 192.08,16.58 192.68,15.98 192.99,15.98
PROCHOT#_CPU: length 5.8
  BOTTOM w0.109: R603.2 99.97,89.72 102.72,86.97 102.72,85.86 U400.E2

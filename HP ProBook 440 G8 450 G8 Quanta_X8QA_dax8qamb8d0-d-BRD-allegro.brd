# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BSH-030-01-L-D-A-TR-60P-RUV
  round 1.016 hole 1.016 unplated: (-10.063,-2.666) (10.063,-2.666)
  rect 0.279x2.261 smd: 1(7.25,2.864) 2(7.25,-2.864) 3(6.75,2.864) 4(6.75,-2.864) 5(6.25,2.864) 6(6.25,-2.864) 7(5.75,2.864) 8(5.75,-2.864) 9(5.25,2.864) 10(5.25,-2.864) 11(4.75,2.864) 12(4.75,-2.864) 13(4.25,2.864) 14(4.25,-2.864) 15(3.75,2.864) 16(3.75,-2.864) 17(3.25,2.864) 18(3.25,-2.864) 19(2.75,2.864) 20(2.75,-2.864) 21(2.25,2.864) 22(2.25,-2.864) 23(1.75,2.864) 24(1.75,-2.864) 25(1.25,2.864) 26(1.25,-2.864) 27(0.75,2.864) 28(0.75,-2.864) 29(0.25,2.864) 30(0.25,-2.864) 31(-0.25,2.864) 32(-0.25,-2.864) 33(-0.75,2.864) 34(-0.75,-2.864) 35(-1.25,2.864) 36(-1.25,-2.864) 37(-1.75,2.864) 38(-1.75,-2.864) 39(-2.25,2.864) 40(-2.25,-2.864) 41(-2.75,2.864) 42(-2.75,-2.864) 43(-3.25,2.864) 44(-3.25,-2.864) 45(-3.75,2.864) 46(-3.75,-2.864) 47(-4.25,2.864) 48(-4.25,-2.864) 49(-4.75,2.864) 50(-4.75,-2.864) 51(-5.25,2.864) 52(-5.25,-2.864) 53(-5.75,2.864) 54(-5.75,-2.864) 55(-6.25,2.864) 56(-6.25,-2.864) 57(-6.75,2.864) 58(-6.75,-2.864) 59(-7.25,2.864) 60(-7.25,-2.864)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CC7343-3H
  rect 2.388x2.896 smd: 1(-3.05,0) 2(3.05,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_7X1_25-2P
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-1_85X1_25-2P-0_95H
  rect 0.787x0.889 smd: 1(-1.07,0) 2(1.07,0)
D-1X0_6-0_53H
  rect 0.406x0.711 smd: 1(-0.35,0) 2(0.35,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-4_3X2_7
  rect 2.057x2.057 smd: 1(-1.865,0) 2(1.865,0)
D-SOD323-1_7X1_3-B0530WS
  rect 0.584x0.457 smd: 1(-1.055,0) 2(1.055,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD523-1_2X0_8-0_65H
  rect 0.787x0.61 smd: 1(-0.55,0) 2(0.55,0)
DDR4-D4AR0-26010-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DFN6-1_6X1_6-5-7P-0_6H
  rect 0.406x0.254 smd: 1(0.8,-0.5) 2(0.8,0) 3(0.8,0.5) 4(-0.8,0.5) 5(-0.8,0) 6(-0.8,-0.5)
  rect 0.61x0.991 smd: 7(0,0)
DFN8-3X3-65-7P
  rect 0.305x0.406 smd: 1(-0.975,-1.3) 2(-0.325,-1.3) 3(0.325,-1.3) 4(0.975,-1.3) 5(0.975,1.3)
  rect 1.6x0.406 smd: 6(-0.325,1.3)
  rect 2.388x1.6 smd: 9(0,0)
DFN14-3X2-4-11P
  custom 0.15x0.15 smd: 1(-1.2,-1) 6(0.8,-1) 9(0.8,1) 14(-1.2,1)
  rect 0.203x0.711 smd: 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 10(0.4,1) 11(0,1) 12(-0.4,1)
  rect 2.489x0.787 smd: 15(0,0)
ESD3-0_985X0_585
  custom 0.062x0.062 smd: 1(0.35,-0.225) 2(0.35,0.225)
  custom 0.1x0.1 smd: 3(-0.35,0)
ESD10-2_5X1-5-0_5H
  rect 0.203x0.483 smd: 1(-1,-0.388) 2(-0.5,-0.388) 3(0,-0.388) 4(0.5,-0.388) 5(1,-0.388) 6(1,0.388) 7(0.5,0.388) 8(0,0.388) 9(-0.5,0.388) 10(-1,0.388)
F2_1X1_4-2_2-0_8H
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
F2_1X1_35-2_2-0_75H
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
F4_5X3_2-5_23
  rect 1.778x3.15 smd: 1(-2.615,0) 2(2.615,0)
FILTER-BLM03EB500SN1D-2P
  rect 0.254x0.305 smd: 1(-0.25,0) 2(0.25,0)
FILTER-MCM2012B900GBE-4P-SMT
  rect 0.762x0.61 smd: 1(-0.925,0.502) 2(0.925,0.502) 3(0.925,-0.502) 4(-0.925,-0.502)
FPC-50506-0150B-V01-15P-L
  rect 0.305x0.889 smd: 1(-3.5,3.05) 2(-3,3.05) 3(-2.5,3.05) 4(-2,3.05) 5(-1.5,3.05) 6(-1,3.05) 7(-0.5,3.05) 8(0,3.05) 9(0.5,3.05) 10(1,3.05) 11(1.5,3.05) 12(2,3.05) 13(2.5,3.05) 14(3,3.05) 15(3.5,3.05)
  rect 0.991x2.007 smd: 16(-5.6,0) 17(5.6,0)
FPC-51697-0420M-001-42P-L
  rect 0.305x1.245 smd: 1(-10.25,3.275) 2(-9.75,3.275) 3(-9.25,3.275) 4(-8.75,3.275) 5(-8.25,3.275) 6(-7.75,3.275) 7(-7.25,3.275) 8(-6.75,3.275) 9(-6.25,3.275) 10(-5.75,3.275) 11(-5.25,3.275) 12(-4.75,3.275) 13(-4.25,3.275) 14(-3.75,3.275) 15(-3.25,3.275) 16(-2.75,3.275) 17(-2.25,3.275) 18(-1.75,3.275) 19(-1.25,3.275) 20(-0.75,3.275) 21(-0.25,3.275) 22(0.25,3.275) 23(0.75,3.275) 24(1.25,3.275) 25(1.75,3.275) 26(2.25,3.275) 27(2.75,3.275) 28(3.25,3.275) 29(3.75,3.275) 30(4.25,3.275) 31(4.75,3.275) 32(5.25,3.275) 33(5.75,3.275) 34(6.25,3.275) 35(6.75,3.275) 36(7.25,3.275) 37(7.75,3.275) 38(8.25,3.275) 39(8.75,3.275) 40(9.25,3.275) 41(9.75,3.275) 42(10.25,3.275)
  rect 1.397x1.194 smd: 43(-12.705,0) 44(12.705,0)
FPC-52509-00601-V01-6P-L
  rect 0.305x0.787 smd: 1(-1.25,2.5) 2(-0.75,2.5) 3(-0.25,2.5) 4(0.25,2.5) 5(0.75,2.5) 6(1.25,2.5)
  rect 0.457x0.787 smd: 7(-2.465,0) 8(2.465,0)
FPC-52509-00801-V01-8P-L
  rect 0.305x0.787 smd: 1(-1.75,2.5) 2(-1.25,2.5) 3(-0.75,2.5) 4(-0.25,2.5) 5(0.25,2.5) 6(0.75,2.5) 7(1.25,2.5) 8(1.75,2.5)
  rect 0.457x0.787 smd: 9(-2.965,0) 10(2.965,0)
FPC-52526-04001-001-40P-L
  rect 0.305x0.61 smd: 1(-9.75,2.85) 2(-9.25,2.85) 3(-8.75,2.85) 4(-8.25,2.85) 5(-7.75,2.85) 6(-7.25,2.85) 7(-6.75,2.85) 8(-6.25,2.85) 9(-5.75,2.85) 10(-5.25,2.85) 11(-4.75,2.85) 12(-4.25,2.85) 13(-3.75,2.85) 14(-3.25,2.85) 15(-2.75,2.85) 16(-2.25,2.85) 17(-1.75,2.85) 18(-1.25,2.85) 19(-0.75,2.85) 20(-0.25,2.85) 21(0.25,2.85) 22(0.75,2.85) 23(1.25,2.85) 24(1.75,2.85) 25(2.25,2.85) 26(2.75,2.85) 27(3.25,2.85) 28(3.75,2.85) 29(4.25,2.85) 30(4.75,2.85) 31(5.25,2.85) 32(5.75,2.85) 33(6.25,2.85) 34(6.75,2.85) 35(7.25,2.85) 36(7.75,2.85) 37(8.25,2.85) 38(8.75,2.85) 39(9.25,2.85) 40(9.75,2.85)
  rect 0.406x0.787 smd: 41(-11.1,0) 42(11.1,0)
H-600TGL-1
  custom 1.425x1.425 hole 2.794: 1(0,0)
H-600TGL-4
  custom 1.75x1.75 hole 2.997: 1(0,0)
H-C71D71N
  round 1.803 hole 1.803 unplated: (0,0)
H-O80X100D80X100N
  oval 2.032x2.54 hole 2.032x2.54 unplated: (0,0)
H-O98X59D98X59N
  oval 2.489x1.499 hole 2.489x1.499 unplated: (0,0)
H-TBC276IC154D154P2
  round 7.01 hole 3.912: 1(0,0)
H-TC197IBC126D126P2
  round 3.2 hole 3.2: 1(0,0)
H-TC276IC134BC276D134P2
  round 7.01 hole 3.404: 1(0,0)
H-TC276IC134BS1D134P2
  round 7.01 hole 3.404: 1(0,0)
H-TC276IC150BC150D150PT
  round 7.01 hole 3.81: 1(0,0)
HDMI-PDMR004019P1-1-19P
  round 0.787 hole 0.559: 1(-4.5,6.5) 2(-4,8.05) 3(-3.5,6.5) 4(-3,8.05) 5(-2.5,6.5) 6(-2,8.05) 7(-1.5,6.5) 8(-1,8.05) 9(-0.5,6.5) 10(0,8.05) 11(0.5,6.5) 12(1,8.05) 13(1.5,6.5) 14(2,8.05) 15(2.5,6.5) 16(3,8.05) 17(3.5,6.5) 18(4,8.05) 19(4.5,6.5)
  oval 1.499x2.21 hole 0.889x1.6: 20(-9.15,0) 21(-7.45,6.8) 22(9.15,-1.25) 23(7.45,6.8)
L2_5X2-1_2
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L4_5X4_7-2_8H
  rect 2.007x2.489 smd: 1(-2.5,0) 2(2.5,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-3H
  rect 1.854x3.505 smd: 1(-2.775,0) 2(2.775,0)
LEDLTW-326DSKF-5A-3P-SMT
  rect 0.889x1.295 smd: 1(-1.45,-0.1) 3(1.45,-0.1)
  rect 0.889x0.889 smd: 2(0,-0.65)
LVDS-50406-03001-V09-30P-R
  rect 0.254x1.295 smd: 1(7.25,1.95) 2(6.75,1.95) 3(6.25,1.95) 4(5.75,1.95) 5(5.25,1.95) 6(4.75,1.95) 7(4.25,1.95) 8(3.75,1.95) 9(3.25,1.95) 10(2.75,1.95) 11(2.25,1.95) 12(1.75,1.95) 13(1.25,1.95) 14(0.75,1.95) 15(0.25,1.95) 16(-0.25,1.95) 17(-0.75,1.95) 18(-1.25,1.95) 19(-1.75,1.95) 20(-2.25,1.95) 21(-2.75,1.95) 22(-3.25,1.95) 23(-3.75,1.95) 24(-4.25,1.95) 25(-4.75,1.95) 26(-5.25,1.95) 27(-5.75,1.95) 28(-6.25,1.95) 29(-6.75,1.95) 30(-7.25,1.95)
  rect 1.194x2.692 smd: 31(9.65,0) 32(-9.65,0)
  rect 2.311x1.295 smd: 33(6.4,-1.95) 34(0,-1.95) 35(-6.4,-1.95)
MSOP8-4_9-65-G547
  rect 0.356x1.397 smd: 1(-0.975,-2.5) 2(-0.325,-2.5) 3(0.325,-2.5) 4(0.975,-2.5) 5(0.975,2.5) 6(0.325,2.5) 7(-0.325,2.5) 8(-0.975,2.5)
NGFF-NFSB0-S6710-TP20-KB-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NFSE0-S6710-TPH4-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NFSM0-S6710-TPH4-75P-KM
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
POWER-3X3-65-5P-ADNR21357
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(0,0)
POWER-4_5X3_5-5-13P
  rect 0.279x0.762 smd: 1(-1,-2.175) 2(-0.5,-2.175) 3(0,-2.175) 4(0.5,-2.175) 5(1,-2.175)
  custom 0.322x0.322 smd: 6(1.303,-1)
  custom 0.439x0.439 smd: 9(0,0)
  custom 0.188x0.188 smd: 12(0,1.955)
  rect 0.762x0.279 smd: 19(-1.675,0) 20(-1.675,-0.5) 21(-1.675,-1)
  rect 0.737x0.279 smd: 22(-1.688,-1.5)
  rect 1.194x1.168 smd: 23(-0.412,-0.94)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5_2X5_55-1_27-7P-1H
  rect 0.508x0.559 smd: 1(-1.905,-2.8) 5(1.905,2.8) 6(0.635,2.8) 7(-0.635,2.8) 8(-1.905,2.8)
  custom 0.463x0.463 smd: 2(0,-2.1)
  rect 4.648x2.54 smd: 9(0,0.55)
QFN8-1_2X1-4
  rect 0.178x0.381 smd: 1(-0.4,-0.46) 3(0.4,-0.46) 5(0.4,0.46) 6(0,0.46) 7(-0.4,0.46)
  rect 0.178x0.508 smd: 2(0,-0.398)
  rect 0.381x0.178 smd: 4(0.56,0) 8(-0.56,0)
QFN10-2X1_5-5-0_65H
  rect 0.305x0.533 smd: 1(-0.75,-0.64) 4(0.75,-0.64) 6(0.75,0.64) 9(-0.75,0.64)
  rect 0.254x0.533 smd: 2(-0.25,-0.64) 3(0.25,-0.64) 7(0.25,0.64) 8(-0.25,0.64)
  rect 0.635x0.356 smd: 5(0.84,0) 10(-0.84,0)
QFN11-2X2-5
  rect 0.254x1.499 smd: 1(-0.25,-0.55) 6(0.25,0.55)
  rect 0.711x0.254 smd: 2(1,-0.75) 3(1,-0.25) 4(1,0.25) 5(1,0.75) 8(-1,0.75) 9(-1,0.25) 10(-1,-0.25) 11(-1,-0.75)
  rect 0.254x0.711 smd: 7(-0.25,0.95)
QFN12-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 7(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 9(-1.45,0.75) 10(-1.45,0.25) 11(-1.45,-0.25) 12(-1.45,-0.75)
  rect 0.254x0.711 smd: 8(-0.5,0.95)
QFN13-4X3-45
  custom 0.337x0.337 smd: 1(0.25,-1.68)
  rect 1.702x0.457 smd: 2(1,-0.5) 12(-1,-0.5)
  rect 1.702x0.838 smd: 3(1,0.38) 11(-1,0.38)
  rect 0.787x0.203 smd: 4(1.45,1.13) 10(-1.45,1.13)
  rect 0.254x0.787 smd: 5(0.9,1.95) 6(0.45,1.95) 7(0,1.95) 8(-0.45,1.95) 9(-0.9,1.95)
  rect 0.787x0.254 smd: 13(-1.45,-1.125)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN19-4X3-4
  rect 0.254x1.702 smd: 1(-1,-0.95) 2(0,-0.95) 3(1,-0.95) 11(0.5,0.95) 12(-0.5,0.95)
  rect 0.787x0.254 smd: 4(1.9,-1.05) 9(1.9,1.05) 14(-1.9,1.05) 19(-1.9,-1.05)
  rect 0.787x0.203 smd: 5(1.9,-0.6) 6(1.9,-0.2) 7(1.9,0.2) 8(1.9,0.6) 15(-1.9,0.6) 16(-1.9,0.2) 17(-1.9,-0.2) 18(-1.9,-0.6)
  rect 0.254x0.787 smd: 10(1,1.4) 13(-1,1.4)
QFN20-3X3-4-21P-MP2988
  custom 0.05x0.05 smd: 1(-0.8,-1.45) 5(0.8,-1.45) 6(1.45,-0.8) 10(1.45,0.8) 11(0.8,1.45) 15(-0.8,1.45) 16(-1.45,0.8) 20(-1.45,-0.8)
  rect 0.203x0.711 smd: 2(-0.4,-1.45) 3(0,-1.45) 4(0.4,-1.45) 12(0.4,1.45) 13(0,1.45) 14(-0.4,1.45)
  rect 0.711x0.203 smd: 7(1.45,-0.4) 8(1.45,0) 9(1.45,0.4) 17(-1.45,0.4) 18(-1.45,0) 19(-1.45,-0.4)
  rect 1.651x1.651 smd: 21(0,0)
QFN20-3X3-4-21P-RT6543B
  custom 0.05x0.05 smd: 1(-0.8,-1.475) 5(0.8,-1.475) 6(1.475,-0.8) 10(1.475,0.8) 11(0.8,1.475) 15(-0.8,1.475) 16(-1.475,0.8) 20(-1.475,-0.8)
  rect 0.203x0.838 smd: 2(-0.4,-1.475) 3(0,-1.475) 4(0.4,-1.475) 12(0.4,1.475) 13(0,1.475) 14(-0.4,1.475)
  rect 0.838x0.203 smd: 7(1.475,-0.4) 8(1.475,0) 9(1.475,0.4) 17(-1.475,0.4) 18(-1.475,0) 19(-1.475,-0.4)
  rect 1.702x1.702 smd: 21(0,0)
QFN21-5X3-4-15P
  rect 0.305x1.6 smd: 1(-1.475,-1) 2(-0.825,-1) 3(0.275,-1) 4(1.375,-1) 12(0.825,1) 13(-0.275,1) 14(-1.475,1)
  custom 0.212x0.212 smd: 5(2.375,0)
  custom 0.175x0.175 smd: 15(-2.375,1.2) 21(-2.375,-1.2)
  rect 0.838x0.203 smd: 16(-2.375,0.8) 17(-2.375,0.4) 18(-2.375,0) 19(-2.375,-0.4) 20(-2.375,-0.8)
QFN23-4X4-5-20P
  rect 0.254x0.457 smd: 1(-1.25,-1.825) 2(-0.75,-1.825) 3(-0.25,-1.825) 4(0.25,-1.825) 5(0.75,-1.825) 6(1.25,-1.825) 12(1.25,1.825) 13(0.75,1.825) 14(0.25,1.825) 15(-0.25,1.825) 16(-0.75,1.825) 17(-1.25,1.825)
  custom 0.346x0.346 smd: 7(1.825,-1.25)
  custom 0.249x0.249 smd: 10(1.825,0.75)
  rect 0.457x0.254 smd: 18(-1.825,1.25) 19(-1.825,0.75) 20(-1.825,0.25) 21(-1.825,-0.25) 22(-1.825,-0.75) 23(-1.825,-1.25)
QFN28-4X4-4-29P-BQ24780RUYR
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
QFN32-4X4-4-33P-ISL95860
  custom 0.05x0.05 smd: 1(-1.4,-1.9) 8(1.4,-1.9) 9(1.9,-1.4) 16(1.9,1.4) 17(1.4,1.9) 24(-1.4,1.9) 25(-1.9,1.4) 32(-1.9,-1.4)
  rect 0.203x0.61 smd: 2(-1,-1.9) 3(-0.6,-1.9) 4(-0.2,-1.9) 5(0.2,-1.9) 6(0.6,-1.9) 7(1,-1.9) 18(1,1.9) 19(0.6,1.9) 20(0.2,1.9) 21(-0.2,1.9) 22(-0.6,1.9) 23(-1,1.9)
  rect 0.61x0.203 smd: 10(1.9,-1) 11(1.9,-0.6) 12(1.9,-0.2) 13(1.9,0.2) 14(1.9,0.6) 15(1.9,1) 26(-1.9,1) 27(-1.9,0.6) 28(-1.9,0.2) 29(-1.9,-0.2) 30(-1.9,-0.6) 31(-1.9,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-4X4-5-33P-RTS5227-GRT
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-SLB9645VQ
  rect 0.254x0.711 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4) 17(1.75,2.4) 18(1.25,2.4) 19(0.75,2.4) 20(0.25,2.4) 21(-0.25,2.4) 22(-0.75,2.4) 23(-1.25,2.4) 24(-1.75,2.4)
  rect 0.711x0.254 smd: 9(2.4,-1.75) 10(2.4,-1.25) 11(2.4,-0.75) 12(2.4,-0.25) 13(2.4,0.25) 14(2.4,0.75) 15(2.4,1.25) 16(2.4,1.75) 25(-2.4,1.75) 26(-2.4,1.25) 27(-2.4,0.75) 28(-2.4,0.25) 29(-2.4,-0.25) 30(-2.4,-0.75) 31(-2.4,-1.25) 32(-2.4,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
QFN40-5X5-4-41P-SMB349NT
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
QFN48-6X6-4-49P-0_6H
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.597x4.597 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
S1206
  rect 2.032x1.626 smd: 1(1.4,0) 2(-1.4,0)
SDCARD-158-1000902616-9P
  rect 0.66x0.991 smd: 1(2.6,9.6) 2(1.7,9.6) 3(0.8,9.6) 4(-0.1,9.6) 5(-1,9.6) 6(-1.9,9.6) 7(-2.8,9.6) 8(-3.7,9.6)
  rect 0.889x0.991 smd: 9(-5.3,9.6)
  rect 1.194x1.295 smd: 10(7.3,2.7)
  rect 0.991x1.702 smd: 11(-7.2,9.25) 12(7.2,9.25)
  oval 1.092x1.803 hole 0.508x1.194: 13(6.825,0) 14(-6.825,0)
SIMCARD-5-501709002000-6-6P
  rect 0.889x1.194 smd: 1(-3.175,6.8) 2(-0.635,6.8) 3(1.905,6.8) 5(-1.905,6.8) 6(0.635,6.8) 7(3.175,6.8)
  rect 1.295x1.803 smd: 8(-5.85,2.7) 9(5.85,2.7) 10(-5.85,-6.1) 11(5.85,-6.1)
SOIC8-6-1_27-24AA02
  rect 0.61x1.549 smd: 1(-1.905,-2.7) 2(-0.635,-2.7) 3(0.635,-2.7) 4(1.905,-2.7) 5(1.905,2.7) 6(0.635,2.7) 7(-0.635,2.7) 8(-1.905,2.7)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON8-8X6-1_27-9P
  rect 0.508x1.397 smd: 1(-1.905,-3.9) 2(-0.635,-3.9) 3(0.635,-3.9) 4(1.905,-3.9) 5(1.905,3.9) 6(0.635,3.9) 7(-0.635,3.9) 8(-1.905,3.9)
  rect 4.293x3.404 smd: 9(0,0)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-G517
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-2_8-95-6P-G2822C
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT353-2_1-65-5P
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
SOT353-2_1-65-5P-1_1H
  rect 1.194x0.305 smd: 1(1.05,-0.65) 2(1.05,0) 3(1.05,0.65) 4(-1.05,0.65) 5(-1.05,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT363-2_1-65-6P-74LVC1G98GW
  rect 1.194x0.305 smd: 1(1.05,-0.65) 2(1.05,0) 3(1.05,0.65) 4(-1.05,0.65) 5(-1.05,0) 6(-1.05,-0.65)
SOT363-2_1-65-6P-DMC2004DWK-7
  rect 0.61x0.432 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SOT363-2_1-65-6P-PJ4N3KDW
  rect 0.508x0.457 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SOT363-2_1-65-6P-PJT7828
  rect 0.66x0.457 smd: 1(0.92,-0.65) 2(0.92,0) 3(0.92,0.65) 4(-0.92,0.65) 5(-0.92,0) 6(-0.92,-0.65)
SOT963-1-35-6P-SMT
  rect 0.406x0.152 smd: 1(0.552,-0.35) 2(0.552,0) 3(0.552,0.35) 4(-0.552,0.35) 5(-0.552,0) 6(-0.552,-0.35)
SPAD-RE138X98
  rect 3.505x2.489 smd: 1(0,0)
SPAD-X8Q-X8Q-1
  custom 1.672x1.672 smd: 1(0,0)
SPAD-X8Q-X8Q-2
  custom 1.775x1.775 smd: 1(0,0)
SPAD-X8Q-X8Q-3
  custom 1.775x1.775 smd: 1(0,0)
SPAD-X8Q-X8Q-4
  custom 1.505x1.505 smd: 1(0,0)
SPAD-X8Q-X8Q-5
  custom 1.52x1.52 smd: 1(0,0)
SW-SOX-154HNT-2P
  rect 0.61x1.499 smd: 1(-1.6,0) 2(1.6,0)
TP2050
  round 0.508 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TQFN32-3X6-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-2,-1.5) 2(-1.6,-1.5) 3(-1.2,-1.5) 4(-0.8,-1.5) 5(-0.4,-1.5) 6(0,-1.5) 7(0.4,-1.5) 8(0.8,-1.5) 9(1.2,-1.5) 10(1.6,-1.5) 11(2,-1.5) 12(3,-0.8) 13(3,-0.4) 14(3,0) 15(3,0.4) 16(3,0.8) 17(2,1.5) 18(1.6,1.5) 19(1.2,1.5) 20(0.8,1.5) 21(0.4,1.5) 22(0,1.5) 23(-0.4,1.5) 24(-0.8,1.5) 25(-1.2,1.5) 26(-1.6,1.5) 27(-2,1.5) 28(-3,0.8) 29(-3,0.4) 30(-3,0) 31(-3,-0.4) 32(-3,-0.8)
  rect 4.597x1.803 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.5,-0.5) 35(-0.5,-0.5) 36(0.5,-0.5) 37(1.5,-0.5) 38(1.5,0.5) 39(0.5,0.5) 40(-0.5,0.5) 41(-1.5,0.5)
TSOT23-2_8-95-5P-G916-475TOUF
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
UB3-TCRB5-9U6391-9P
  round 1.397 hole 0.813: 1(3.5,9.2) 2(1,9.2) 3(-1,9.2) 4(-3.5,9.2) 5(-4,7.7) 6(-2,7.7) 7(0,7.7) 8(2,7.7) 9(4,7.7)
  oval 1.295x2.489 hole 0.711x1.905: 10(6.4,8.45) 11(-6.4,8.45)
  oval 1.295x2.21 hole 0.711x1.6: 12(-7.85,0) 13(7.85,0)
UB31-UT12123-1090H-7H-24P
  custom 0.413x0.413 hole 0.61x1.778: 1(-4.32,2.64) 2(4.32,2.64)
  oval 1.245x0.457 hole 1.245x0.457: 3(-3.995,1.977) 4(3.995,1.977)
  oval 0.838x2.108 hole 0.559x1.803: 5(-5.82,0) 6(5.82,0) 7(-6.42,-2.9) 8(6.42,-2.9)
  rect 0.254x0.889 smd: A1(-2.625,3.28) A2(-2.125,3.28) A3(-1.625,3.28) A4(-1.125,3.28) A5(-0.625,3.28) A6(-0.125,3.28) A7(0.375,3.28) A8(0.875,3.28) A9(1.375,3.28) A10(1.875,3.28) A11(2.375,3.28) A12(2.875,3.28)
  rect 0.254x0.787 smd: B1(2.625,1.68) B2(2.125,1.68) B3(1.625,1.68) B4(1.125,1.68) B5(0.625,1.68) B6(0.125,1.68) B7(-0.375,1.68) B8(-0.875,1.68) B9(-1.375,1.68) B10(-1.875,1.68) B11(-2.375,1.68) B12(-2.875,1.68)
unnamed
  rect 0.203x0.102 smd: 1(0,0)
WSON8-6X5-1_27-9P-W25Q64FWZPIG
  rect 0.508x1.499 smd: 1(-1.905,-2.85) 2(-0.635,-2.85) 3(0.635,-2.85) 4(1.905,-2.85) 5(1.905,2.85) 6(0.635,2.85) 7(-0.635,2.85) 8(-1.905,2.85)
  rect 4.293x3.404 smd: 9(0,0)
WTB-50450-0107C-001-10P-L-SMT
  rect 0.508x0.991 smd: 1(-3.6,1.45) 2(-2.8,1.45) 3(-2,1.45) 4(-1.2,1.45) 5(-0.4,1.45) 6(0.4,1.45) 7(1.2,1.45) 8(2,1.45) 9(2.8,1.45) 10(3.6,1.45)
  rect 1.194x1.295 smd: 11(-4.9,0) 12(4.9,0)
WTB-51362-0100T-V01-10P-L
  rect 0.787x1.905 smd: 1(-5.625,4.925) 2(-4.375,4.925) 3(-3.125,4.925) 4(-1.875,4.925) 5(-0.625,4.925) 6(0.625,4.925) 7(1.875,4.925) 8(3.125,4.925) 9(4.375,4.925) 10(5.625,4.925)
  rect 1.295x3.353 smd: 11(-8.475,0) 12(8.475,0)
WTB-51378-0040N-V01-4P-L
  rect 0.787x2.007 smd: 1(-1.875,4.05) 2(-0.625,4.05) 3(0.625,4.05) 4(1.875,4.05)
  rect 2.007x2.489 smd: 5(-4.075,0) 6(4.075,0)
XTL-2X1_6-1_35X1_05-0_7H
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1V8_AON: C6621.1 C6628.1 C6630.1 C6673.1 C6676.1 C6678.1 C6680.2 C6682.2 C6698.1 C6699.1 C6714.2 C6818.1 C6900.2 PR9808.2 PR9828.1 PR10501.1 PR10515.1 R6602.2 R6800.2 R6804.2 R6809.2 R6826.1 R6839.1 R6841.1 R6902.2 R6903.2 R6904.2 R6905.2 R6906.2 R6907.2 R6908.2 R6909.2 R6910.2 R6923.1 R6924.2 R6926.2 R6927.1 R6928.2 R6929.2 R6944.2 R6950.1 R6951.2 R6952.2 R6953.2 R6956.2 R6957.2 R6958.2 R6965.2 U6600.G10 U6600.G12 U6601.5(VCC) U6701.5 U6801.8 U6902.5(VCC) U7601.1 U7601.2 U7601.9
1V8_AON_EN: C7747.2 PD10500.1(CATHODE) PR10516.2 U6901.4(Y)
1V8_MAIN: C6620.2 C6624.2 C6632.2 C6633.2 C6636.2 C6646.1 C6648.1 C6651.1 C6654.1 C6697.1 L6600.1 L6700.1 L6701.1 PR10514.2 PR10519.1 Q6900.2 Q6900.5 R6615.2 R6807.2 R7727.1 U6600.AA8 U6600.AA9 U6600.AA10 U6600.AA12 U6600.AA13 U6600.AA16 U6600.AA18 U6600.AA19 U6600.AA20 U6600.AA21 U6600.AB22 U6600.AC23 U6600.AD24 U6600.AE25 U6600.AF26 U6600.AF27
1V8_MAIN_EN: D6901.3(COMMON ANODE) PD9800.1(CATHODE) PD9801.2 PQ10501.2 PR9817.1 PR9833.1 PR10508.2 PR10517.1 R6958.1 R6960.1 U6600.F9
1V8A_PG: PR8107.2 PR9114.1 PR9121.1 PR9206.2
2V5_PG: PR8716.2 R3302.2 R3303.2 R3304.2
3V3_VCCST_OVERRIDE: PD9600.1 PD9603.2 PQ10603.3 PR10618.1 PU10602.1 PU10605.2
3V3DS_PG_R: PC8109.1 PR8125.1 PR8126.1 PU8102.2
3V_5V_PG: PR8125.2 PR8600.1 PR8617.1
+1.2V_CR: C7610.1 C7613.2 C7614.1 U7600.10 U7600.14
+1.2VSUS: C707.1 C712.1 C716.1 C719.1 C722.1 C728.1 C732.1 C737.1 C739.1 C741.1 C743.1 C746.1 C749.1 C752.1 C755.1 C758.1 C760.1 C762.1 C764.1 C766.1 C768.1 C1700.2 C1701.1 C1702.2 C1703.1 C1704.1 C1705.1 C1706.1 C1707.1 C1708.1 C1709.1 C1710.1 C1711.1 C1712.1 C1713.1 C1714.1 C1715.1 C1716.1 C1717.1 C1718.1 C1719.1 C1720.1 C1721.1 C1722.1 C1723.1 C1724.1 C1725.1 C1726.1 C1727.1 C1909.2 C2801.1 C2802.1 C2803.1 C2804.1 C2805.1 C2806.1 C2807.1 C2808.1 C2809.1 C2810.1 C2811.1 C2812.1 C2813.1 C2814.1 C2815.1 C2816.1 C2901.1 C2903.1 C2905.1 C2907.1 C2909.1 C2911.1 C2912.1 C2914.1 C2916.1 C2917.1 C2918.1 C2919.1 C2921.1 C2923.1 C2924.1 C2925.1 C7223.2 C7224.2 C7225.2 C7226.2 EC2901.1 EC2903.1 JDIM2800.12 JDIM2800.33 JDIM2800.54 JDIM2800.75 JDIM2800.96 JDIM2800.111 JDIM2800.112 JDIM2800.117 JDIM2800.118 JDIM2800.123 JDIM2800.124 JDIM2800.129 JDIM2800.130 JDIM2800.135 JDIM2800.136 JDIM2800.141 JDIM2800.142 JDIM2800.147 JDIM2800.148 JDIM2800.153 JDIM2800.154 JDIM2800.159 JDIM2800.160 JDIM2800.163 JDIM2800.178 JDIM2800.199 JDIM2800.220 JDIM2800.241 JDIM2900.12 JDIM2900.33 JDIM2900.54 JDIM2900.75 JDIM2900.96 JDIM2900.111 JDIM2900.112 JDIM2900.117 JDIM2900.118 JDIM2900.123 JDIM2900.124 JDIM2900.129 JDIM2900.130 JDIM2900.135 JDIM2900.136 JDIM2900.141 JDIM2900.142 JDIM2900.147 JDIM2900.148 JDIM2900.153 JDIM2900.154 JDIM2900.159 JDIM2900.160 JDIM2900.163 JDIM2900.178 JDIM2900.199 JDIM2900.220 JDIM2900.241 PR8706.2 R509.1 R2801.1 R2802.1 R2803.1 R2804.1 R2805.1 R2806.1 R2807.1 R2808.1 R2809.1 R2810.1 R2811.2 R2816.1 R2901.1 R2908.1 R2909.1 R2910.1 R2911.1 R2912.1 R2913.1 R2914.1 R2915.1 R2916.2 R2918.1 R2921.1 U400.AA39 U400.AB40 U400.AC39 U400.AD40 U400.AD51 U400.AD52 U400.AE39 U400.AF40 U400.AG39 U400.AH40 U400.AJ39 U400.AK40 U400.AK51 U400.AK52 U400.AL39 U400.AM40 U400.AN39 U400.AP40 U400.AR39 U400.AT52 U400.AU40 U400.AW40 U400.AW51 U400.AW52 U400.BD51 U400.BD52 U400.BK51 U400.BK52 U400.BV51 U400.BV52 U400.CA40 U400.CC40 U400.CC49 U400.CC50 U400.CE40 U400.CG40 U400.CH39 U400.CJ40 U400.CL40 U400.CN40 U400.CP47 U400.CR40 U400.D50 U400.E51 U400.F49 U400.T51 U400.T52 U1903.D1 U1903.D2
+1.2VSUS_S: C1909.1 PC8715.1 PC8716.1 PC8717.1 PC8718.1 PC8719.1 PL8701.2 PR8706.1 PR8709.1 PR8711.2 U1903.D3
+1.05V_GFX_S2: PC10501.1 PC10502.1 PC10503.1 PL10500.2 PR10502.1 PR10505.2
+1.8V: C1804.2 C3602.2 L3600.1 PR8103.2 PR9509.2 R1124.2 U1801.D1 U1801.D2 U3600.29 U6901.5
+1.8V_AVDD: C3608.1 L3600.2 U3600.33
+1.8V_DEEP_SUS: C1609.2 C1610.2 C1918.2 C7731.2 F4200.2 F7603.2 PC9522.1 PC9523.1 PR8104.1 PR9205.2 PR9510.1 PR10512.2 PU9502.1 PU9502.6 R820.2 R1134.1 R1136.1 R1138.1 R1141.1 R1143.1 R1222.2 R1227.1 R1231.2 R1241.1 R1400.1 R1401.1 R1516.1 R1517.1 R1518.1 R1519.1 R1520.2 R1601.2 R1609.2 R1611.1 R1612.1 R4141.2 R4144.1 R4725.1 R7711.1 U400.CV39 U400.CY18 U400.CY20 U400.CY24 U400.CY26 U400.DA18 U400.DA20 U400.DA22 U400.DA24 U400.DA26 U400.DC18 U400.DC20 U400.DC22 U400.DC24 U400.DC26 U400.DD20 U400.DD22 U400.DV22 U1907.D1 U1907.D2
+1.8V_DEEP_SUS_F: CON7602.29 F7603.1
+1.8V_DEEP_SUS_R: C1918.1 PC9526.2 PC9529.2 PR9510.2 PU9502.14 U1907.D3
+1.8V_R: C1804.1 PC9527.1 PC9528.1 PR9509.1 PU9502.9 U1801.D3
+1.8VPCU_R: PC9211.1 PC9212.1 PC9213.1 PC9214.1 PC9216.1 PL9200.2 PR9205.1 PR9208.2
+1.8VPCU_TUNE: C4215.2 C4216.2 C4217.2 CON4203.1 F4200.1
+2.5VSUS: C1819.2 C2824.1 C2825.1 C2920.1 C2922.1 JDIM2800.257 JDIM2800.259 JDIM2900.257 JDIM2900.259 PR8717.1 U1809.D1 U1809.D2
+2.5VSUS_S: C1819.1 PC8722.1 PC8723.1 PC8724.1 PL8702.2 PR8717.2 PR8721.1 U1809.D3
+3.3V_8270C: PC8618.1 PU8601.10
+3V: C1905.2 C2004.1 C2013.1 C2826.1 C2827.1 C2913.1 C2915.1 C3420.2 C3528.1 C3529.1 C3530.1 C3531.1 C3618.2 C3619.1 C3620.2 C3621.1 C5201.1 C5406.1 C5412.1 C7237.1 F3401.2 F5202.1 F7606.2 JDIM2800.255 JDIM2900.255 PC9906.2 PC9914.2 PQ9801.1(S) PR8101.2 PR8117.2 PR9501.2 PR9800.1 PR9803.1 PR9819.1 PR9829.1 PR9830.2 PU9900.20 PU9901.20 Q1100.2 Q1100.5 Q4104.2 Q5404.2 Q5404.5 R625.2 R626.2 R627.2 R804.2 R805.2 R806.2 R807.2 R810.2 R1114.2 R1116.2 R1119.1 R1120.2 R1145.1 R1146.1 R1200.1 R1202.2 R1204.2 R1206.2 R1212.2 R1220.1 R1402.2 R1403.2 R1404.2 R1406.2 R1407.2 R1408.2 R1523.1 R1524.1 R1525.1 R1526.1 R2812.2 R2813.2 R2814.2 R2902.1 R2903.1 R2904.1 R3420.1 R3421.1 R3425.1 R3504.2 R3506.2 R3507.2 R3516.2 R3517.2 R3608.1 R3611.2 R3619.1 R3622.2 R4300.2 R4308.2 R4718.1 R4719.1 R5127.1 R5215.1 R5216.2 R5218.2 R5401.1 R5403.1 R5407.2 R5417.1 R5418.1 R5925.1 R6943.2 R6946.1 R6947.2 R7606.1 R7722.1 R7723.1 U1900.D1 U1900.D2 U2002.D3 U2005.D3 U3400.4 U3400.5 U3402.4 U3402.5 U3404.4 U3404.5 U3501.11 U3501.30(VDDIO) U3600.1 U3600.8 U5400.1(VCC) U5403.1(VCC)
+3V_1.8V_DEEP_SUS: R1609.1 R1610.1 U400.DA28
+3V_ALW: CON7602.16 PC8105.1 PC8108.2 PC8605.1 PR8106.1 PR8121.1 PR8126.2 PR8720.2 PU8101.2 PU8102.5(VCC) PU8602.6 R1415.1 R3300.1 R4825.1 R7500.1 R7503.2 R7507.2 R7508.1 U7500.1(VDD)
+3V_CAM: C2019.2 C3425.1 C3426.1 CON3400.35 R3412.2 R3417.1 U2008.D1 U2008.D2
+3V_CAM_R: C2019.1 F3401.1 R3412.1 U2008.D3 U3402.1(OUT)
+3V_CLICK: C5207.1 C5209.1 C5210.1 CON5202.8 F5203.1 R5212.1
+3V_CLICK+: C1903.1 R5215.2 U1902.D3
+3V_CLICK-: C1903.2 R5214.2 U1902.D1 U1902.D2
+3V_CLICK_R: F5203.2 R5214.1 R5216.1
+3V_CM_PWR: C1800.1 C1801.1 C1802.1 C1803.1 C1808.1 C1809.1 C1810.1 C1815.1 C1816.1 C1900.1 C1902.1 C1906.1 C1907.1 C1908.1 C1912.1 C1914.1 C1915.1 C1916.1 C2000.1 C2001.1 C2002.1 C2008.1 C2009.1 C2010.1 C2011.1 C2016.1 C2018.1 R1900.1 U1800.B1(VS) U1800.B3 U1801.B1(VS) U1802.B1(VS) U1803.B1(VS) U1803.B3 U1803.C3 U1804.B1(VS) U1804.C3 U1805.B1(VS) U1805.C3 U1806.B1(VS) U1806.C3 U1807.B1(VS) U1809.B1(VS) U1809.B3 U1900.B1(VS) U1900.B3 U1902.B1(VS) U1903.B1(VS) U1904.B1(VS) U1904.B3 U1905.B1(VS) U1906.B1(VS) U1907.B1(VS) U1908.B1(VS) U1908.C3 U1909.B1(VS) U2000.B1(VS) U2000.B3 U2001.B1(VS) U2002.B1(VS) U2004.B1(VS) U2004.B3 U2004.C3 U2005.B1(VS) U2006.B1(VS) U2006.C3 U2007.B1(VS) U2008.B1(VS) U2008.C3 U2010.B1(VS)
+3V_CR: C2013.2 C7600.2 C7601.1 C7611.2 C7612.1 Q7600.2 R1411.2 R7600.1 R7601.2 R7602.2 R7606.2 R7614.2 U2005.D1 U2005.D2 U7600.11 U7600.27
+3V_DEEP_SUS: C1501.2 C1910.1 C2015.2 C4200.1 CON7700.1 PR8102.1 PR8118.1 PR8219.1 PR9503.1 R406.1 R407.1 R504.1 R506.1 R628.2 R811.2 R812.2 R813.2 R814.2 R815.1 R816.1 R817.2 R1005.2 R1125.2 R1126.2 R1128.2 R1129.2 R1130.2 R1131.2 R1132.1 R1207.1 R1208.1 R1209.1 R1210.1 R1214.1 R1221.2 R1223.1 R1226.1 R1230.2 R1232.1 R1234.1 R1236.1 R1245.1 R1247.1 R1306.1 R1308.1 R1414.2 R1507.2 R1510.1 R1511.1 R1512.1 R1514.1 R1515.2 R1521.2 R1535.2 R1560.1 R1613.2 R1616.2 R4133.1 R4134.1 R4748.1 R5622.1 R5636.1 R5929.2 U1501.5(VCC) U1502.5(VCC) U1904.D3 U2007.D1 U2007.D2 U4102.5(VCC) U4200.5
+3V_DEEP_SUS_PRIME: C1638.2 C1641.2 C1655.1 C1656.1 R1610.2 R1615.2 R1616.1 R1617.1 U400.CY31 U400.CY33 U400.DA35 U400.DC28 U400.DC30 U400.DD30 U1600.1(OUT)
+3V_DEEP_SUS_PRIME_DIS: R1615.1 U1600.4
+3V_DEEP_SUS_R: C2015.1 PC9508.1 PC9511.1 PR9503.2 PU9500.9 U2007.D3
+3V_ECACC: C4720.1 C4721.2 R4740.1 U4700.D1
+3V_F: CON7602.8 CON7602.9 F7606.1
+3V_FR: C4400.1 CON4402.2 CON4402.3 CON4402.15 CON5200.1 CON5200.2 CON7704.1 F5202.2 R4415.2
+3V_R: C1905.1 PC9509.1 PC9510.1 PR9501.1 PU9501.9 U1900.D3
+3V_RTC: C1401.1 C4701.1 C4702.1 D1400.3(COMMON ANODE) R1237.1 R1416.1 R1418.1 R1604.2 U4700.L4
+3V_RTC_0: C4706.1 CON4700.1 PC8411.1 PD8402.1 PR8420.2 R1419.2
+3V_RTC_1: D1400.1 Q1400.2 R1419.1 R1420.1
+3V_RTC_2: D1400.2 R1415.2
+3V_SSD: C2004.2 C4300.2 C4301.2 C4302.2 C4303.2 C4313.2 C4314.2 C7234.2 C7239.1 CON4300.2 CON4300.4 CON4300.14 CON4300.16 CON4300.18 CON4300.70 CON4300.72 CON4300.74 EC4301.2 R4300.1 R4301.2 U2002.D1 U2002.D2
+3V_THR: C5410.1 R5405.1 U5401.5(VCC)
+3V_VCC: C4715.1 C4716.2 C4717.2 C4718.2 C4719.2 PQ8004.2 PR8011.1 R4736.1 U4700.A7 U4700.B1 U4700.D12 U4700.M8
+3V_VCC_CR: C7615.2 C7616.1 CON7600.4 U7600.12
+3V_WLAN_C: C2012.1 R4101.1 U2004.D3 U4100.3
+3V_WLAN_P: C2012.2 C4100.1 C4101.1 C4103.2 C4110.2 C4111.1 CON4100.2 CON4100.4 CON4100.72 CON4100.74 Q4112.2 R4101.2 R4113.1 R4118.1 R4121.1 R4132.1 R4140.2 U2004.D1 U2004.D2
+3V_WWAN_P: C1805.2 C4208.1 C4209.1 C4210.2 C4211.1 C4212.2 C4213.1 C4214.2 CON4202.2 CON4202.4 CON4202.70 CON4202.72 CON4202.74 R4200.1 R4201.1 R4207.1 U1800.D1 U1800.D2
+3VCM_PWR_B: CON1900.1 CON1900.10 R1900.2
+3VLANVCC: C1818.2 F7605.2 PR9500.1 U1807.D1 U1807.D2
+3VLANVCC_F: CON7602.30 CON7602.31 CON7602.32 CON7602.33 F7605.1
+3VLANVCC_R: C1818.1 PC9504.2 PC9505.1 PR9500.2 PU9501.14 U1807.D3
+3VLCD_CON: C1806.2 C3403.1 C3404.1 C3405.1 C3406.1 C3407.2 C3408.2 CON3400.23 CON3400.24 L3400.2 U1802.D1 U1802.D2
+3VPCU: C1654.1 C1805.1 C1812.2 C1911.1 C4105.2 C4714.1 C5938.1 C6103.2 C6104.1 C6109.1 C6683.1 C7208.2 C7209.2 C7219.2 CON7700.3 CON7700.7 CON7702.22 F5002.1 L4700.2 LED7600.3 PC8225.2 PC8404.2 PC9500.1 PC9501.1 PC9503.1 PC9601.1 PC9605.1 PC10500.1 PC10638.1 PC10639.1 PC10640.1 PC10641.1 PC10642.1 PQ8008.1(EMITTER) PQ8011.1(EMITTER) PQ8400.2 PQ8404.1(EMITTER) PQ8405.1(EMITTER) PR8124.1 PR8127.2 PR8230.2 PR8235.2 PR8238.2 PR8239.2 PR8412.2 PR8601.2 PR8719.1 PR8824.2 PR9100.2 PR9101.2 PR9104.1 PR9108.2 PR9214.2 PR9606.2 PR10617.2 PR10618.2 PU8201.4 PU9500.6 PU9501.1 PU9501.6 PU9600.5 PU9601.5 PU10500.4(VIN) PU10602.5 PU10603.5 PU10604.5 PU10605.5 PU10606.5 Q7500.2 Q7502.2 R819.1 R1004.2 R1531.1 R1532.2 R1534.1 R1606.2 R3303.1 R3407.2 R3431.1 R3605.1 R4102.2 R4200.2 R4202.1 R4203.1 R4721.1 R4722.1 R4723.1 R4724.1 R4726.1 R4727.1 R4728.1 R4729.1 R4733.2 R4734.2 R4735.2 R4736.2 R4737.2 R4738.2 R4739.2 R4749.1 R4752.2 R4800.2 R4802.2 R4803.2 R4804.2 R4805.2 R4806.2 R4807.2 R4816.1 R4817.1 R4820.1 R4823.2 R5015.5 R5015.10 R5217.1 R5405.2 R5406.1 R5628.2 R5901.2 R5948.2 R6101.2 R6103.2 R6107.2 R6108.2 R6109.2 R6114.1 R6124.2 R7726.1 U1600.5 U1800.D3 U1804.D1 U1804.D2 U1905.D3 U3405.5(VCC) U4100.1(S) U4400.5(VCC) U4701.5(VCC) U5904.A2 U6101.10(VDD) U7601.3(VBIAS)
+3VPCU_KB: C5001.1 CON5000.4 CON5000.6 CON5000.13 F5002.2
+3VPCU_PD: C6100.2 C6101.2 C6102.1 CON7702.30 R6100.1 R6106.1 R6110.1 U6100.10 U6100.11
+3VPCU_R: C1812.1 PC8611.1 PC8612.1 PC8613.1 PC8614.1 PC8615.1 PL8601.2 PR8601.1 PR8607.2 U1804.D3
+5V: C1811.1 C1913.2 C1919.1 C3503.1 C3609.2 C3610.1 C4401.1 C4402.1 F3400.2 F3500.1 F4400.1 F4401.2 L3601.2 PR8100.2 PR9502.1 Q3406.2 Q5005.1(S) Q6100.2 R1530.2 R3604.2 R5026.2 R5400.1 U1805.D3 U1906.D1 U1906.D2 U1909.D3 U3500.3
+5V_ALW: PC8627.2 PU8601.9
+5V_AVDD_R: C1811.2 C3606.1 C3607.2 R3604.1 U1805.D1 U1805.D2 U3600.20
+5V_CAM: C7233.2 CON3400.27 CON3400.28 F3400.1
+5V_FAN: C1919.2 C5400.1 C5401.2 CON5400.3 R5400.2 U1909.D1 U1909.D2
+5V_HDMIC: C3500.1 C3501.1 C3502.1 CON3501.18 D3500.3(COMMON ANODE) F3500.2 U3500.1(OUT)
+5V_LED_KBLIGHT: C5045.2 F5003.1 Q5005.3
+5V_LED_KBLIGHT_C: CON5002.1 CON5002.2 CON5002.3 F5003.2
+5V_R: C1913.1 PC9506.2 PC9507.2 PR9502.2 PU9500.14 U1906.D3
+5V_USBP1: C6202.1 C6203.1 C6205.2 C6212.1 CON6202.1(VBUS) U6202.1(VOUT) VC6201.2
+5V_USBP4: C6200.1 C6201.1 C6204.2 C6216.2 C6217.1 CON6201.1(VBUS) U6203.12 VC6200.2
+5VPCU: C1813.2 C6112.2 C6113.2 C6213.1 C6214.2 C6215.2 C7210.2 C7617.1 C7618.2 C7619.2 CON7602.1 CON7602.2 CON7602.3 CON7602.4 CON7602.5 CON7602.6 CON7602.7 PC8103.2 PC8638.1 PC8714.2 PC8910.2 PC8929.2 PC9502.1 PC9512.1 PC9513.1 PC9534.1 PC10512.1 PC10633.2 PR8610.2 PR8712.2 PR8805.1 PR8826.2 PR8845.2 PR8846.2 PR8900.1 PR8907.1 PR9119.1 PR9826.2 PR10201.1 PR10205.1 PR10212.1 PR10507.1 PR10518.1 PU8100.8 PU8700.12 PU8900.21 PU8901.21 PU9500.1 PU9500.4(VBIAS) PU9501.4(VBIAS) PU9502.4(VBIAS) PU10501.4(VBIAS) PU10601.4(VBIAS) R4822.1 R5005.1 R6104.2 R6128.1 R6203.2 U1806.D1 U1806.D2 U6100.45 U6202.5 U6203.1 VC6202.1
+5VPCU_R: C1813.1 PC8630.1 PC8631.1 PC8632.1 PC8633.1 PC8634.2 PC10624.1 PL8604.2 PR8610.1 PR8615.1 U1806.D3
+V3.3DX_RT_TCP0: C2014.1 C5939.2 L5901.1 U2006.D3 U5904.A1(VOUT#1)
+VCC0P9_LC_TCP0: C5932.2 U5900.J3
+VCC0P9_LVR_TCP0: C5933.2 C5934.2 U5900.L6 U5900.M6
+VCC0V9_SVR_TCP0: C5926.2 C5927.2 C5928.2 C5929.2 C5930.2 C5931.2 C5935.2 C5936.1 L5900.2 U5900.E3 U5900.E9 U5900.F6 U5900.G3 U5900.G6 U5900.G9
+VCC0V9_SVR_TCP0_PHASE: L5900.1 U5900.L1 U5900.M1
+VCC1.05_MIPI60: C7700.1 CON7703.43 CON7703.44(VCC_OBS_CD) R7700.2 R7701.1
+VCC1.05_OUT_FET: PR10611.2 PR10615.2 R1242.2 R7700.1 R7710.1 U400.BR3 U400.BR4 U400.BT5
+VCC1.05_OUT_PCH: U400.DA31 U400.DC31 U400.DC33
+VCC3P3_ANA_TCP0: C5918.2 U5900.L2
+VCC3P3_LC_TCP0: C5922.1 R5937.2 R5939.2 R5941.2 R5943.2 U5900.E5
+VCC3V3_SX_TCP0: C2014.2 C5919.1 C5920.1 C5921.1 L5901.2 R5933.2 R5934.2 R5936.1 U2006.D1 U2006.D2 U5900.E6 U5900.J5 U5900.M4 U5900.M5
+VCC3V3A_SX_TCP0: C5923.2 C5924.2 C5925.2 R5936.2 U5900.J7
+VCC_TS: C1917.2 C3400.1 C3423.1 CON3400.40 R3400.1 R3401.1 R3403.1 R3417.2 R3419.1 U1908.D1 U1908.D2
+VCC_TS_R: C1917.1 C3421.1 R3419.2 U1908.D3 U3404.1(OUT)
+VCCDPHY_1P24: C1647.1 U400.DV28
+VCCDSW_1P05: C1648.2 U400.DD38
+VCCIN: C700.1 C701.1 C702.1 C703.1 C704.1 C705.1 C706.1 C708.1 C709.1 C710.1 C711.1 C714.1 C715.1 C718.1 C720.1 C721.1 C723.1 C724.1 C725.1 C726.1 C727.1 C729.1 C730.1 C731.1 C735.1 C736.1 C738.1 C740.1 C742.1 C744.1 C745.1 C747.1 C748.1 C750.1 C751.1 C753.1 C754.1 C756.1 C757.1 C759.1 C761.1 C763.1 C765.1 C767.1 C769.1 C770.1 C7238.2 C7736.2 C7737.2 C7738.1 C7739.2 C7740.1 C7741.2 C7742.2 C7757.2 C7758.2 C7759.2 C7767.1 PC8917.1 PC8918.1 PC8937.1 PL8902.2 PL8903.2 PR8832.1 PR8906.2 PR8913.2 U400.A24 U400.A26 U400.A29 U400.A30 U400.A33 U400.A35 U400.AY39 U400.B24 U400.B26 U400.B29 U400.B30 U400.B33 U400.B35 U400.BA10 U400.BA40 U400.BB9 U400.BB39 U400.BC10 U400.BC40 U400.BD9 U400.BD39 U400.BE10 U400.BE40 U400.BF9 U400.BG10 U400.BG40 U400.BH9 U400.BH12 U400.BH39 U400.BJ10 U400.BJ40 U400.BK39 U400.BL10 U400.BL40 U400.BM39 U400.BN40 U400.BP12 U400.BP39 U400.BR10 U400.BR40 U400.BT12 U400.BT39 U400.BU10 U400.BU40 U400.BV12 U400.BY12 U400.CA10 U400.CB12 U400.D24 U400.D26 U400.D29 U400.D30 U400.D33 U400.D35 U400.E24 U400.E26 U400.E27 U400.E29 U400.E30 U400.E32 U400.E33 U400.G2 U400.G24 U400.G26 U400.G30 U400.G32 U400.H24 U400.H26 U400.H30 U400.H32 U400.J1 U400.J2 U400.K1 U400.K2 U400.K24 U400.K26 U400.K30 U400.K32 U400.L24 U400.L26 U400.L30 U400.L32 U400.N24 U400.N26 U400.N30 U400.N32 U400.P24 U400.P26 U400.P28 U400.P30 U400.P32 U400.T21 U400.T23 U400.T25 U400.T27 U400.T31 U400.U23 U400.U27 U400.U29 U400.U31 U400.U33 U400.V23 U400.V25 U400.V27 U400.V29 U400.V31 U400.V33 U400.W22 U400.W24 U400.W28 U400.W32
+VCCIN_AUX: C1600.1 C1601.1 C1602.1 C1603.1 C1604.1 C1605.1 C1606.1 C1607.1 C1608.1 C1611.1 C1612.1 C1613.1 C1614.1 C1615.1 C1616.1 C1617.1 C1618.1 C1619.1 C1620.1 C1621.1 C1622.1 C1623.1 C1624.1 C1625.1 C1626.1 C1627.1 C1628.1 C1629.1 C1630.1 C1631.1 C1632.1 C1633.1 C1634.1 C1635.1 C1636.1 C1637.1 C1639.1 C1640.1 C1642.1 C1643.1 C1645.1 C7743.2 C7744.1 C7745.2 C7746.1 C7760.2 C7761.2 C7762.2 C7763.2 C7764.2 PC9110.1 PC9111.1 PC9112.1 PC9113.1 PC9114.1 PC9118.1 PL9101.2 PR9115.1 PR9120.1 U400.AB12 U400.AC10 U400.AE10 U400.AK1 U400.AK2 U400.AR10 U400.AT12 U400.AU10 U400.AW10 U400.BV1 U400.BV39 U400.BW40 U400.BY39 U400.CC1 U400.CD12 U400.CF10 U400.CG12 U400.CH10 U400.CJ1 U400.CJ12 U400.CK10 U400.CL12 U400.CM10 U400.CP1 U400.CP10 U400.CR12 U400.CT10 U400.CU12 U400.CY1
+VCCIO_OUT: R1012.1 R1013.1 R1014.1 R1015.1 R1016.1 R1017.1 R1018.1 R1019.1 R1020.1 R1021.1 R1023.1 R1024.1 R1025.1 R1026.1 R1027.1 R1029.1 R1032.1 R1033.1 R1035.1 R1036.1 U400.V15
+VCCLDOSTD_OUT_0P85: C1644.2 U400.DV46
+VCCRTC: C1649.2 C1650.2 C1651.2 R1604.1 U400.DC35
+VCCST: C733.2 C734.1 C773.1 C2006.2 C4801.2 PC8800.2 PC10631.1 PC10632.1 PR8800.1 PR8801.1 PR8802.1 PR8803.1 PU10601.9 R600.2 R604.2 R703.2 R704.2 R1561.1 U400.BT1 U400.BT2 U400.BT4 U2001.D1 U2001.D2 U4700.M6
+VCCST_S2: C2006.1 U2001.D3
+VCCSTG: PC10629.1 PC10630.1 PU10601.14 R621.2 U400.BP1 U400.BP2 U400.BP4
+VCCSTG_OUT_FUSE: C713.2 C717.1 U400.AD12 U400.AF9 U400.AF12 U400.AG10 U400.AM9 U400.AN10
+VCCSTG_OUT_LGC: R700.1 U400.M9
+VCCSTG_TERM: R602.2 R605.2 R607.2 R610.2 R614.2 R616.2 R700.2
+VIN: C2021.1 C7200.2 C7201.2 C7202.2 C7203.2 C7204.2 C7205.2 C7206.2 C7207.2 C7227.2 C7228.2 C7229.2 C7230.2 C7231.2 C7232.2 C7732.1 C7733.2 C7734.1 C7735.2 C7748.2 C7749.1 C7750.2 C7751.2 C7752.2 C7753.2 C7754.2 C7755.2 C7756.2 C7765.1 C7766.2 C7768.1 EC1.1 EC2.1 EC3.1 EC5.1 F3402.2 PC8200.2 PC8202.1 PC8206.1 PC8207.1 PC8208.1 PC8209.2 PC8607.2 PC8626.2 PC8704.1 PC8907.1 PC9108.2 PC9203.1 PC9922.2 PC9926.1 PC10209.1 PC10221.1 PD8200.1 PD8201.1 PL8600.2 PL8602.2 PL8603.2 PL8700.2 PL9201.2 PL9902.1 PL9903.1 PL10200.2 PQ8200.1 PQ8200.2 PQ8200.3(S3) PQ8202.1 PQ8203.5 PR8120.1 PR8200.2 PR8202.2 PR8914.2 PR9123.2 R4407.1 RR1.2 U2010.D3
+VIN_1.8VPCU: PC9201.1 PC9202.2 PC9204.1 PC9205.1 PC9206.1 PC9207.1 PC9208.2 PL9201.1 PU9200.1(VIN)
+VIN_3VPCU: PC8600.1 PC8601.1 PC8602.2 PC8603.2 PC8604.2 PC8606.2 PC8608.2 PL8600.1 PU8602.1
+VIN_5VPCU: PC8619.1 PC8620.2 PC8621.2 PC8622.2 PC8623.2 PC8624.2 PC8625.2 PC8637.1 PL8602.1 PL8603.1 PR8613.1 PU8601.1(VIN) RR1.1
+VIN_BLIGHT: C1807.1 C3412.1 C3413.2 C7236.2 F3402.1 R3415.1 U1803.D3
+VIN_BLIGHT_L: C1807.2 C3414.1 CON3400.1 CON3400.2 R3415.2 U1803.D1 U1803.D2
+VIN_DDR: PC8701.1 PC8702.1 PC8703.1 PC8707.1 PC8708.1 PC8709.1 PL8700.1 PQ8700.2 PR8704.2
+VIN_FBVDDQ_MEM: PC10200.1 PC10201.1 PC10202.2 PC10203.2 PC10204.2 PC10206.2 PC10208.1 PL10200.1 PR10200.1 PU10200.7 PU10200.22
+VIN_GPU: PC9900.1 PC9901.1 PC9902.1 PC9903.1 PC9904.1 PC9911.1 PC9912.1 PC9913.1 PC9915.1 PC9916.1 PC9917.1 PC9923.1 PC9924.1 PC9925.1 PL9902.2 PL9903.2 PR9900.2 PU9900.1 PU9900.14 PU9901.1 PU9901.14
+VIN_VCC_CORE: PC8900.1 PC8901.2 PC8902.1 PC8903.1 PC8904.1 PC8905.1 PC8906.1 PC8920.1 PC8921.2 PC8922.1 PC8923.1 PC8924.1 PC8925.1 PC8926.1 PC8939.1 PL8900.2 PL8901.2 PL8904.2 PL8905.2 PR8804.1 PU8900.6 PU8901.6
+VIN_VCC_CORE_R: C2021.2 PL8900.1 PL8901.1 PL8904.1 PL8905.1 PR8914.1 U2010.D1 U2010.D2
+VIN_VCCIN_AUX: PC9101.2 PC9102.1 PC9103.1 PC9104.1 PC9105.1 PC9106.1 PC9107.1 PC9122.1 PC9123.1 PL9100.2 PL9102.2 PU9100.2
+VIN_VCCIN_AUX_R: PL9100.1 PL9102.1 PR9123.1
AGND: C3603.2 C3604.1 C3605.2 C3606.2 C3607.1 C3608.2 C3613.1 C3700.1 C3701.1 C3702.1 CON3700.4 CON3700.5 EC3602.1 EC3603.1 EC3605.1 EC3606.1 EC3607.1 EC3700.1 EC3701.1 EC3702.1 EC3703.1 EC3704.1 R3603.1 R3607.1 U3600.13 U3600.19 U3600.31
DV33_18: C7607.1 U7600.18

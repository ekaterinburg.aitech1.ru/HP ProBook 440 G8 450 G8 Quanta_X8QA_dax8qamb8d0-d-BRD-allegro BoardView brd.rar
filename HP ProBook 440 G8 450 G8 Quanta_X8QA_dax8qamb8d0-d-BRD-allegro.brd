# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 69.74,25.88 69.75,25.8 69.8,25.72 70.62,24.91 70.65,24.85 70.68,24.81 70.71,24.74 70.68,24.67 70.61,24.56 70.58,24.42 70.62,24.27 70.71,24.15 70.72,24.14 70.72,21.38 70.52,21.18 70.45,21.25 70.56,21.42 70.57,21.52 70.54,21.66 70.47,21.77 70.44,21.85 70.48,21.92 70.57,22.04 70.6,22.19 70.51,22.43 70.28,22.54 70.19,22.6 70.21,22.71 70.26,22.81 70.28,22.92 70.24,23.09 70.14,23.21 70.09,23.29 70.13,23.38 70.24,23.5 70.28,23.66 70.17,23.91 69.92,24.02 69.89,24.02 69.82,24 69.14,24.69 69.14,24.78 69.2,24.88 69.31,24.86 69.39,24.78 69.43,24.76 69.61,24.76 69.61,24.75 69.74,24.62 69.92,24.58 70.28,24.93 69.92,25.29 69.75,25.25 69.62,25.13 69.61,25.1 69.55,25.1 69.5,25.15 69.5,25.79 69.56,25.86 69.59,25.88 69.62,25.91 69.64,25.95 69.65,25.99 69.74,25.99
GND on BOTTOM (solid shape): 157.55,68.1 157.63,68.08 157.66,68 157.66,67.7 157.56,67.59 157.56,65.43 158.17,64.83 158.15,64.76 158.15,64.72 158.25,64.46 158.57,64.32 158.6,64.25 158.6,63.13 158.61,63.12 158.62,63.08 158.6,63.05 158.47,62.91 158.43,62.74 158.54,62.47 158.8,62.37 158.85,62.37 158.9,62.38 158.99,62.36 159.03,62.28 159.03,61.07 158.13,60.17 158.04,60.14 157.97,60.2 157.9,60.29 157.82,60.36 157.79,60.4 157.8,60.43 157.81,60.46 157.82,60.49 157.82,60.87 157.82,60.94 157.91,60.94 158.05,60.79 158.24,60.74 158.61,61.11 158.24,61.48 158.05,61.43 157.91,61.28 157.8,61.28 157.12,61.97 157.12,62.74 157.54,63.16 157.54,63.19 157.72,63.37 158.22,63.37 158.31,63.4 158.34,63.48 158.34,64.04 158.3,64.12 158.22,64.16 157.51,64.16 157.43,64.12 157.4,64.04 157.4,63.53 157.32,63.46 157.27,63.45 157.24,63.5 157.24,63.8 156.58,64.46 156.58,65.28 157.24,65.94 157.24,66.47 157.2,66.5 157.2,66.72 157.26,66.78 157.26,67.97 157.28,68.02 157.32,68.06 157.36,68.05 157.39,68.05 157.46,68.06 157.53,68.08
GND on BOTTOM (solid shape): 53.94,78.23 54.03,78.18 54.14,78.16 54.19,78.17 54.24,78.18 54.33,78.17 54.38,78.09 54.41,77.94 54.51,77.83 54.54,77.76 54.52,77.69 54.47,77.59 54.46,77.49 54.55,77.25 54.79,77.16 54.99,77.23 55.11,77.41 55.12,77.45 55.85,77.45 55.96,77.48 56.02,77.57 56.03,77.59 56.04,77.6 56.13,77.63 56.2,77.57 56.26,77.49 56.33,77.43 56.33,77.19 56.15,77.08 56.07,76.87 56.07,76.82 56.09,76.77 56.08,76.71 56.05,76.66 55.94,76.66 55.06,75.78 55.02,75.75 54.99,75.71 54.98,75.7 54.98,75.67 54.97,75.63 54.97,74.74 54.86,74.62 54.82,74.46 54.83,74.39 54.85,74.32 54.84,74.22 54.76,74.17 53.59,74.17 53.55,74.22 53.56,74.29 53.56,74.33 53.47,74.56 53.23,74.66 53.11,74.64 53.01,74.57 52.98,74.54 52.7,74.81 53.05,75.16 53.05,75.93 53.11,76.02 53.22,76 53.89,75.33 54.17,75.33 54.49,75.46 54.63,75.78 54.54,76.06 54.3,76.22 54.29,76.23 53.72,76.8 53.72,78.07 53.9,78.25
GND on BOTTOM (solid shape): 60.44,80.27 60.43,80.2 60.5,80 60.68,79.88 60.73,79.84 60.75,79.77 60.77,79.66 60.85,79.58 60.94,79.49 60.97,79.38 60.97,79.35 60.96,79.32 60.95,79.26 60.97,79.2 60.98,79.17 60.97,79.14 60.92,79.07 60.89,78.99 60.85,78.92 60.78,78.9 60.73,78.9 60.67,78.93 60.63,78.99 60.53,79.16 60.34,79.23 60.14,79.16 60.02,78.9 59.95,78.87 59.87,78.86 59.83,78.9 59.83,78.94 59.75,79.15 59.54,79.23 59.42,79.21 59.32,79.13 59.23,79.09 59.15,79.15 59.11,79.21 59.06,79.26 58.54,79.78 58.48,79.78 58.38,79.84 58.4,79.96 58.44,80 58.91,80 59,79.92 59.11,79.89 59.13,79.88 59.25,79.76 59.25,79.75 59.35,79.56 59.54,79.49 59.74,79.57 59.86,79.84 59.94,79.87 59.94,79.87 60.17,79.97 60.27,80.2 60.27,80.23 60.26,80.27 60.28,80.31 60.32,80.33 60.38,80.33
GND on BOTTOM (solid shape): 78.27,61.86 78.27,61.82 78.27,61.76 77.44,61.76 77.3,61.76 77.15,61.69 77.08,61.54 77.07,61.44 77.07,61.39 77.07,61.34 77.08,61.24 77.15,61.09 77.3,61.03 77.44,61.02 79.32,61.02 79.89,61.59 80.54,60.94 80.54,60 80.91,59.63 80.91,59.01 80.94,58.97 80.94,58.88 80.91,58.83 80.85,58.84 80.06,59.63 80.06,59.84 80.1,59.85 80.17,59.88 80.2,59.96 80.2,60.47 80.17,60.55 80.09,60.58 79.47,60.58 79.36,60.63 79.24,60.65 79.1,60.63 78.98,60.57 78.95,60.54 78.84,60.39 78.8,60.21 78.8,59.49 78.54,59.23 78.44,59.09 78.41,58.92 78.54,58.61 78.85,58.48 79.02,58.52 79.16,58.61 79.67,59.13 79.67,59.28 79.74,59.38 79.85,59.36 81.02,58.19 81.02,58.03 81.05,57.94 81.05,57.84 80.96,57.79 79.24,57.79 79.24,57.91 79.21,57.99 79.13,58.02 78.75,58.02 78.71,58.01 78.67,57.99 78.66,57.98 78.46,57.98 78.45,58.01 78.37,58.11 78.25,58.15 77.95,58.15 77.89,58.14 77.13,58.9 76.49,58.9 76.34,59.05 76.34,61.78 76.51,61.95 78.27,61.95
GND on BOTTOM (solid shape): outline of 85 points within 152.64,77.44 155.63,82.69
GND on BOTTOM (solid shape): outline of 83 points within 196.95,78.25 201.58,85.22
GND on BOTTOM (solid shape): 139.67,58 139.73,58 139.75,58 140.13,58 140.13,57.06 140.77,56.41 143.34,56.41 143.69,56.06 144.32,56.06 144.41,55.98 144.43,55.89 144.37,55.81 144.2,55.68 144.14,55.47 144.25,55.21 144.51,55.1 144.72,55.16 144.85,55.33 144.93,55.39 145.02,55.37 145.23,55.15 145.25,55.04 145.16,54.98 143.86,54.98 143.42,54.53 141.52,54.53 140.79,55.25 140.77,55.37 140.86,55.43 141.13,55.43 141.27,55.28 141.46,55.23 141.66,55.29 141.8,55.45 141.87,55.51 141.96,55.48 142.26,55.18 142.9,55.18 143.03,55.04 143.22,54.99 143.48,55.09 143.59,55.35 143.51,55.59 143.3,55.72 143.24,55.75 143.22,55.82 143.22,55.85 143.11,56.11 142.85,56.22 142.59,56.11 142.48,55.85 142.49,55.76 142.52,55.68 142.52,55.58 142.43,55.53 142.4,55.53 141.62,56.3 140.71,56.3 139.64,57.37 139.65,57.44 139.66,57.48 139.62,57.62 139.54,57.75 139.51,57.83 139.55,57.9 139.58,57.93 139.62,57.97
GND on BOTTOM (solid shape): 206.84,16.04 206.92,16.01 206.94,15.94 206.95,15.82 206.96,15.8 206.96,15.76 206.93,15.74 206.82,15.66 206.75,15.55 206.75,15.29 206.82,15.18 206.93,15.11 207.19,15.11 207.25,15.14 207.3,15.19 207.66,15.19 207.78,15.3 207.95,15.3 208.1,15.31 208.18,15.32 208.24,15.36 208.27,15.37 208.31,15.36 208.37,15.32 208.45,15.3 208.62,15.3 208.73,15.2 208.75,15.12 208.7,15.04 208.67,15.02 208.64,14.99 208.56,14.95 208.48,14.99 208.4,15.05 208.31,15.07 208.03,15.07 207.92,15.04 207.84,14.96 207.83,14.94 206.96,14.94 206.33,14.31 206.22,14.31 206.11,14.23 206.03,14.12 206.03,13.86 206.07,13.8 206.11,13.75 206.14,13.68 206.11,13.61 206.02,13.51 205.94,13.51 205.88,13.48 205.83,13.44 205.8,13.44 205.78,13.45 205.72,13.51 205.65,13.54 205.58,13.55 205.5,13.61 205.52,13.72 205.6,13.79 205.6,14.24 205.43,14.41 205.37,14.41 205.36,14.61 205.34,14.66 205.34,14.73 205.59,14.73 205.67,14.74 205.75,14.79 206.18,15.23 206.23,15.3 206.25,15.39 206.25,15.42 206.26,15.44 206.3,15.49 206.33,15.54 206.34,15.65 206.72,16.04
GND on BOTTOM (solid shape): outline of 103 points within 31.11,57.6 37.26,62.34
GND on BOTTOM (solid shape): outline of 198 points within 197.91,42.37 216.83,47.43
GND on BOTTOM (solid shape): 31.59,45.64 31.68,45.67 31.75,45.62 31.89,45.46 32.09,45.4 32.22,45.42 32.33,45.49 32.41,45.52 32.48,45.48 32.61,45.38 32.76,45.35 32.79,45.35 33.14,44.99 33.53,44.99 33.61,44.95 33.62,44.86 33.61,44.8 33.6,44.74 33.71,44.48 33.97,44.37 34.06,44.38 34.15,44.42 34.25,44.41 34.3,44.33 34.3,41.42 34.36,41.36 34.31,41.31 34.24,41.3 34.19,41.28 34.1,41.28 34.05,41.35 34,41.46 33.91,41.55 33.87,41.63 33.91,41.71 34.02,41.84 34.06,42.01 33.69,42.38 33.32,42.01 33.36,41.84 33.48,41.71 33.52,41.63 33.48,41.55 33.36,41.42 33.32,41.25 33.43,40.99 33.69,40.88 33.77,40.89 33.84,40.91 33.93,40.91 33.98,40.85 34.11,40.65 34.34,40.57 34.42,40.58 34.51,40.61 34.6,40.61 34.65,40.52 34.65,38.5 34.3,38.15 34.3,38.06 34.26,38.01 34.21,38.03 32.74,39.49 31.82,39.49 31.78,39.49 31.69,39.51 31.66,39.59 31.66,44.44 31.51,44.59 30.89,44.59 30.89,44.66 31.1,44.87 31.1,45.15
GND on BOTTOM (solid shape): outline of 99 points within 137.41,79.04 139.75,81.15
GND on BOTTOM (solid shape): outline of 100 points within 132.63,65.86 134.42,68.49
GND on BOTTOM (solid shape): 172.74,72.77 172.74,71.04 172.74,71.04 172.85,70.93 174.5,70.93 174.56,70.88 174.56,70.46 175.5,69.51 175.73,69.51 176.4,68.85 177.31,68.85 177.39,68.8 177.4,68.71 177.55,68.27 178,68.34 178.08,68.38 178.16,68.33 178.61,68.2 178.8,68.64 178.81,68.73 178.9,68.77 179.2,68.77 179.29,68.72 179.28,68.61 179.22,68.38 179.31,68.16 179.33,68.13 179.29,68.08 179.08,67.88 179.08,67.59 179.07,67.57 176.89,67.57 176.58,67.88 176.19,68.05 175.79,67.88 175.47,67.57 175.42,67.57 174.93,68.06 174.46,68.52 171.51,68.52 171.26,68.79 170.9,68.85 170.66,69.09 170.66,69.44 170.62,69.65 170.51,69.83 170.51,70.22 170.62,70.6 170.33,70.87 170.27,70.9 170.24,70.97 170.24,71.02 170.24,71.07 170.25,71.14 170.3,71.18 170.54,71.62 170.13,71.9 170.03,72.01 170.03,72.11 170.11,72.36 170.07,72.61 170.07,72.72 170.21,73.03 170.14,73.36 170.14,73.52 170.36,73.73 171.78,73.73
GND on BOTTOM (solid shape): outline of 218 points within 35.34,34.15 48.61,46.6
GND on BOTTOM (solid shape): 64.96,86.46 65.03,86.43 65.07,86.37 65.16,86.18 65.35,86.11 65.42,86.08 65.45,86 65.45,86 65.42,85.92 65.35,85.89 65.07,85.6 65.35,85.31 65.42,85.28 65.45,85.2 65.45,85.2 65.55,84.97 65.78,84.87 65.8,84.87 65.87,84.85 65.91,84.78 65.91,84.76 65.89,84.72 65.85,84.7 65.81,84.71 65.78,84.71 65.55,84.61 65.45,84.38 65.46,84.31 65.4,84.25 65.36,84.25 65.16,84.17 65.07,83.97 65.03,83.89 64.96,83.87 64.87,83.86 64.81,83.92 64.81,83.96 64.73,84.16 64.54,84.25 64.47,84.29 64.45,84.36 64.44,84.47 64.48,84.51 64.52,84.51 64.73,84.59 64.81,84.8 64.74,85 64.48,85.12 64.45,85.19 64.45,85.21 64.48,85.28 64.54,85.31 64.81,85.6 64.54,85.89 64.48,85.92 64.45,85.99 64.45,86.01 64.48,86.08 64.54,86.11 64.72,86.19 64.81,86.37 64.85,86.43 64.92,86.46
GND on BOTTOM (solid shape): outline of 112 points within 106.09,82.22 109.79,83.66
GND on BOTTOM (solid shape): outline of 219 points within 41.09,47.89 47.55,55.12
GND on BOTTOM (solid shape): outline of 176 points within 145.03,74.75 149.04,77.69
GND on BOTTOM (solid shape): outline of 103 points within 182.66,23.65 191.22,31.54
GND on BOTTOM (solid shape): outline of 118 points within 115.81,104.02 121.17,110.61
GND on BOTTOM (solid shape): 175.26,59.73 175.26,58.48 175.37,58.36 175.37,58.2 175.32,58.11 175.21,58.11 175.11,58.16 175,58.18 174.64,57.81 175,57.44 175.11,57.46 175.21,57.5 175.32,57.51 175.37,57.42 175.37,57.36 175.81,56.92 175.81,56.15 174.57,54.92 174.46,54.9 174.4,54.99 174.4,55.3 174.94,55.84 175.01,55.82 175.05,55.82 175.42,56.19 175.05,56.56 174.96,56.55 174.87,56.51 174.79,56.5 174.73,56.54 174.6,56.66 174.42,56.71 174.16,56.6 174.05,56.34 174.1,56.16 174.22,56.03 174.25,56.01 174.25,55.95 173.83,55.53 173.83,52.76 173.92,52.66 173.88,52.61 173.85,52.6 173.78,52.61 173.73,52.66 173.62,52.79 173.47,52.86 173.44,52.87 173.44,55.44 172.96,55.91 172.93,55.98 172.97,56.06 173.01,56.1 173.04,56.15 173.1,56.19 173.17,56.19 173.24,56.16 173.32,56.16 173.69,56.53 173.32,56.89 173.29,56.89 173.25,56.89 173.17,56.91 173.13,56.99 173.13,58.77 173.15,58.79 173.27,58.81 173.32,58.71 173.32,58.67 173.95,58.41 173.69,59.04 173.66,59.04 173.56,59.09 173.56,59.2 173.56,59.34 173.58,59.36 174.11,59.36 174.68,59.92 175.06,59.92
GND on BOTTOM (solid shape): outline of 136 points within 192.71,24.82 199.82,30.15
GND on BOTTOM (solid shape): outline of 102 points within 142.38,64.73 144.43,67.29
GND on BOTTOM (solid shape): outline of 103 points within 142.06,68.21 146.82,70.87
GND on BOTTOM (solid shape): outline of 243 points within 174.35,61.11 182.47,67.15
GND on BOTTOM (solid shape): outline of 97 points within 142.39,75.13 144.56,77.74
GND on BOTTOM (solid shape): outline of 122 points within 26.71,41.77 34.27,46.78
GND on BOTTOM (solid shape): outline of 263 points within 48.54,37.92 105.79,47.5
GND on BOTTOM (solid shape): outline of 102 points within 153.11,9.74 160.68,14.93
GND on BOTTOM (solid shape): outline of 127 points within 180.94,70.3 189.89,75.15
GND on BOTTOM (solid shape): outline of 135 points within 70.09,87.02 76.29,96.21
GND on BOTTOM (solid shape): outline of 243 points within 30.08,46.95 38.14,57.86
GND on BOTTOM (solid shape): outline of 93 points within 58.83,73.1 61.24,75.37
GND on BOTTOM (solid shape): outline of 271 points within 145.5,9.72 153.37,18.5
GND on BOTTOM (solid shape): outline of 118 points within 138.41,81.74 140.76,85.26
GND on BOTTOM (solid shape): outline of 253 points within 142.68,62.56 145.52,64.86
GND on BOTTOM (solid shape): outline of 300 points within 188.9,43.29 201.39,51.37
GND on BOTTOM (solid shape): outline of 99 points within 69.44,83.75 72.03,86.96
GND on BOTTOM (solid shape): outline of 331 points within 158.92,52.37 162.38,60.55
GND on BOTTOM (solid shape): outline of 185 points within 91.53,64.03 101.2,70.07
GND on BOTTOM (solid shape): outline of 155 points within 149.22,88.97 168.22,95.91
GND on BOTTOM (solid shape): outline of 128 points within 201.26,88.56 218.33,106.82
GND on BOTTOM (solid shape): outline of 154 points within 86.91,72.68 93.33,82.53
GND on BOTTOM (solid shape): outline of 381 points within 193.35,51.84 202.72,60.84
GND on BOTTOM (solid shape): outline of 349 points within 149.64,55.5 155.51,69.53
GND on BOTTOM (solid shape): outline of 415 points within 181.8,29.65 201.53,40.49
GND on BOTTOM (solid shape): outline of 126 points within 202.59,0.51 216.83,8.42
GND on BOTTOM (solid shape): outline of 401 points within 199.74,6.46 210.06,12.25
GND on BOTTOM (solid shape): outline of 179 points within 141.26,55.45 149.16,59.92
GND on BOTTOM (solid shape): outline of 430 points within 182.57,95.39 186.98,98.12
GND on BOTTOM (solid shape): outline of 437 points within 80.34,101.29 86.68,112.21
GND on BOTTOM (solid shape): outline of 482 points within 57.82,55.05 73.19,63.03
GND on BOTTOM (solid shape): outline of 578 points within 36.77,34 123.19,55.12
GND on BOTTOM (solid shape): outline of 242 points within 55.83,86.69 67.83,93.16
GND on BOTTOM (solid shape): outline of 719 points within 145.93,77.7 159.38,88.78
GND on BOTTOM (solid shape): outline of 307 points within 41.65,70.07 50.59,77.73
GND on BOTTOM (solid shape): outline of 334 points within 138.69,76.34 145.18,80.79
GND on BOTTOM (solid shape): outline of 1050 points within 71.89,83.44 86.52,95.63
GND on BOTTOM (solid shape): outline of 966 points within 129.62,78.54 138.41,88.89
GND on BOTTOM (solid shape): outline of 1207 points within 72.25,68.19 87.48,80.3
GND on BOTTOM (solid shape): outline of 1891 points within 58.96,64.23 70.81,72.31
GND on BOTTOM (solid shape): outline of 1674 points within 134.97,68.18 144.83,76.04
GND on BOTTOM (solid shape): outline of 1705 points within 105.16,82.2 125.14,90.7
GND on BOTTOM (solid shape): outline of 2169 points within 37.14,44.52 80.01,74.04
GND on BOTTOM (solid shape): outline of 2385 points within 97.2,75.53 111.06,89.31
GND on BOTTOM (solid shape): outline of 2592 points within 188.12,49.57 214.83,86.35
GND on BOTTOM (solid shape): outline of 2637 points within 152.52,16.41 183.06,36.88
GND on BOTTOM (solid shape): outline of 3453 points within 116.01,19.49 154.11,34.27
GND on BOTTOM (solid shape): outline of 8728 points within 82.22,50.04 141.2,75.74
GND on BOTTOM (solid shape): outline of 27570 points within 0.51,0.51 218.33,119.74
GND on SGND (solid shape): outline of 4053 points within 0.51,0.51 218.33,119.74
GND on IN1 (solid shape): 105.18,12.08 105.18,10.84 105.08,10.75 103.64,10.75 103.45,10.93 103.45,12.32 103.53,12.4 104.85,12.4
GND on IN1 (solid shape): 108.68,7.19 108.68,6.77 108.58,6.66 105.02,6.66 104.77,6.91 104.77,7.2 104.8,7.22 108.65,7.22
GND on IN1 (solid shape): 196.97,38.15 196.97,36.25 196.87,36.14 193.75,36.14 193.28,36.61 193.28,38.09 193.48,38.29 196.84,38.29
GND on IN1 (solid shape): 158.01,11.59 158.01,11.23 157.95,11.17 154.38,11.17 154.25,11.3 154.25,11.61 154.31,11.66 157.94,11.66
GND on IN1 (solid shape): 126.57,75.2 126.57,75.15 126.59,75.09 126.6,75.06 124.44,72.9 123.01,72.9 122.93,72.98 122.93,73.16 125.01,75.24 126.56,75.24
GND on IN1 (solid shape): 74.51,95.73 74.52,95.73 74.92,95.33 74.92,92.34 74.34,91.76 71.6,91.76 71.41,91.95 71.41,93.7 71.45,93.73 71.45,95.69 71.65,95.9 74.34,95.9
GND on IN1 (solid shape): 189.13,74.35 189.1,74.31 189.02,74.18 189,74.04 189,73.64 187.81,72.46 187.27,72.46 188.12,73.31 188.12,73.83 188.88,74.59
GND on IN1 (solid shape): 81.96,80.3 81.96,78.85 81.73,78.61 81.16,78.61 81.1,78.55 81.05,78.54 81.02,78.59 81.02,79.94 81.45,80.37 81.89,80.37
GND on IN1 (solid shape): 188.67,40.43 188.73,40.53 188.84,40.5 189.37,39.98 189.37,38.64 189.25,38.53 188.82,38.53 188.67,38.68
GND on IN1 (solid shape): 193.87,40.97 193.87,39.61 194.51,38.97 194.53,38.86 194.44,38.8 193.65,38.8 193.12,39.33 193.12,40.97 193.22,41.07 193.77,41.07
GND on IN1 (solid shape): 129.03,77.98 129.03,77.12 128.76,76.85 126.31,76.85 126.21,76.91 126.24,77.03 126.52,77.31 128.07,77.31 128.6,77.83 128.6,77.95 128.67,78.03 128.98,78.03
GND on IN1 (solid shape): 33.7,44.09 35.34,44.09 35.69,43.75 35.66,43.67 35.62,43.62 35.28,43.96 31.05,43.96 30.67,44.34 30.65,44.45 30.74,44.51 33.28,44.51
GND on IN1 (solid shape): 15.04,13.84 15.16,13.66 15.36,13.58 15.36,12.06 15.26,11.96 14.93,11.96 14.04,12.84 14.04,13.75 14.17,13.88 15.03,13.88
GND on IN1 (solid shape): 35.01,59.53 35.04,59.42 34.94,59.35 29.85,59.35 29.54,59.66 28.58,59.66 28.53,59.69 28.54,59.75 28.6,59.8 34.74,59.8
GND on IN1 (solid shape): 53.48,69.47 53.59,69.49 53.66,69.39 53.66,68.7 52.33,67.37 51.64,67.37 51.54,67.44 51.56,67.55
GND on IN1 (solid shape): 95.29,65.35 95.4,65.37 95.46,65.28 95.46,59.4 92.65,56.59 90.44,56.59 89.89,57.14 89.89,60.66 92.49,63.26 92.51,63.28 92.62,63.4 93.33,63.4
GND on IN1 (solid shape): 146.89,87.15 146.98,87.08 146.96,86.97 146.5,86.52 142.48,86.52 142.39,86.58 142.41,86.69 142.86,87.15
GND on IN1 (solid shape): 182.11,36.25 182.11,35.78 182.05,35.68 181.94,35.7 181.16,36.48 181.16,36.98 180.02,38.13 180.01,38.19 180.05,38.22 180.15,38.22
GND on IN1 (solid shape): 135.61,89.99 135.61,89.81 135.46,89.66 135.28,89.66 135.18,89.7 135.07,89.71 135.01,89.71 134.95,89.7 134.92,89.69 133.78,90.83 133.75,90.94 133.85,91.01 134.59,91.01
GND on IN1 (solid shape): 48.98,45.83 49.05,45.8 49.08,45.73 49.09,45.67 49.11,45.61 49.1,45.51 49.01,45.47 47.93,45.47 46.18,43.71 45.59,43.71 45.46,43.84 45.46,45.65 45.64,45.83
GND on IN1 (solid shape): 52.57,81.25 52.57,81.2 51.95,81.2 51.5,80.75 51.43,80.64 51.4,80.5 51.4,80.42 51.18,80.42 50.66,79.9 50.32,79.9 50.23,79.97 50.25,80.08 51.48,81.3 52.57,81.3
GND on IN1 (solid shape): 143.61,91.12 143.62,91.06 143.63,91 143.62,90.9 143.54,90.86 139.26,90.86 139.26,90.91 139.25,90.97 139.24,91.03 139.25,91.12 139.33,91.16 143.61,91.16
GND on IN1 (solid shape): 178.8,40.99 178.8,40 180.02,38.78 180.05,38.67 179.95,38.61 176.57,38.61 176.08,39.11 176.08,43.26 175.8,43.54 175.78,43.65 175.88,43.71 176.08,43.71
GND on IN1 (solid shape): 58.34,68.61 58.4,68.7 58.52,68.68 58.53,68.67 58.53,67 58.03,65.79 57.83,65.59 57.72,65.57 57.66,65.66 57.66,67.11 58.34,67.8 58.34,68.3
GND on IN1 (solid shape): 90.83,77.38 90.92,77.31 90.9,77.2 89.39,75.69 88.82,75.69 88.73,75.75 88.74,75.85 88.77,75.9 88.79,75.96 88.8,76 89.09,76 90.47,77.38
GND on IN1 (solid shape): 106.52,111 106.52,110.42 106.55,110.3 106.62,110.2 108.04,108.78 107.82,108.78 105.86,110.73 105.82,110.76 105.78,110.77 102.52,110.77 101.78,111.51 90.33,111.51 89.34,112.5 89.32,112.61 89.41,112.67 104.85,112.67
GND on IN1 (solid shape): 126.49,96.48 126.58,96.42 126.57,96.31 125.75,96.1 124.95,95.85 124.75,95.81 124.5,95.68 123.25,95.13 122.05,94.45 122.04,94.45 120.05,94.45 119.96,94.54 119.96,95.33 121.11,96.48
GND on IN1 (solid shape): 200,70.81 200,67.49 200.57,66.92 200.57,65.57 200.54,65.54 200.5,65.52 200.4,65.62 200.05,65.62 200.02,65.6 200.01,65.59 199.85,65.47 199.76,65.29 199.75,65.25 199.5,65.25 198.91,65.84 198.91,70.87 199.06,71.02 199.79,71.02
GND on IN1 (solid shape): 77.86,73.7 77.95,73.64 77.93,73.53 75.31,70.92 73.66,70.92 73.59,70.95 73.56,71.02 73.55,71.08 73.53,71.15 73.54,71.24 73.62,71.29 73.93,71.29 75.71,73.07 77.13,73.07 77.76,73.7
GND on IN1 (solid shape): 85.61,74.69 85.72,74.71 85.78,74.62 85.78,74.19 82.57,70.98 82.57,70.22 78.57,66.22 78.37,66.22 78.24,66.09 78.05,66.09 77.8,66.34 77.8,66.37 77.79,66.37 77.79,66.6 78.09,66.9 78.1,66.9 78.97,66.9 79.06,67 79.08,67 81.24,69.16 81.24,69.18 81.56,69.49 81.56,70.39 82.95,71.78 82.95,72.06 85.54,74.65 85.56,74.65
GND on IN1 (solid shape): 166.34,84.92 166.51,84.92 166.6,84.87 166.6,84.78 166.58,84.71 166.57,84.63 166.51,84.54 166.39,84.56 165.14,85.81 164.62,85.81 163.82,86.61 163.8,86.72 163.89,86.78 164.48,86.78
GND on IN1 (solid shape): 142.71,58.02 142.77,58.11 142.88,58.09 143.99,56.98 144.07,56.98 144.15,56.94 144.16,56.85 144.15,56.8 144.15,56.75 144.16,56.65 144.21,56.56 144.22,56.45 144.13,56.4 144.04,56.4 143.32,57.12 142.84,57.12 142.71,57.25
GND on IN1 (solid shape): 164.08,76.02 167.29,76.02 167.38,75.96 167.36,75.84 166.89,75.38 163.88,75.38 163.11,76.14 163.06,76.14 162.98,76.19 162.98,76.29 163.01,76.38 163.03,76.46 163.01,76.58 162.95,76.68 162.94,76.79 163.03,76.84 163.26,76.84
GND on IN1 (solid shape): 180.02,36.87 180.08,36.97 180.19,36.95 180.45,36.69 180.45,36.19 181.49,35.16 181.49,34.79 181.42,34.69 181.31,34.72 179.69,36.34 179.66,36.44 179.74,36.51 179.94,36.62 180.02,36.84
GND on IN1 (solid shape): 14.37,6.14 14.57,6.24 14.76,6.14 14.81,6.1 14.81,5.73 14.43,5.35 10.79,5.35 10.67,5.47 10.73,5.52 10.78,5.52 10.87,5.53 10.95,5.57 11.1,5.69 11.16,5.88 11.14,5.99 11.08,6.09 11.12,6.13 11.17,6.14
GND on IN1 (solid shape): 57.36,12.15 57.45,12.08 57.42,11.97 57.34,11.86 57.31,11.72 57.32,11.64 57.34,11.57 57.34,11.47 57.25,11.43 55.96,11.43 55.4,10.86 54.33,10.86 52.73,9.26 51.7,9.26 51.64,9.33 51.67,9.42 53.68,11.44 55.43,11.44 56.14,12.15
GND on IN1 (solid shape): 23.26,35.41 23.3,35.33 23.3,32.7 20.51,29.92 20.41,29.85 20.34,29.75 19.62,29.03 19.62,28.8 19.58,28.8 19.49,28.76 19.41,28.69 19.3,28.67 19.23,28.76 19.23,29.69 22.15,32.61 22.15,34.19 23.06,35.1 23.06,35.37 23.07,35.4 23.1,35.42 23.14,35.42 23.17,35.43
GND on IN1 (solid shape): 64.13,89.91 64.13,89 64.09,88.92 64.02,88.89 64,88.9 63.97,88.91 63.95,88.95 63.95,89.71 63.18,90.48 62.17,90.48 62.16,90.53 62.06,90.73 61.86,90.81 61.76,90.79 61.67,90.75 61.63,90.72 61.56,90.79 61.61,90.83 61.71,90.93 61.75,91.05 61.76,91.1 62.94,91.1
GND on IN1 (solid shape): 147.43,52.79 147.55,52.77 147.65,52.67 152.99,52.67 153.1,52.56 153.1,50.77 153.94,49.93 153.89,49.88 153.79,49.85 153.63,50.01 150.02,50.01 149.55,50.48 148.16,50.48 147.11,51.53 147.11,52.09 147,52.2 146.98,52.3 147.06,52.37 147.28,52.48 147.37,52.7
GND on IN1 (solid shape): 197.18,7.35 197.22,7.32 197.26,7.29 197.29,7.28 197.29,6.52 196.21,5.45 195.97,5.45 195.03,6.4 195,6.51 195.1,6.57 195.21,6.57 195.77,6.01 196.4,6.01 196.69,6.3 196.69,6.88 196.51,7.06 196.51,7.24 196.52,7.3 196.56,7.33 196.66,7.28 196.77,7.26 196.82,7.26 196.87,7.26 197,7.28 197.1,7.35 197.14,7.37
GND on IN1 (solid shape): 78.57,77.67 78.66,77.61 78.64,77.49 77.67,76.53 77.67,75.87 77.35,75.55 77.24,75.53 77.18,75.62 77.18,75.88 77.16,75.91 77.12,76.04 77.16,76.17 77.18,76.2 77.18,76.7 77.11,76.78 77.09,76.88 77.14,77.02 77.27,77.1 77.31,77.11 77.87,77.67
GND on IN1 (solid shape): 147.26,84.85 147.55,84.64 147.84,84.85 147.85,84.88 148.3,84.88 148.65,84.54 148.62,84.5 148.59,84.42 148.57,84.33 148.57,84.28 146.8,84.28 146.66,84.43 146.7,84.48 146.72,84.48 146.91,84.58 146.99,84.78 146.98,84.84 147.02,84.87 147.06,84.88 147.25,84.88
GND on IN1 (solid shape): 164.37,85.22 164.9,85.22 165.04,85.09 165.06,84.98 164.97,84.91 164.33,84.91 163.56,85.68 157.83,85.68 157.36,85.21 157.28,85.18 157.2,85.23 157.08,85.34 156.92,85.39 156.78,85.36 156.67,85.28 156.64,85.24 156.6,85.28 155.87,85.28 155.78,85.34 155.8,85.46 156.79,86.45 163.15,86.45
GND on IN1 (solid shape): 82.5,78.07 82.61,78.09 82.67,78 82.67,77.94 81.84,77.12 81.77,77.09 81.7,77.12 81.59,77.19 81.46,77.22 81.22,77.12 81.13,76.88 81.13,76.82 81.15,76.76 81.16,76.73 80.8,76.38 80.69,76.35 80.63,76.45 80.63,76.68 81.6,77.65 82.08,77.65
GND on IN1 (solid shape): 33.28,42.43 33.37,42.37 33.36,42.26 33.27,42 33.37,41.74 33.27,41.64 33.27,41.07 33.29,41.06 33.25,41.01 33.19,40.99 30.69,40.99 30.54,40.84 30.24,40.91 30.01,40.69 30,40.76 30.03,40.81 31.65,42.43
GND on IN1 (solid shape): 48.03,70.14 48.12,70.08 48.1,69.97 46.14,68.01 46.14,67.74 45.87,67.46 45.5,67.46 45.42,67.5 45.4,67.58 45.4,67.62 45.41,67.66 45.4,67.7 45.4,67.74 45.41,67.83 45.49,67.87 45.74,67.87 46.13,68.26 46.17,68.3 46.21,68.35 46.43,68.57 46.43,69.86 46.32,69.97 46.29,70.08 46.39,70.14
GND on IN1 (solid shape): 65.33,64.04 65.44,64.06 65.5,63.98 65.57,63.8 65.72,63.69 65.78,63.62 65.75,63.53 65.3,63.08 65.3,61.64 64.47,60.81 64.2,60.81 64.11,60.87 64.13,60.98 64.18,61.08 64.2,61.19 64.15,61.37 64.02,61.49 63.99,61.5 63.99,62.7
GND on IN1 (solid shape): 58.2,72.12 58.31,72.14 58.37,72.04 58.37,69.83 58.32,69.78 58.19,69.78 57.93,69.52 57.67,69.78 57.32,69.78 56.85,69.31 56.46,69.31 56.34,69.44 56.34,69.94 56.67,70.27 56.74,70.39 56.77,70.52 56.76,70.61 57.82,71.67 57.9,71.78 57.92,71.92 57.92,71.96 57.95,72.04 58.02,72.08 58.16,72.08
GND on IN1 (solid shape): 133.97,82.58 134.06,82.53 134.1,82.47 133.92,82.29 133.8,82.17 133.8,81.16 133.76,81.15 133.67,81.1 133.61,81.02 133.58,81.02 133.55,81.03 133.5,81.07 133.44,81.11 133.42,81.12 133.42,81.49 133.41,81.56 133.39,81.64 133.39,81.69 132.95,82.13 132.95,82.4 133.07,82.51 133.17,82.51 133.22,82.46 133.57,82.34 133.88,82.54
GND on IN1 (solid shape): 134.19,79.69 134.29,79.72 134.36,79.66 134.36,76.18 132.79,74.61 132.79,74.3 132.78,74.27 132.74,74.25 132.62,74.22 132.52,74.14 132.45,74.11 132.38,74.14 132.27,74.22 132.13,74.25 132.1,74.25 132.01,74.31 132.03,74.42 132.03,74.87 134.04,76.88 134.11,76.97 134.15,77.07 134.15,77.08 134.17,77.09 134.17,79.67
GND on IN1 (solid shape): 157.26,88.02 157.26,87.45 157.18,87.37 156.38,87.37 155.02,86 150.96,86 150.59,86 149.48,87.12 148.51,88.08 147.06,88.08 146.98,88.12 146.96,88.21 146.96,88.24 146.97,88.27 146.94,88.4 146.88,88.5 146.85,88.59 146.91,88.66 147.07,88.79 147.13,88.98 147.13,89.01 147.15,89.09 147.23,89.13 149.29,89.13 151.39,91.23 154.04,91.23
GND on IN1 (solid shape): 170.49,75.18 171.05,75.18 171.08,75.15 172.25,75.15 172.35,75.09 172.32,74.98 172.12,74.78 168.96,74.78 168.89,74.81 168.86,74.88 168.81,75.05 168.67,75.18 168.55,75.31 168.37,75.36 168.2,75.31 168.08,75.18 168.06,75.15 167.66,75.15 167.61,75.2 167.29,75.2 167.2,75.26 167.22,75.37 167.71,75.86 169.81,75.86
GND on IN1 (solid shape): 214.39,21.66 214.39,17.23 214.29,17.13 214.26,17.11 214.23,17.11 214.2,17.11 214.17,17.12 214.15,17.14 214.13,17.17 214.12,17.2 214.12,17.21 214.12,18.44 213.04,19.53 212.44,19.53 212.09,19.89 212.09,20.62 212.77,20.62 212.77,20.57 212.79,20.52 212.8,20.47 212.83,20.43 212.86,20.39 212.9,20.36 212.94,20.33 212.99,20.31 213.04,20.29 213.09,20.29 213.14,20.29 213.19,20.3 213.24,20.32 213.29,20.34 213.33,20.37 213.36,20.41 213.39,20.45 213.41,20.5 213.43,20.55 213.44,20.6 213.44,20.65 213.43,20.7 213.41,20.75 213.39,20.79 213.36,20.83 213.33,20.87 213.29,20.9 213.24,20.93 213.19,20.94 213.14,20.95 213.09,20.96 213.04,20.95 212.99,20.94 212.94,20.92 212.9,20.89 212.86,20.85 212.83,20.81 212.8,20.77 212.79,20.72 212.77,20.67 212.77,20.62 212.09,20.62 212.09,21.59 212.29,21.79 214.26,21.79
GND on IN1 (solid shape): 190.62,101.61 190.65,101.54 190.62,101.46 189.09,99.93 189.09,98.32 189.07,98.27 189.04,98.23 188.94,98.29 188.83,98.31 188.62,98.22 188.53,98 188.53,97.98 188.61,97.78 188.81,97.69 188.83,97.69 188.91,97.7 188.99,97.74 189.06,97.7 189.09,97.63 189.09,93.96 189.02,93.9 188.75,93.9 188.67,93.83 188.28,93.83 188.23,93.88 188.23,99.51 190.33,101.61
GND on IN1 (solid shape): 42.54,40.53 44.31,40.53 44.4,40.47 44.38,40.36 44.27,40.25 44.23,40.24 44.19,40.26 43.92,40.4 43.64,40.26 43.6,40.24 43.56,40.26 43.21,40.41 42.94,40.14 42.94,40.09 38.92,40.09 38.83,40.16 38.85,40.27 39.47,40.88 42.2,40.88
GND on IN1 (solid shape): 45.19,78 45.28,77.95 45.27,77.85 45.24,77.76 45.22,77.66 45.33,77.41 45.58,77.31 46.41,77.31 46.41,76.56 46.35,76.48 46.25,76.48 46.17,76.52 46.08,76.53 45.96,76.51 45.86,76.44 45.82,76.43 45.78,76.44 44.9,77.33 44.15,77.33 44.07,77.37 44.06,77.45 44.07,77.5 44.07,77.54 44.07,77.71 44.36,78
GND on IN1 (solid shape): 127.33,80.77 127.39,80.73 127.39,80.6 126.57,79.79 125.09,78.3 124.58,78.3 124.49,78.37 124.52,78.48 124.68,78.64 124.77,78.58 124.87,78.56 125.02,78.61 125.12,78.73 125.16,78.81 125.18,78.9 125.17,78.97 125.14,79.05 125.12,79.08 125.72,79.68 125.92,79.68 125.96,79.72 126.03,79.76 126.08,79.81 126.86,80.59 126.95,80.57 127.13,80.63 127.24,80.78 127.27,80.79 127.3,80.79
GND on IN1 (solid shape): 89.27,94.41 89.31,94.36 89.49,94.14 89.78,94.15 89.83,94.16 89.9,94.13 89.93,94.06 89.93,93.19 89.88,93.1 89.77,93.1 89.69,93.14 89.59,93.16 89.36,93.06 89.26,92.82 89.26,92.77 89.28,92.72 89.29,92.69 88.32,91.71 88.22,91.71 88.17,91.76 88.17,91.89 88.94,92.67 88.94,94.21 89.14,94.41 89.18,94.43 89.22,94.43
GND on IN1 (solid shape): 176.54,25.63 176.74,25.5 176.99,25.48 177.06,25.45 177.1,25.37 177.1,25.29 176.98,25.3 176.93,25.3 176.66,25.3 176.56,25.2 175.58,25.2 175.5,25.36 175.35,25.46 175.38,25.47 175.58,25.78 175.38,26.09 175.35,26.1 175.58,26.42 175.35,26.73 175.41,26.76
GND on IN1 (solid shape): 53.58,72.36 53.6,72.29 53.57,72.23 53.53,72.19 53.53,71.8 53.33,71.6 53.3,71.64 53.2,71.69 52.88,71.62 52.79,71.4 52.81,71.3 52.86,71.2 52.89,71.17 52.8,71.08 52.8,70.37 52.75,70.32 52.64,70.29 52.58,70.39 52.58,71.78 52.87,72.07 52.9,72.04 52.99,71.99 53.09,71.97 53.31,72.06 53.4,72.28 53.4,72.31 53.39,72.36
GND on IN1 (solid shape): 86.85,80.04 86.92,80.07 86.99,80.04 87.01,80.02 87.05,79.94 87.02,79.87 86.86,79.71 86.86,78.67 84.7,76.51 84.59,76.49 84.52,76.58 84.52,76.68 85.22,77.38 85.22,78.9 85.31,78.98 85.36,78.93 85.36,78.91 85.46,78.68 85.69,78.59 85.93,78.69 86.02,78.92 85.93,79.16 85.7,79.26 85.68,79.26 85.63,79.31 85.73,79.4 86.21,79.4
GND on IN1 (solid shape): 38.28,69.84 39.35,69.84 40.11,69.07 40.11,68.06 40.05,67.96 39.94,67.99 38.93,69 38.96,69.03 39.01,69.12 39.03,69.23 38.94,69.45 38.73,69.54 38.56,69.49 38.45,69.37 38.44,69.34 36.97,69.34 36.96,69.33 36.85,69.31 36.79,69.4 36.79,69.74 36.84,69.83 36.95,69.82 37.05,69.78 37.15,69.76 37.29,69.79 37.4,69.86 37.47,69.93 38.19,69.93
GND on IN1 (solid shape): 99.04,75.38 99.11,75.34 99.13,75.27 99.13,75.23 99.13,75.19 99.14,75.14 99.13,75.05 99.05,75.01 98.22,75.01 98.19,74.98 98.09,74.95 98.02,75.01 97.9,75.16 97.71,75.22 97.47,75.12 97.38,74.89 97.39,74.8 97.42,74.72 97.42,74.62 97.33,74.57 97.22,74.57 97.11,74.45 96.18,74.45 96.08,74.51 96.11,74.62 97.04,75.56 98.87,75.56
GND on IN1 (solid shape): 92,75.95 92.1,75.89 92.07,75.78 91.73,75.43 91.73,75.05 90.53,73.85 90.5,73.88 90.41,73.92 90.31,73.93 90.07,73.84 89.98,73.6 90.07,73.37 90.31,73.27 90.37,73.27 90.45,73.25 90.48,73.17 90.48,73.06 90.38,73.07 90.34,73.07 90.11,72.98 89.98,72.67 89.91,72.64 89.42,72.64 89.29,72.77 89.29,73.36 91.88,75.95
GND on IN1 (solid shape): 151.08,7.77 150.94,7.63 150.85,7.6 150.78,7.66 150.65,7.8 150.47,7.85 150.34,7.83 150.23,7.75 150.15,7.71 150.08,7.75 149.97,7.82 149.84,7.85 149.69,7.82 149.58,7.73 149.5,7.69 149.42,7.73 149.31,7.82 149.17,7.85 148.93,7.75 148.84,7.51 148.84,7.44 148.7,7.3 148.23,7.3 148.15,7.39 148.15,7.82 148.3,7.98 150.87,7.98
GND on IN1 (solid shape): 36.11,95.99 36.2,96.02 36.27,95.95 36.4,95.8 36.59,95.73 36.68,95.67 36.66,95.56 36.37,95.28 36.37,94.86 36.36,94.82 36.32,94.81 36.03,94.5 36.32,94.19 36.36,94.18 36.37,94.14 36.37,93.42 36.31,93.36 35.88,93.79 35.88,93.8 35.75,93.98 35.55,94.05 35.48,94.08 35.46,94.15 35.46,94.94 35.45,94.95 35.45,95.33
GND on IN1 (solid shape): 186.21,5.71 186.31,5.71 186.39,5.67 186.41,5.58 186.39,5.52 186.39,5.46 186.48,5.22 186.72,5.13 186.92,5.19 187.04,5.36 187.11,5.43 187.21,5.41 187.44,5.17 190.95,5.17 191.04,5.13 191.04,5.03 191.01,4.95 191.01,4.86 191.04,4.7 191.13,4.56 191.37,4.32 191.68,4.32 191.78,4.26 191.75,4.15 191.49,3.88 186.52,3.88 186.29,4.11 185.96,4.11 185.65,4.43 185.65,5.56 185.86,5.78 186.14,5.78
GND on IN1 (solid shape): 27.13,5.76 29.32,5.76 29.41,5.71 29.41,5.61 29.37,5.52 29.36,5.43 29.45,5.19 29.69,5.1 29.92,5.19 30.02,5.43 30.01,5.52 29.97,5.61 29.97,5.71 30.06,5.76 30.39,5.76 31.32,4.83 31.34,4.72 31.24,4.66 26.36,4.66 25.62,5.41 25.63,5.44 25.65,5.5 25.66,5.56 25.65,5.62 25.63,5.68 25.64,5.78 25.73,5.82 27.07,5.82
GND on IN1 (solid shape): 42.35,94.46 42.38,94.33 42.46,94.22 42.95,93.72 44.25,93.72 44.34,93.66 44.32,93.55 43.97,93.21 43.9,93.18 43.82,93.21 43.82,93.35 43.67,93.51 43.55,93.49 43.47,93.5 43.41,93.54 43.38,93.57 42.13,93.57 42.06,93.54 42.04,93.52 41.98,93.48 41.91,93.47 41.85,93.48 41.79,93.51 41.76,93.53 41.73,93.53 41.71,93.53 41.66,93.54 41.6,93.53 41.56,93.53 41.51,93.47 41.48,93.49 41.47,93.52 41.47,93.8 41.44,93.93 41.36,94.05 41.26,94.15 41.15,94.23 41.01,94.26 40.93,94.26 40.93,94.49 40.95,94.51 42.35,94.51
GND on IN1 (solid shape): 140.88,66.23 140.86,66.22 140.79,66.09 140.76,65.94 140.76,65.63 140.77,65.55 140.79,65.48 140.81,65.44 140.83,65.4 140.81,65.37 140.79,65.33 140.77,65.26 140.76,65.17 140.89,64.88 141.18,64.76 141.22,64.76 141.29,64.74 141.33,64.68 141.46,64.55 141.48,64.51 141.46,64.49 141.43,64.45 141.4,64.4 141.36,64.39 141.32,64.4 141.21,64.51 141.06,64.55 140.84,64.46 140.75,64.24 140.75,64.18 140.76,64.13 140.77,64.1 140.72,64.04 140.58,64.18 140.58,66.09 140.79,66.3 140.88,66.3
GND on IN1 (solid shape): 132.18,88.67 132,88.48 132,88.29 131.84,88.29 131.8,88.33 131.65,88.49 131.44,88.55 131.24,88.5 131.09,88.36 131.02,88.36 130.89,88.42 130.73,88.58 130.38,88.58 130.14,88.33 130.11,88.34 130.08,88.36 130,88.45 129.75,88.45 129.73,88.46 129.6,88.56 129.43,88.59 129.25,88.55 129.11,88.43 129.09,88.42 129,88.4 128.93,88.47 128.9,88.55 128.85,88.62 128.84,88.73 128.93,88.79 132.13,88.79
GND on IN1 (solid shape): 37.4,95.3 37.5,95.32 37.57,95.24 37.6,95.13 37.67,95.03 38.11,94.59 38.77,94.59 38.77,93.3 38.33,92.86 37.45,92.86 37.45,92.91 37.37,93.11 37.17,93.21 37.11,93.24 37.08,93.31 37.08,93.34 37.1,93.38 37.21,93.4 37.29,93.43 37.79,93.43 37.87,93.4 37.94,93.39 38.25,93.7 37.94,94.01 37.87,94 37.79,93.97 37.29,93.97 37.23,94 37.17,94.01 37.11,94.04 37.08,94.11 37.08,94.98
GND on IN1 (solid shape): 145.92,57.22 145.92,56.73 147.12,55.53 147.12,54.87 147.06,54.78 146.95,54.8 146.54,55.21 146.18,55.21 146.09,55.25 146.08,55.34 146.1,55.4 146.1,55.46 146.08,55.58 146.01,55.69 145.98,55.76 146.02,55.84 146.1,55.95 146.13,56.09 146.03,56.32 145.8,56.42 145.59,56.35 145.47,56.15 145.4,56.07 145.3,56.1 144.79,56.61 144.8,56.64 144.81,56.7 144.82,56.75 144.81,56.8 144.8,56.85 144.82,56.94 144.9,56.98 145.32,56.98 145.67,57.32 145.82,57.32
GND on IN1 (solid shape): outline of 81 points within 194.8,7.61 196.93,12.18
GND on IN1 (solid shape): 165.55,105.35 165.57,105.24 165.48,105.17 163.4,105.17 163.15,104.93 163.15,103.51 163.49,103.17 163.9,103.17 164.03,103.04 164.03,103.01 164.06,102.98 164.07,102.93 164.02,102.9 163.52,102.9 163.44,102.9 163.38,102.84 162.27,101.73 153.41,101.73 152.65,101.73 152.6,101.78 152.6,101.93 154.88,104.21 157.57,104.21 157.57,104.21 158.34,104.21 158.43,104.23 158.51,104.28 158.64,104.41 158.65,104.42 158.8,104.54 158.85,104.72 158.76,104.96 158.52,105.06 158.43,105.04 158.34,105 158.25,105 158.19,105.08 158.17,105.15 158.13,105.23 158.12,105.33 158.21,105.39 165.51,105.39
GND on IN1 (solid shape): 145.65,62.95 145.68,62.99 145.73,62.98 145.95,62.76 146.01,62.76 146.08,62.74 146.15,62.74 147.67,62.74 149.29,61.11 149.29,60.49 149.23,60.39 149.12,60.41 148.74,60.79 148.04,61.49 147.75,61.49 147.74,61.52 147.7,61.61 147.64,61.69 147.63,61.69 147.6,61.77 147.63,61.84 147.71,61.95 147.74,62.08 147.64,62.32 147.41,62.42 147.17,62.32 147.07,62.09 147.1,61.95 147.18,61.84 147.22,61.76 147.19,61.68 147.13,61.61 147.09,61.52 147.09,61.49 147,61.49 145.65,62.84
GND on IN1 (solid shape): 43.97,71.75 44.07,71.75 44.07,71.7 44.38,71.4 44.69,71.7 44.69,71.75 45.19,71.75 45.91,71.03 45.93,70.92 45.84,70.86 45.45,70.86 45.45,70.9 45.14,71.18 44.83,70.9 44.83,70.86 43.88,70.86 43.87,70.9 43.77,71.1 43.56,71.18 43.54,71.18 43.46,71.21 43.43,71.28 43.43,71.29 43.46,71.36 43.53,71.39 43.54,71.39 43.76,71.48 43.85,71.7 43.84,71.77 43.89,71.83
GND on IN1 (solid shape): 168.51,72.62 168.46,72.51 168.45,72.41 168.55,72.18 168.78,72.08 168.95,72.13 169.08,72.25 169.16,72.31 169.25,72.25 169.38,72.13 169.55,72.08 169.56,72.08 169.65,72.02 169.63,71.91 168.67,70.94 167.92,70.94 167.84,70.99 167.83,71.08 167.84,71.14 167.85,71.2 167.75,71.43 167.52,71.53 167.4,71.51 167.3,71.45 167.21,71.54 167.21,71.69 167.36,71.8 167.42,71.97 167.46,72.04 167.53,72.07 167.8,72.07 168.36,72.62
GND on IN1 (solid shape): outline of 93 points within 107.07,59.32 108.72,61.5
GND on IN1 (solid shape): 144.09,89.08 144.2,88.88 144.42,88.79 144.64,88.88 144.75,89.08 144.76,89.13 145.67,89.13 145.75,89.09 145.77,89.01 145.97,88.63 146.37,88.76 146.45,88.8 146.54,88.77 146.55,88.75 146.58,88.66 146.51,88.59 146.34,88.43 146.31,88.21 146.29,88.12 146.21,88.08 142.3,88.08 142.22,88.12 142.2,88.21 142.19,88.41 142.07,88.57 142.06,88.58 142.03,88.63 142.52,89.13 144.09,89.13
GND on IN1 (solid shape): 157.07,77.22 157.17,77.16 157.15,77.05 155.9,75.8 155.82,75.69 155.8,75.56 155.8,75.51 155.78,75.42 155.56,75.35 155.46,75.25 155.43,75.22 155.39,75.2 155.28,75.29 155.14,75.32 154.99,75.28 154.88,75.17 154.84,75.18 154.81,75.2 154.17,75.83 154.15,75.88 154.15,75.93 154.2,75.95 154.27,75.96 154.33,75.92 154.44,75.82 154.59,75.79 154.59,75.79 154.81,75.88 154.9,76.1 154.89,76.17 154.86,76.24 154.9,76.28 154.95,76.29 155.88,76.29 156.81,77.22
GND on IN1 (solid shape): 17.98,16.91 18.09,16.93 18.15,16.84 18.18,16.68 18.28,16.54 18.36,16.45 18.28,16.37 18.18,16.23 18.15,16.07 18.28,15.78 18.57,15.65 18.73,15.68 18.87,15.78 18.9,15.8 18.93,15.82 18.97,15.8 19.34,15.69 19.57,16 19.6,16.03 19.71,16.05 19.77,15.96 19.77,15.78 18.13,14.14 18.13,13.88 18.09,13.88 17.74,13.59 17.84,13.16 17.93,13.08 17.83,12.98 17.8,12.97 17.78,12.97 17.76,12.98 17.5,13.24 17.5,16.43
GND on IN1 (solid shape): 23.19,15.82 23.19,15.4 22.91,15.12 22.77,15.12 22.48,15.42 22.13,15.42 21.89,15.17 21.89,14.82 22.09,14.61 21.89,14.41 21.89,14.25 21.88,14.2 21.75,14.2 21.05,13.5 21.05,12.71 20.97,12.63 20.87,12.6 20.8,12.67 20.76,12.75 20.7,12.82 20.62,12.91 20.7,12.99 20.79,13.13 20.83,13.29 20.7,13.58 20.41,13.71 20.24,13.68 20.11,13.58 20.07,13.54 20.01,13.56 20.01,13.57 19.84,13.66 19.65,13.64 19.57,13.65 19.52,13.72 19.49,13.81 19.44,13.89 19.41,13.96 19.44,14.02 20.78,15.36 20.78,15.54 20.8,15.6 20.86,15.64 21.01,15.64 21.32,15.94 21.89,15.94 21.89,15.95 23.06,15.95 23.06,15.95
GND on IN1 (solid shape): 73.63,70.33 73.71,70.3 73.83,70.02 74.04,69.93 74.26,70.02 74.38,70.3 74.45,70.33 75.43,70.33 75.43,70.28 75.53,70.04 75.77,69.95 75.78,69.95 75.86,69.92 75.89,69.85 75.89,69.64 75.49,69.24 74.44,69.24 74.37,69.28 74.34,69.36 74.34,69.4 74.04,69.71 73.73,69.4 73.73,69.39 73.58,69.39 73.55,69.42 73.46,69.65 73.16,69.78 73.13,69.85 73.13,70.27 73.19,70.33
GND on IN1 (solid shape): 79.57,77.27 79.67,77.21 79.65,77.1 79.45,76.9 79.45,76.14 79.45,76.03 79.39,75.94 79.29,75.95 79.2,75.99 79.1,76.01 78.77,75.67 79.1,75.34 79.24,75.37 79.36,75.46 79.45,75.43 79.45,75.3 78.27,74.12 77.92,74.12 77.83,74.18 77.85,74.29 77.85,74.85 77.91,74.95 78.02,74.93 78.13,74.85 78.26,74.83 78.59,75.16 78.26,75.49 78.23,75.49 78.18,75.54 78.27,75.63 78.27,76.32 79.22,77.27
GND on IN1 (solid shape): outline of 107 points within 184.1,15.29 186.77,23.44
GND on IN1 (solid shape): 140.13,26.88 140.43,26.7 140.72,26.88 142.14,26.88 142.31,26.74 142.53,26.74 142.56,26.75 143.45,25.86 142.88,25.29 142.79,25.26 142.72,25.31 142.36,25.48 142.09,25.19 142.09,25.14 140.76,25.14 140.72,25.29 140.61,25.4 140.59,25.44 140.61,25.49 140.72,25.61 140.76,25.76 140.43,26.1 140.09,25.76 140.13,25.61 140.24,25.49 140.26,25.44 140.24,25.4 140.18,25.35 140.13,25.28 140.09,25.26 140.05,25.27 139.93,25.39 139.93,26.88
GND on IN1 (solid shape): 9.08,6.85 9.17,6.79 9.17,6.69 9.13,6.61 9.12,6.52 9.15,6.39 9.23,6.28 9.26,6.2 9.23,6.13 9.16,6.02 9.13,5.9 9.23,5.66 9.47,5.56 9.52,5.57 9.57,5.58 9.6,5.59 10.31,4.88 10.28,4.85 10.22,4.75 10.2,4.63 10.21,4.58 10.22,4.52 10.21,4.43 10.12,4.39 6.59,4.39 6.49,4.49 6.49,5.98 6.55,6.07 6.66,6.05 6.92,5.79 7.38,5.79 7.48,5.72 7.45,5.61 7.15,5.31 7.12,5.32 7.06,5.33 7.01,5.33 6.77,4.76 7.34,5 7.34,5.05 7.33,5.11 7.31,5.14 9.02,6.85
GND on IN1 (solid shape): 85.92,98.66 85.95,98.55 85.85,98.48 85.74,98.48 85.72,98.51 85.6,98.65 85.42,98.7 85.19,98.6 85.09,98.37 85.18,98.14 85.39,98.03 85.47,97.98 85.47,97.89 85.45,97.82 85.44,97.75 85.5,97.56 85.64,97.44 85.7,97.37 85.68,97.28 85.63,97.19 85.61,97.08 85.65,96.93 85.74,96.81 85.78,96.74 85.75,96.66 85.69,96.56 85.66,96.45 85.6,96.35 85.49,96.38 84.94,96.93 83.22,96.93 82.96,97.19 82.96,97.31 83.06,97.31 83.3,97.41 83.39,97.64 83.39,97.7 83.38,97.75 83.37,97.78 84.6,99.02 85.57,99.02
GND on IN1 (solid shape): 28.2,30.1 28.31,30.12 28.37,30.03 28.37,28.86 28.37,28.86 28.37,28.49 26.98,27.1 26.91,27.07 26.84,27.09 26.82,27.11 26.78,27.18 26.81,27.26 26.87,27.36 26.9,27.49 26.56,27.82 26.23,27.49 26.26,27.34 26.36,27.22 26.4,27.15 26.37,27.07 26.3,26.97 26.28,26.85 26.3,26.73 26.37,26.62 26.39,26.55 26.36,26.48 25.87,25.99 25.5,25.99 25.43,25.96 25.35,25.99 25.33,26.01 25.29,26.09 25.31,26.16 25.38,26.27 25.4,26.39 25.3,26.62 25.07,26.72 25.06,26.72 24.97,26.78 24.99,26.9
GND on IN1 (solid shape): 202.11,57.63 202.11,54.84 201.72,54.45 195.2,54.45 194.67,53.92 193.89,53.92 193.8,53.96 193.8,54.07 193.9,54.03 194.01,54.02 194.35,54.16 194.51,54.49 194.51,54.58 194.35,54.91 194.01,55.04 193.94,55.04 193.85,55.02 193.8,55.05 193.79,55.06 193.68,55.21 193.51,55.27 193.43,55.34 193.46,55.44 194,55.99 197,55.99 197.27,56.25 197.38,56.28 197.44,56.18 197.44,56.17 197.54,55.93 197.77,55.84 198.01,55.93 198.11,56.17 198.01,56.4 197.77,56.5 197.76,56.5 197.67,56.56 197.69,56.68 199.16,58.15 199.16,58.59 199.38,58.8 200.94,58.8
GND on IN1 (solid shape): outline of 107 points within 110.64,55.21 115.3,62.35
GND on IN1 (solid shape): 102.9,84.56 102.94,84.42 103.02,84.32 103.03,84.29 103.04,84.25 102.95,84.16 102.9,84.03 102.9,83.99 102.28,83.99 100.38,82.08 98.12,82.08 98.12,82.13 98.06,82.28 97.88,82.47 97.91,82.55 98.71,83.35 98.73,83.35 98.82,83.31 98.83,83.21 98.81,83.15 98.8,83.08 98.9,82.84 99.13,82.75 99.28,82.78 99.39,82.87 99.47,82.91 99.54,82.89 99.65,82.82 99.77,82.8 100,82.9 100.1,83.13 100.1,83.18 100.09,83.23 100.11,83.31 100.19,83.35 100.91,83.35 102.05,84.5 102.11,84.53 102.18,84.51 102.28,84.32 102.48,84.24 102.7,84.33 102.79,84.55 102.79,84.56
GND on IN1 (solid shape): 192.98,7.22 193,7.11 192.91,7.05 192.08,7.05 192,7.09 191.99,7.19 192,7.25 192.01,7.3 191.91,7.54 191.67,7.64 191.5,7.59 191.38,7.46 191.29,7.41 191.2,7.46 191.08,7.59 190.91,7.64 190.68,7.54 190.58,7.3 190.58,7.25 190.6,7.19 190.59,7.09 190.51,7.05 189.66,7.05 189.31,7.4 189.28,7.48 189.33,7.56 189.43,7.68 189.47,7.83 189.14,8.17 188.8,7.83 188.82,7.74 188.85,7.66 188.86,7.55 188.77,7.5 188.17,7.5 187.45,8.22 187.43,8.33 187.52,8.4 191.81,8.4
GND on IN1 (solid shape): 93.31,95.68 93.39,95.64 93.4,95.55 93.4,95.51 93.39,95.46 93.51,95.19 93.78,95.08 93.93,95.11 94.06,95.2 94.14,95.24 94.21,95.2 94.35,95.09 94.51,95.05 94.67,95.09 94.81,95.19 94.88,95.22 94.96,95.19 95.09,95.09 95.25,95.05 95.41,95.09 95.54,95.18 95.62,95.22 95.7,95.18 95.83,95.06 96.01,95.02 96.28,95.13 96.39,95.4 96.39,95.47 96.37,95.54 96.38,95.63 96.46,95.68 96.98,95.68 97.1,95.56 97.1,93.53 97.53,93.1 97.55,92.99 97.46,92.93 97.41,92.93 96.54,93.81 93.33,93.81 92.48,94.66 92.48,95.26 92.57,95.38 92.6,95.53 92.6,95.57 92.63,95.64 92.7,95.68
GND on IN1 (solid shape): 19.6,21.14 19.6,19.86 19.69,19.77 19.69,19.33 19.77,19.26 19.59,19.08 18.37,19.08 17.18,17.89 17.18,17.54 16.49,16.85 16.49,14.66 16.42,14.57 16.31,14.59 15.84,15.06 13.83,15.06 12.97,15.93 12.97,18.32 14.1,19.46 14.1,20.83 14.65,21.38 16.45,21.38 16.55,21.28 16.55,21.02 16.54,20.97 16.51,20.94 16.51,20.54 16.22,20.54 15.97,20.29 15.97,19.94 16.18,19.74 15.97,19.53 15.97,19.18 16.22,18.94 16.56,18.94 16.84,19.21 17.01,19.21 17.61,19.81 17.66,19.77 17.69,19.7 17.66,19.63 17.58,19.51 17.55,19.37 17.88,19.04 18.21,19.37 18.21,19.42 18.16,19.55 18.1,19.62 18.07,19.7 18.1,19.77 18.19,19.89 18.21,20.02 18.17,20.18 18.06,20.3 18.01,20.37 18.02,20.44 18.07,20.54 18.09,20.64 17.99,20.88 17.75,20.97 17.72,20.97 17.64,21 17.61,21.07 17.61,21.12 17.92,21.44 19.3,21.44
GND on IN1 (solid shape): 157.14,77.92 160.96,77.92 161.09,77.79 161.11,77.68 161.02,77.62 160.79,77.52 160.69,77.28 160.7,77.18 160.75,77.09 160.76,76.98 160.67,76.93 160.55,76.93 160.1,76.48 160,76.45 159.93,76.53 159.81,76.72 159.6,76.8 159.54,76.79 159.47,76.77 159.44,76.76 158.74,77.46 156.71,77.46 155.78,76.53 155.64,76.53 155.64,76.61 155.67,76.63 155.81,76.74 155.85,76.91 155.55,77.22 155.24,76.91 155.28,76.76 155.38,76.65 155.36,76.57 155.28,76.53 154.92,76.53 154.88,76.54 154.84,76.57 154.85,76.61 154.85,76.65 154.83,76.76 154.77,76.86 154.75,76.97 154.84,77.03 154.87,77.03 155.91,78.07 155.91,78.22 155.93,78.23 156.06,78.35 156.11,78.51 156.09,78.61 156.04,78.7 156.03,78.81 156.12,78.86 156.19,78.86
GND on IN1 (solid shape): 140.81,100.53 140.91,100.47 140.88,100.36 140.89,99.88 141.36,99.89 141.44,99.92 141.51,99.89 141.69,99.79 141.9,99.82 141.93,99.83 141.97,99.81 142.02,99.75 142.03,99.7 141.98,99.67 141.08,99.67 140.66,99.24 139.57,99.24 139.47,99.2 139.39,99.2 139.33,99.26 139.21,99.44 139.01,99.51 138.93,99.5 138.85,99.47 138.77,99.46 138.71,99.52 138.66,99.6 138.6,99.66 138.55,99.75 138.6,99.83 138.67,99.89 138.72,99.96 138.81,100.01 138.9,99.96 139.02,99.82 139.2,99.77 139.32,99.8 139.43,99.87 139.51,99.9 139.58,99.86 139.95,99.77 140.16,100.09 140.16,100.11 140.14,100.24 140.05,100.35 140.03,100.47 140.12,100.53
GND on IN1 (solid shape): 29.14,37.83 29.23,37.76 29.21,37.65 27.63,36.07 27.52,36.05 27.46,36.14 27.35,36.37 27.12,36.46 26.89,36.36 26.79,36.12 26.88,35.89 27.11,35.79 27.2,35.73 27.17,35.62 26.48,34.92 26.4,34.89 26.33,34.93 26.21,35.04 26.05,35.08 25.81,34.98 25.71,34.75 25.79,34.53 25.99,34.42 26.04,34.41 26.04,32.94 25.26,32.17 25.15,32.15 25.09,32.24 25.09,33.8 25.13,33.8 25.41,34.04 25.3,34.39 25.27,34.47 25.3,34.55 25.42,34.78 25.34,35.03 25.31,35.06 26.15,35.91 26.15,36.18 26.19,36.26 26.26,36.29 26.31,36.28 26.52,36.35 26.64,36.54 26.64,36.57 27.72,36.57 28.98,37.83
GND on IN1 (solid shape): outline of 144 points within 154.16,49.98 156.99,53.17
GND on IN1 (solid shape): outline of 159 points within 51.3,20.89 54.45,25.63
GND on IN1 (solid shape): 26.68,32.16 26.77,32.19 26.84,32.13 26.89,32.05 26.94,31.99 26.98,31.92 26.95,31.84 26.9,31.79 26.87,31.72 26.81,31.67 26.73,31.67 26.66,31.69 26.59,31.7 26.36,31.6 26.26,31.37 26.34,31.15 26.53,31.04 26.61,30.97 26.58,30.87 23.31,27.59 23.31,26.23 20.63,23.55 20.63,21.78 20.57,21.68 20.46,21.7 20.31,21.85 20.31,25.29 22.27,27.25 22.4,27.38 22.45,27.32 22.44,27.25 22.78,26.91 23.11,27.25 23.07,27.4 22.97,27.52 22.93,27.59 22.95,27.66 23,27.76 23.02,27.87 22.96,28.06 22.8,28.18 22.79,28.18 22.75,28.23 24.74,30.22 24.81,30.25 24.88,30.23 24.99,30.16 25.11,30.14 25.34,30.24 25.44,30.47 25.42,30.59 25.35,30.7 25.33,30.77 25.36,30.84
GND on IN1 (solid shape): 139.16,66.96 139.16,66.66 139.25,66.56 139.28,66.49 139.25,66.42 139.23,66.42 139.01,65.89 139.54,66.11 139.54,66.13 139.61,66.16 139.68,66.13 139.77,66.04 139.77,63.86 140.27,63.37 140.27,63.24 140.23,63.19 140.18,63.21 139.34,64.04 139.34,64.54 139.26,64.62 139.23,64.7 139.28,64.77 139.31,64.77 139.34,64.76 139.56,65.29 139.03,65.07 139.04,65.04 139.04,65.01 138.97,64.96 138.89,64.99 138.28,65.6 137.98,65.6 137.92,65.65 137.91,65.7 137.95,65.74 138.14,65.84 138.22,66.04 138.19,66.18 138.1,66.28 138.07,66.36 138.1,66.43 138.17,66.53 138.16,66.79 138.07,66.9 138.03,66.97 138.05,67.04 138.09,67.13 138.11,67.22 138.1,67.27 138.14,67.3 138.18,67.31 138.81,67.31
GND on IN1 (solid shape): 105.34,92.17 105.36,92.07 105.29,92 105.21,91.96 105.15,91.91 105.07,91.87 105,91.91 104.89,91.98 104.75,92.01 104.42,91.68 104.75,91.34 104.89,91.37 105,91.45 105.07,91.48 105.15,91.45 105.26,91.37 105.39,91.34 105.63,91.44 105.72,91.68 105.72,91.73 105.71,91.78 105.72,91.87 105.8,91.91 106.41,91.91 106.41,91.31 106.2,91.1 104.01,91.1 103.76,91.36 103.71,91.36 103.67,91.39 103.68,91.44 104.12,91.89 104.13,91.89 104.3,92.01 104.36,92.21 104.26,92.44 104.03,92.54 103.9,92.51 103.79,92.44 103.71,92.41 103.63,92.45 103.52,92.54 103.37,92.58 103.16,92.5 103.04,92.31 103.04,92.29 102.99,92.24 100.08,92.24 100.01,92.27 99.98,92.35 99.98,92.38 99.92,92.57 99.76,92.69 99.7,92.77 99.73,92.86 100.04,93.17 104.33,93.17
GND on IN1 (solid shape): 145.64,54.65 145.72,54.61 145.73,54.51 145.7,54.43 145.69,54.35 145.79,54.12 146.02,54.02 146.23,54.1 146.35,54.29 146.42,54.37 146.52,54.34 146.56,54.3 146.56,53.76 147.11,53.21 147.13,53.1 147.04,53.04 146.95,53.02 146.88,52.99 146.79,52.99 146.73,53.04 146.61,53.19 146.43,53.24 146.1,52.91 146.43,52.57 146.51,52.58 146.59,52.62 146.67,52.62 146.73,52.57 146.74,52.56 146.73,52.46 146.65,52.41 145.8,52.41 145.23,52.98 145.21,53.09 145.3,53.16 145.53,53.26 145.62,53.49 145.52,53.73 145.29,53.82 145.05,53.73 144.95,53.5 144.89,53.41 144.78,53.43 144.39,53.83 144.36,53.92 144.42,53.99 144.57,54.12 144.63,54.3 144.62,54.36 144.61,54.41 144.6,54.44 144.81,54.65

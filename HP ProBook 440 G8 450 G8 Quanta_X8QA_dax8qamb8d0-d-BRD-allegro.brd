# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 141.11,58.1 141.2,58.08 141.29,58.04 141.4,58.02 141.48,58.03 141.56,58.06 141.66,58.06 141.71,57.97 141.71,57.33 142.11,56.93 142.13,56.82 142.04,56.76 140.92,56.76 140.48,57.2 140.48,57.29 140.54,57.29 140.59,57.25 140.62,57.24 140.87,57.24 140.96,57.3 141.03,57.4 141.04,57.48 141.04,57.52 141.04,57.56 141.03,57.64 140.98,57.73 140.9,57.79 140.9,57.85 140.94,57.9 141,57.97 141.05,58.04
GND on BOTTOM (solid shape): 80.48,79.8 80.52,79.89 80.62,79.9 81.27,79.24 81.29,79.24 81.29,79.24 82.45,79.24 82.68,79 82.68,78.74 82.75,78.59 82.9,78.53 83.18,78.53 83.31,78.57 83.39,78.68 83.4,78.72 83.68,78.72 83.69,78.68 83.77,78.57 83.9,78.53 84.18,78.53 84.26,78.53 84.26,78.26 84.18,78.26 83.9,78.26 83.77,78.22 83.69,78.11 83.68,78.07 83.4,78.07 83.39,78.11 83.31,78.22 83.18,78.26 82.92,78.26 82.63,78.55 80.99,78.55 80.48,79.07
GND on BOTTOM (solid shape): 84.44,71.23 84.44,69.62 84.19,69.37 84.19,69.13 84.09,69.13 83.82,69.4 83.79,69.46 83.81,69.53 83.83,69.56 83.83,69.59 83.83,70.2 83.8,70.28 83.72,70.32 82.63,70.32 82.55,70.28 82.52,70.2 82.52,69.59 82.55,69.51 82.66,69.46 82.68,69.43 82.68,69.14 80.04,69.14 79.98,69.2 79.96,69.3 80.04,69.37 80.25,69.5 80.33,69.73 80.33,69.78 80.31,69.84 81.36,70.9 83.36,70.9 83.67,71.21 83.67,71.38 84.3,71.38
GND on BOTTOM (solid shape): 95.88,86.82 95.97,86.85 96.04,86.8 96.18,86.64 96.38,86.59 96.57,86.64 96.7,86.78 97.27,86.78 98.29,85.76 98.31,85.65 98.22,85.59 96.67,85.59 96.34,85.79 96.01,85.59 95.88,85.59 95.23,84.94 95.1,84.94 95.04,84.96 95,85.03 95.02,85.04 95.02,85.16 95.02,85.89 95.09,85.97 95.14,86.07 95.14,86.09
GND on BOTTOM (solid shape): 115.5,63.83 115.54,63.78 115.59,63.74 115.59,63.68 115.6,63.63 115.63,63.6 115.68,63.54 115.64,63.5 115.55,63.41 115.53,63.34 115.53,63.23 115.54,63.17 115.58,63.11 115.59,63.1 115.59,63.05 115.31,62.77 115.29,62.74 115.28,62.69 115.28,62.39 115.29,62.34 115.31,62.31 115.41,62.21 115.41,61.79 115.01,61.4 115,61.38 114.99,61.35 114.97,61.32 114.89,61.32 114.89,62.24 114.97,62.33 114.99,62.36 115,62.41 115,62.74 115,62.78 114.95,62.89 114.95,63.01 115.02,63.14 115.08,63.21 115.2,63.21 115.24,63.22 115.27,63.24 115.38,63.35 115.4,63.38 115.41,63.43 115.41,63.86 115.49,63.86
GND on BOTTOM (solid shape): 149.14,8.14 149.22,8.14 149.23,8.11 149.25,8.07 149.29,8.04 149.32,8.03 149.32,7.9 149.28,7.87 149.21,7.88 149.17,7.88 148.91,7.77 148.8,7.51 148.8,7.47 148.81,7.42 148.79,7.34 148.71,7.3 148.53,7.3 148.45,7.38 148.43,7.39 148.33,7.48 148.29,7.62 148.29,7.64 148.28,7.71 148.24,7.77 148.16,7.86 148.14,7.97 148.23,8.03 148.64,8.03 148.71,8.05 148.75,8.11 148.76,8.14 148.84,8.14 148.84,8.86 148.87,8.89 149.14,8.89
GND on BOTTOM (solid shape): 45.09,8.05 45.09,7.97 45.09,7.94 45.08,7.88 45.08,7.82 45.08,7.77 45.1,7.72 45.12,7.67 45.15,7.63 45.18,7.59 45.22,7.55 45.26,7.53 45.31,7.5 45.36,7.49 45.41,7.48 45.46,7.48 45.5,7.49 45.55,7.5 45.69,7.36 45.78,7.36 45.8,7.28 45.82,7.25 45.84,7.24 45.92,7.21 45.92,6.76 45.87,6.74 45.85,6.72 45.83,6.69 45.82,6.64 45.74,6.64 45.74,5.86 45.82,5.86 45.85,5.78 45.87,5.76 45.9,5.75 45.94,5.74 47.32,5.74 47.32,5.69 47.45,5.55 47.45,5.29 47.33,5.17 45,5.17 44.87,5.3 44.87,5.86 45.44,5.86 45.44,6.64 45.24,6.64 45.24,5.86 44.87,5.86 44.87,7.93 45.04,8.1
GND on BOTTOM (solid shape): 58.08,57.69 58.14,57.79 58.25,57.76 58.35,57.67 58.37,57.67 58.62,57.41 61.11,57.41 61.11,57.08 61.14,57.01 61.2,56.97 61.24,56.96 61.24,56.9 62.18,55.96 63.14,55.96 63.83,55.27 63.82,55.2 63.82,55.14 63.77,55.08 63.28,55.57 62.31,55.57 61.97,55.22 61.62,55.22 61.4,55.01 59.66,55.01 59.56,55.07 59.58,55.18 59.65,55.29 59.67,55.42 59.56,55.68 59.3,55.79 59.17,55.76 59.05,55.69 57.87,55.69 57.87,56.13 57.87,56.14 57.87,57.2 57.81,57.26 58.08,57.53
GND on BOTTOM (solid shape): 82.68,81.27 82.68,80.98 82.75,80.82 82.9,80.76 83.18,80.76 83.31,80.8 83.39,80.92 83.4,80.95 83.68,80.95 83.69,80.92 83.77,80.8 83.9,80.76 84.18,80.76 84.26,80.76 84.26,80.47 84.18,80.47 83.9,80.47 83.77,80.43 83.69,80.32 83.68,80.28 83.4,80.28 83.39,80.32 83.31,80.43 83.18,80.47 82.9,80.47 82.75,80.41 82.68,80.26 82.68,80 82.52,79.83 81.51,79.83 81.08,80.26 81.08,81.05 81.48,81.44 82.51,81.44
GND on BOTTOM (solid shape): 136.78,59.57 136.85,59.53 136.89,59.5 136.94,59.49 137.26,59.49 137.34,59.41 137.34,59.12 137.16,58.95 137.16,58.92 137.12,58.91 137.06,58.87 137.03,58.8 137.03,58.68 136.99,58.65 136.98,58.64 136.91,58.57 136.74,58.43 136.74,57.9 136.59,57.77 136.54,57.58 136.65,57.32 136.9,57.22 136.94,57.22 136.97,57.22 137.06,57.2 137.09,57.12 137.09,55.45 137.03,55.36 136.92,55.38 136.16,56.14 136.16,59.34 136.32,59.49 136.61,59.49 136.66,59.5 136.7,59.53
GND on BOTTOM (solid shape): 216.11,25.03 216.19,24.99 216.21,24.9 216.51,24.09 217.37,24.08 217.48,24.09 217.53,24 217.53,16.91 217.48,16.82 217.37,16.83 216.66,16.91 216.2,16.36 216.19,16.32 214.23,16.32 214.23,18.63 216.23,18.63 216.23,22.72 214.23,22.72 214.23,25.03
GND on BOTTOM (solid shape): 109.27,109.26 109.32,109.27 109.35,109.22 109.35,109.05 109.38,108.97 109.42,108.9 109.51,108.81 109.58,108.77 109.66,108.75 109.74,108.75 109.98,108.75 109.99,108.73 110.03,108.69 110.09,108.68 110.77,108.68 110.79,108.68 110.85,108.65 110.89,108.59 110.89,108.43 111.34,107.98 111.34,107.59 111.66,107.27 112.08,107.27 112.17,107.2 112.14,107.09 111.97,106.92 111.91,106.93 111.79,106.91 111.68,106.84 111.04,107.49 110.26,107.49 109.32,108.43 108.37,108.43 108.35,108.49 108.37,108.51 108.37,109.08 108.4,109.12 108.46,109.11 108.48,109.09 109.1,109.09
GND on BOTTOM (solid shape): 193.84,15.77 193.83,15.69 193.84,15.64 193.86,15.58 194.03,15.41 194.08,15.39 194.14,15.39 194.19,15.39 194.23,15.4 194.26,15.41 194.32,15.35 194.32,15.21 194.3,15.19 194.28,15.16 194.26,15.14 194.2,15.12 194.18,15.09 194.16,15.07 194.01,15.07 193.95,15.14 192.03,15.14 191.56,14.66 191.49,14.73 191.43,14.75 191.36,14.76 191.33,14.75 191.27,14.74 191.13,14.87 191.14,14.9 191.15,14.97 191.15,15.03 191.14,15.06 191.3,15.21 191.4,15.21 191.82,15.63 191.84,15.63 191.89,15.65 191.92,15.68 191.94,15.7 192.79,15.7 192.94,15.55 192.98,15.53 193.03,15.52 193.09,15.52 193.09,15.44 193.11,15.39 193.17,15.36 193.37,15.36 193.43,15.39 193.45,15.44 193.45,15.83 193.78,15.83
GND on BOTTOM (solid shape): 161.32,65.58 161.52,65.38 161.55,65.31 161.52,65.24 161.48,65.19 161.42,65.14 161.4,65.08 161.4,65.01 161.4,64.94 161.42,64.88 161.48,64.82 161.51,64.78 161.55,64.75 161.6,64.7 161.67,64.68 161.74,64.67 161.76,64.67 161.77,64.64 161.77,64.15 161.71,64.05 161.6,64.08 161.46,64.21 161.46,64.54 161.43,64.62 161.34,64.65 160.15,64.65 160.07,64.62 160.04,64.54 160.04,63.65 160.04,63.62 160.05,63.6 160.05,63.31 160.04,63.29 160.04,63.25 160,63.21 159.95,63.22 159.61,63.56 159.61,63.88 159.76,64.03 159.76,65.45 160.39,66.07 161.32,66.07
GND on BOTTOM (solid shape): 143.66,10.91 145.66,10.91 145.82,11.06 145.88,11.08 145.91,11.03 145.91,10.94 145.19,10.23 145.17,10.23 144.91,10.12 144.8,9.86 144.91,9.6 145.17,9.49 145.23,9.49 145.27,9.46 145.49,9.46 145.64,9.3 145.64,8.81 145.64,8.81 145.64,8.2 145.59,8.15 145.34,8.15 145.34,8.83 144.97,9.19 144.95,9.19 144.55,9.6 144.54,9.62 144.54,9.86 144.3,10.1 143.43,10.1 143.43,10.11 143.22,10.11 143.15,10.13 143.01,10.45 142.76,10.55 142.66,10.53 142.57,10.5 142.54,10.48 142.49,10.52 142.49,11.15 142.59,11.25 143.32,11.25
GND on BOTTOM (solid shape): 75.16,88.08 75.27,88.1 75.33,88.01 75.33,87.44 75.55,87.23 75.55,86.99 75.26,86.7 75.24,86.7 75.06,86.6 74.98,86.4 74.99,86.37 74.97,86.32 74.92,86.31 74.88,86.32 74.84,86.33 74.77,86.35 74.74,86.42 74.65,86.62 74.44,86.71 74.38,86.7 74.21,86.87 74.21,86.96 74.28,86.96 74.29,86.95 74.36,86.92 74.44,86.91 74.65,86.99 74.73,87.2 74.72,87.28 74.68,87.37 74.69,87.42 74.73,87.44 74.76,87.44 75,87.68 75,87.92
GND on BOTTOM (solid shape): 160.34,80.87 160.36,80.85 160.71,80.5 160.71,77.48 160.67,77.39 160.65,77.28 160.65,77.24 160.66,77.2 160.64,77.12 160.56,77.08 159.34,77.08 158.99,76.73 158.65,76.73 158.62,76.76 158.62,77.33 159.41,78.13 159.59,78.13 159.79,78.33 159.79,79.12 159.54,79.12 159.53,79.15 159.49,79.21 159.42,79.23 159.14,79.23 159.07,79.21 159.03,79.15 159.02,79.12 158.89,79.12 158.88,79.15 158.84,79.21 158.77,79.23 158.72,79.23 158.47,79.48 158.47,80.8 158.52,80.85 158.72,80.85 158.77,80.8 158.77,79.88 159.02,79.88 159.03,79.85 159.06,79.81 159.1,79.78 159.11,79.77 159.33,79.56 159.93,79.56 160.1,79.73 160.1,79.77 160.13,79.79 160.17,79.83 160.19,79.88 160.19,80.08 160.21,80.09 160.25,80.13 160.27,80.19 160.27,80.87
GND on BOTTOM (solid shape): 180.74,72.57 180.74,71.04 180.83,71.04 180.84,71 180.88,70.95 180.94,70.93 181.33,70.93 181.42,70.87 181.4,70.76 181.34,70.31 181.77,70.17 181.82,70.16 181.84,70.12 181.83,70.08 181.84,70.04 181.76,69.96 181.22,69.96 181.07,69.81 181,69.79 180.92,69.82 180.89,69.85 180.89,70.36 180.41,70.84 178.98,70.84 178.74,70.6 178.14,70.6 178.11,70.62 178.11,70.68 178.25,70.81 178.25,70.93 178.28,70.94 178.33,70.98 178.34,71.04 178.34,72.32 178.41,72.41 178.52,72.39 178.74,72.17 179.88,72.17 180.36,72.65 180.66,72.65
GND on BOTTOM (solid shape): 88.15,98.8 88.15,97.35 88.09,97.35 87.99,97.36 87.98,97.36 87.89,97.4 87.8,97.41 87.15,97.41 87.15,97.48 87.15,97.89 87.12,97.97 87.03,98.01 86.71,98.01 86.55,98.16 86.55,98.79 86.56,98.8 86.58,98.84 86.59,98.88 86.59,99.26 86.56,99.34 86.48,99.38 86.27,99.38 86.19,99.34 86.16,99.26 86.16,99.1 85.92,98.86 85.92,98.21 85.89,98.14 85.81,98.11 85.79,98.11 85.74,98.16 85.75,98.19 85.78,98.27 85.79,98.37 85.68,98.63 85.42,98.73 85.38,98.73 85.31,98.72 84.66,99.37 84.55,99.37 84.62,99.43 84.67,99.5 87.45,99.5
GND on BOTTOM (solid shape): 177.6,70.3 177.7,70.27 177.91,70.05 178.97,70.05 179.2,70.29 179.7,70.29 179.79,70.24 179.79,70.14 179.75,70.04 179.73,69.94 179.84,69.69 180.09,69.59 180.14,69.59 180.19,69.6 180.27,69.59 180.31,69.52 180.35,69.41 180.42,69.31 180.45,69.24 180.42,69.17 180.42,68.86 180.38,68.78 180.3,68.76 180.2,68.76 179.65,69.32 179.05,69.32 178.45,69.92 177.51,69.92 177.42,69.99 177.44,70.1 177.49,70.16 177.53,70.23
GND on BOTTOM (solid shape): 118.96,106.61 119.49,106.61 119.57,106.56 119.58,106.47 119.56,106.4 119.56,106.33 119.66,106.07 119.92,105.96 120.16,106.05 120.28,106.28 120.35,106.36 120.45,106.34 121.7,105.09 121.68,105.02 121.68,104.98 121.69,104.91 121.7,104.86 121.69,104.76 121.61,104.72 121.49,104.72 121.35,104.86 121.36,104.93 121.37,104.98 121.26,105.23 121,105.34 120.86,105.31 120.75,105.23 118.69,105.23 118.57,105.36 118.57,106.5 118.69,106.63 118.94,106.63
GND on BOTTOM (solid shape): 74.62,12.67 74.62,12.19 74.75,12.05 77.17,12.05 77.26,11.99 77.24,11.88 75.23,9.86 75.23,8.3 75.19,8.22 75.17,8.14 75.17,8.12 75.12,8.07 75.02,8.17 75.02,9.5 75.09,9.57 75.09,10.84 74.6,11.34 74.47,11.3 74.45,11.29 74.2,11.28 74.06,11.5 74.08,11.62 74.1,11.68 74.15,11.78 74.03,11.91 74.03,11.92 73.99,12 73.91,12.03 73.53,12.03 73.53,12.38 73.9,12.75 73.53,13.12 73.5,13.12 73.42,13.14 73.39,13.22 73.39,13.32 73.97,13.32
GND on BOTTOM (solid shape): 195.76,94.35 195.8,94.35 195.8,94.25 195.83,94.17 195.9,94.14 196.21,94.14 196.24,94.15 196.26,94.16 196.32,94.18 196.37,94.16 196.4,94.15 196.43,94.14 196.68,94.14 196.71,94.15 196.74,94.16 196.8,94.18 196.87,94.16 196.9,94.15 196.93,94.14 197.22,94.14 197.22,94.09 197.21,94.05 197.21,93.9 197.18,93.82 197.1,93.8 196.82,93.79 196.66,93.64 196.64,93.61 196.43,93.61 196.39,93.61 196.32,93.57 196.24,93.61 196.21,93.61 195.9,93.61 195.82,93.58 195.79,93.5 195.79,93.16 195.58,92.96 195.1,92.96 195.02,93.03 194.92,93.14 194.92,94.18 195.1,94.36 195.75,94.36
GND on BOTTOM (solid shape): 103.83,90.79 103.84,90.69 103.84,90.51 103.83,90.48 103.83,90.37 103.79,90.34 103.79,88.08 103.77,88.04 103.75,88 103.75,87.9 103.74,87.86 103.67,87.84 103.61,87.87 102.48,89 102.46,89.04 102.45,89.08 102.45,89.1 102.44,89.11 102.44,89.16 102.49,89.21 102.51,89.21 102.74,89.33 102.84,89.57 102.73,89.83 102.48,89.93 102.42,89.93 102.37,89.92 102.34,89.96 102.33,90 102.33,90.19 102.37,90.2 102.44,90.24 102.46,90.31 102.46,90.51 102.43,90.59 102.35,90.63 101.97,90.63 101.94,90.62 101.86,90.64 101.82,90.72 101.82,90.91 101.89,90.99 103.64,90.99
GND on BOTTOM (solid shape): 171.55,27.54 171.69,27.54 171.72,27.47 171.73,27.44 171.71,27.4 171.61,27.28 171.57,27.12 171.92,26.77 172.28,27.12 172.24,27.28 172.14,27.4 172.12,27.44 172.13,27.47 172.16,27.54 172.3,27.54 172.3,29.28 172.55,29.28 172.55,27.54 172.69,27.54 172.7,27.5 172.72,27.47 172.74,27.45 172.77,27.44 172.77,26.83 172.29,26.36 172.27,26.33 172.27,26.16 172.2,26.13 172.13,26.14 172.03,26.19 171.92,26.21 171.88,26.21 171.81,26.19 171.08,26.92 171.08,27.44 171.11,27.45 171.13,27.47 171.15,27.5 171.16,27.54 171.3,27.54 171.3,29.28 171.55,29.28
GND on BOTTOM (solid shape): 58.02,72.57 58.14,72.45 58.31,72.4 58.35,72.4 58.41,72.42 58.45,72.38 58.45,72.34 58.52,72.14 58.71,72.05 58.78,72.01 58.8,71.94 58.8,71.9 58.78,71.83 58.71,71.79 58.52,71.7 58.45,71.5 58.45,71.46 58.26,71.27 58.18,71.27 58.18,71.34 58.19,71.35 58.22,71.42 58.23,71.5 58.16,71.69 57.98,71.79 57.92,71.83 57.9,71.9 57.9,71.92 57.84,72.11 57.69,72.23 57.63,72.3 57.65,72.39 57.86,72.59 58.01,72.59
GND on BOTTOM (solid shape): 165.83,59.27 165.78,59.24 165.73,59.23 165.69,59.24 165.65,59.24 165.28,58.87 165.65,58.5 165.69,58.51 165.73,58.51 165.78,58.51 165.83,58.48 165.83,58.03 165.85,58 166.34,57.52 166.34,57.21 166.32,57.18 166.29,57.16 165.95,56.79 166.29,56.42 166.32,56.41 166.34,56.37 166.34,54.96 165.86,54.48 165.25,54.48 165.16,54.54 165.18,54.65 165.43,54.9 165.43,56.19 164.9,56.72 163.99,56.72 163.93,56.77 163.93,59.41 164.47,59.95 165.83,59.95
GND on BOTTOM (solid shape): 29.22,41.2 29.23,41.19 29.35,40.99 29.58,40.91 29.65,40.88 29.68,40.81 29.68,40.21 29.66,40.19 29.64,40.16 29.63,40.11 29.63,39.95 29.33,39.65 29.18,39.65 29.1,39.72 29.1,39.9 29.08,39.97 29.02,40.01 28.99,40.02 28.99,40.1 27.69,40.1 27.69,40.02 27.66,40.01 27.6,39.97 27.58,39.9 27.58,39.6 27.58,39.51 27.36,39.51 26.98,39.89 26.98,41.18 27.01,41.22 27.06,41.22 27.09,41.2 27.12,41.18 27.12,40.98 27.51,40.59 27.58,40.59 27.6,40.56 27.62,40.52 27.66,40.5 27.69,40.49 27.69,40.4 28.99,40.4 28.99,40.49 29.02,40.5 29.07,40.54 29.09,40.6 29.09,40.9 29.08,40.94 29.07,40.97 29.05,41 29.07,41.03 29.08,41.06 29.09,41.1 29.09,41.16 29.18,41.25
GND on BOTTOM (solid shape): 43.61,14.58 43.69,14.55 43.72,14.52 43.72,13.2 44.08,12.83 44.08,11.91 43.93,11.76 43.71,11.76 43.56,11.91 43.56,11.96 43.57,11.97 43.61,12.07 43.63,12.18 43.26,12.55 42.89,12.18 42.95,11.99 43.09,11.85 43.09,11.39 43.03,11.34 42.71,11.34 42.66,11.39 42.66,11.75 42.63,11.83 42.55,11.86 42.5,11.86 42.08,12.28 42.08,12.53 42.08,12.56 42.07,12.59 42.02,12.69 41.93,12.75 41.9,12.76 41.9,12.94 41.73,13.11 41.73,14.39 41.77,14.47 41.86,14.48 41.89,14.48 43.44,14.48 43.49,14.49 43.53,14.53
GND on BOTTOM (solid shape): 127.93,89.05 127.93,88.3 127.79,88.3 127.79,88.36 127.8,88.63 127.73,88.73 127.64,88.8 127.39,88.8 127.3,88.73 127.23,88.63 127.23,88.51 127.22,88.48 127.2,88.45 127.16,88.45 126.87,88.17 126.87,87.91 126.74,87.78 126.4,87.78 126.35,87.82 126.29,87.86 126.16,87.86 125.53,88.49 125.53,89.02 125.61,89.1 126.08,89.1 126.12,89.06 126.12,88.95 126.15,88.91 126.18,88.87 126.2,88.8 126.18,88.73 126.15,88.69 126.12,88.65 126.12,88.41 126.19,88.31 126.28,88.25 126.53,88.25 126.62,88.31 126.69,88.41 126.69,88.52 126.72,88.58 126.78,88.61 126.89,88.61 127.18,88.9 127.18,89.06 127.38,89.26 127.72,89.26
GND on BOTTOM (solid shape): 29.77,58.02 29.85,57.91 29.97,57.87 30.27,57.87 30.35,57.88 30.42,57.93 30.46,57.97 30.47,57.97 30.62,57.82 32.6,57.82 32.68,57.74 32.68,57.57 32.72,57.49 32.79,57.46 33,57.46 33.04,57.47 33.08,57.5 33.12,57.52 33.16,57.5 33.18,57.47 33.18,57.41 33.1,57.33 32.9,57.33 32.86,57.32 32.81,57.28 32.69,57.28 32.63,57.31 32.48,57.62 32.23,57.71 31.97,57.61 31.87,57.35 31.87,57.29 31.88,57.24 31.87,57.15 31.79,57.11 29.57,57.11 28.79,57.88 28.77,57.99 28.87,58.05 29.76,58.05
GND on BOTTOM (solid shape): 35.38,42.76 35.44,42.86 35.55,42.83 36.48,41.9 38.79,41.9 41.5,39.18 41.5,38.15 41.93,37.73 41.95,37.61 41.85,37.55 41.21,36.04 42.72,36.69 42.78,36.78 42.89,36.76 46.95,32.7 46.97,32.59 46.88,32.53 38.75,32.53 37.03,34.25 37.03,36.27 35.73,37.56 35.73,41.59 35.38,41.95
GND on BOTTOM (solid shape): 50.36,87.94 50.36,87.61 50.29,87.51 50.18,87.54 49.83,87.89 46.82,87.89 46.62,88.08 46.6,88.2 46.69,88.26 47.67,88.26 47.95,88.13 48.23,88.26 48.79,88.26 48.81,88.24 48.85,88.21 48.9,88.19 49.1,88.19 49.18,88.23 49.21,88.31 49.21,88.39 49.23,88.45 49.24,88.5 49.23,88.55 49.21,88.61 49.21,88.69 49.18,88.77 49.1,88.81 48.9,88.81 48.85,88.79 48.81,88.76 48.79,88.74 48.23,88.74 47.95,88.87 47.67,88.74 46.71,88.74 46.62,88.8 46.64,88.91 46.68,88.95 49.35,88.95
GND on BOTTOM (solid shape): 60.78,78.24 60.86,78.22 60.93,77.99 61.03,77.89 61.03,77.67 60.78,77.42 60.78,77.26 60.77,77.25 60.71,77.25 60.48,77.16 60.38,76.92 60.39,76.87 60.4,76.82 60.39,76.77 60.35,76.75 60.33,76.75 60.29,76.77 60.27,76.81 60.28,76.87 60.18,77.11 59.95,77.2 59.89,77.2 59.83,77.26 59.83,77.3 59.81,77.4 59.76,77.49 59.73,77.53 60.13,77.93 60.17,77.9 60.25,77.86 60.34,77.85 60.55,77.93 60.63,78.14 60.66,78.22 60.74,78.24
GND on BOTTOM (solid shape): 69.99,94.11 70.02,94.07 69.99,94.02 69.98,94.01 69.88,93.93 69.85,93.82 69.85,93.54 69.89,93.41 70,93.33 70.04,93.32 70.04,93.02 70,93.01 69.88,92.94 69.84,92.81 69.84,92.53 69.9,92.37 70.05,92.31 70.23,92.31 70.44,92.1 70.44,90.88 70.06,90.5 68.93,91.64 68.93,92.16 69.06,92.3 69.38,92.3 69.43,92.31 69.47,92.36 69.53,92.43 69.55,92.53 69.55,92.81 69.51,92.93 69.4,93.01 69.37,93.02 69.37,93.32 69.4,93.33 69.52,93.41 69.56,93.54 69.56,93.82 69.52,93.93 69.43,94.01 69.42,94.02 69.38,94.07 69.42,94.11 69.48,94.15 69.92,94.15
GND on BOTTOM (solid shape): 123.99,12.18 123.96,12.11 123.88,12.08 123.85,12.08 123.79,12.08 123.72,12.06 123.54,11.88 123.52,11.81 123.51,11.75 123.52,11.68 123.54,11.61 123.61,11.55 123.61,10.67 123.6,10.66 123.6,10.14 123.72,10.01 123.75,9.9 123.65,9.84 122.01,9.84 121.92,9.9 121.94,10.01 122.31,10.39 122.31,10.47 122.46,10.61 122.51,10.8 122.5,10.89 122.47,10.97 122.46,11.05 122.51,11.11 122.56,11.14 122.59,11.18 122.6,11.2 122.62,11.25 122.62,11.29 122.83,11.5 122.83,11.96 122.99,12.12 122.99,12.22 123.2,12.43 123.23,12.5 123.3,12.53 123.61,12.53 123.76,12.59 123.83,12.74 123.83,12.8 123.92,12.89 123.99,12.89
GND on BOTTOM (solid shape): 126.88,11.05 126.96,11.01 126.98,10.91 126.96,10.86 126.96,10.8 127.07,10.53 127.33,10.43 127.36,10.43 127.44,10.4 127.47,10.33 127.47,9.84 127.44,9.83 127.4,9.8 127.38,9.76 127.37,9.73 127.29,9.73 127.29,8.48 127.37,8.48 127.38,8.45 127.42,8.39 127.49,8.37 128.19,8.37 128.28,8.31 128.28,8.21 128.23,8.11 128.22,8.01 128.22,7.97 128.23,7.9 128.04,7.71 127.71,7.71 126.99,8.43 126.99,9.73 126.91,9.73 126.9,9.76 126.86,9.82 126.79,9.84 126.31,9.84 126.31,9.96 126.38,10.02 126.38,10.46 126.52,10.6 126.57,10.79 126.57,10.85 126.55,10.91 126.56,11.01 126.65,11.05
GND on BOTTOM (solid shape): 149.05,79.36 148.62,79.36 148.51,79.25 148.51,78.74 148.6,78.65 148.59,78.59 148.59,78.43 148.43,78.26 147.33,78.26 147,77.94 146.87,77.94 146.56,78.24 145.91,78.24 145.65,78.5 145.62,78.57 145.65,78.64 145.66,78.65 145.73,78.68 145.8,78.65 145.84,78.62 145.89,78.59 146.13,78.59 146.23,78.66 146.29,78.76 146.29,79 146.23,79.09 146.13,79.16 146.06,79.16 146,79.22 145.97,79.29 146,79.37 146.07,79.37 146.14,79.39 146.31,79.56 146.33,79.62 146.33,79.69 146.4,79.72 146.47,79.69 147.11,79.05 147.58,79.05 147.74,79.21 147.86,79.21 147.97,79.21 148.08,79.28 148.16,79.39 148.16,79.65 148.13,79.71 148.09,79.75 148.13,79.8 148.18,79.82 149.05,79.82
GND on BOTTOM (solid shape): 152.84,52.5 153.86,52.5 153.94,52.46 153.96,52.37 153.94,52.31 153.93,52.25 153.94,52.17 153.96,52.11 153.95,52.01 153.87,51.97 153.67,51.97 152.14,50.44 151.44,50.44 150.79,49.8 150.31,49.8 149.66,50.44 141.01,50.44 139.64,51.81 139.62,51.92 139.71,51.99 145.99,51.99 146.08,51.94 146.09,51.85 146.07,51.78 146.06,51.71 146.43,51.34 146.8,51.71 146.77,51.84 146.7,51.96 146.69,51.99 146.71,52.03 147.01,52.33 147.04,52.33 147.29,52.43 147.41,52.66 147.41,52.71 152.63,52.71
GND on BOTTOM (solid shape): 159.18,72.49 159.18,71.87 159.15,71.86 158.99,71.72 158.93,71.52 159.02,71.29 159.23,71.16 159.25,71.15 159.25,70.63 159.29,70.59 159.29,70.28 159.25,70.21 159.17,70.18 159.13,70.19 158.76,69.82 159.13,69.46 159.17,69.46 159.25,69.44 159.29,69.36 159.29,68.51 159.04,68.39 158.94,68.14 159.04,67.89 159.29,67.78 159.29,67.64 158.49,66.85 157.96,66.85 157.9,66.92 157.9,67.45 158.02,67.58 158.02,68.43 158.57,68.98 158.57,70.32 157.67,71.22 157.67,72.4 157.81,72.54 159.13,72.54
GND on BOTTOM (solid shape): 98.42,84.04 98.51,84.01 98.62,83.91 99.35,83.91 99.4,83.86 99.42,83.75 99.33,83.68 98.68,83.68 98.56,83.56 98.01,83.56 98,83.6 97.96,83.67 97.89,83.69 97.68,83.69 97.6,83.66 97.57,83.58 97.57,83.2 97.58,83.15 97.61,83.11 97.64,83.03 97.61,82.95 97.58,82.91 97.57,82.87 97.57,82.48 97.58,82.44 97.58,82.41 97.56,82.38 97.51,82.33 97.46,82.26 96.82,82.26 96.69,82.39 96.71,82.46 96.71,82.5 96.64,82.71 96.46,82.85 96.39,82.92 96.42,83.02 97.38,83.98 97.69,83.98 97.83,83.83 98.02,83.78 98.21,83.84 98.35,83.99
GND on BOTTOM (solid shape): 77.35,67.62 77.43,67.58 77.45,67.49 77.44,67.45 77.43,67.4 77.74,67.09 78.05,67.4 78.04,67.45 78.03,67.49 78.05,67.58 78.13,67.62 78.76,67.62 79.17,67.22 80.69,67.22 80.87,67.4 83.17,67.4 83.47,67.09 83.47,66.43 83.38,66.34 83.01,66.34 82.92,66.38 82.91,66.48 82.94,66.55 82.89,66.81 82.75,66.95 82.73,66.96 82.73,66.97 82.65,66.99 82.58,67 82.39,66.94 82.25,66.8 80.3,66.8 79.54,66.04 77.5,66.04 77.49,66.06 77.49,66.82 77.15,67.15 77.17,67.2 77.18,67.21 77.23,67.3 77.25,67.4 77.24,67.45 77.23,67.49 77.25,67.58 77.33,67.62
GND on BOTTOM (solid shape): 131.12,85.71 131.15,85.79 131.24,85.81 131.28,85.81 131.36,85.79 131.4,85.72 131.4,85.63 131.42,85.54 131.42,85.35 131.39,85.32 131.39,84.8 131.72,84.47 131.72,84.37 131.73,84.33 131.73,84.27 131.7,84.22 131.67,84.22 131.61,84.22 131.54,84.2 131.45,84.14 131.39,84.05 131.36,84.05 131.23,83.92 131.09,83.91 131.05,83.93 131.05,83.99 131.03,84.07 130.96,84.16 130.81,84.24 130.8,84.28 130.82,84.37 130.81,84.5 130.77,84.56 130.75,84.63 130.78,84.7 130.99,84.91 130.99,85.33 131.12,85.46
GND on BOTTOM (solid shape): 145.63,94.72 145.94,94.72 145.95,94.72 146.03,94.7 146.06,94.62 146.06,94.4 145.71,94.05 145.63,94.05 145.55,94.01 145.52,93.93 145.52,92.74 145.52,92.71 145.53,92.69 145.53,92.64 145.48,92.61 145.44,92.61 145.39,92.63 145.39,92.68 145.4,92.71 145.4,92.74 145.4,93.93 145.37,94.01 145.29,94.05 144.98,94.05 144.9,94.01 144.87,93.93 144.87,92.74 144.87,92.71 144.89,92.66 144.86,92.64 144.86,91.79 144.8,91.69 144.69,91.72 144.3,92.11 144.3,94.72 144.64,94.72 144.66,94.72 144.73,94.71 144.78,94.65 144.91,94.45 145.13,94.37 145.36,94.45 145.49,94.65 145.53,94.71 145.61,94.72
GND on BOTTOM (solid shape): 172.23,17.29 172.23,17.29 172.39,17.14 175.05,17.14 175.12,17.11 175.15,17.03 175.15,16.99 175.51,16.63 175.88,16.99 175.87,17.03 175.9,17.11 175.98,17.14 176.5,17.14 176.66,17.29 177.45,17.29 177.65,17.09 177.65,17.07 177.68,16.99 177.76,16.96 178.14,16.96 178.17,16.96 178.33,16.96 178.56,16.73 178.56,14.86 178.97,14.45 181,14.45 181.1,14.35 181.1,13.13 180.92,12.95 178.64,12.95 178.51,12.82 178.13,12.82 177.9,13.05 177.9,16.3 177.79,16.41 176.08,16.41 175.86,16.41 175.82,16.39 175.78,16.33 175.78,16.3 175.78,14.72 175.73,14.68 175.68,14.65 175.67,14.64 175.64,14.62 174.37,14.62 173.13,13.38 173.02,13.35 172.96,13.45 172.69,13.72 172.69,16.19 172.41,16.47 171.37,16.47 170.61,17.22 170.61,17.95 170.76,18.1 171.42,18.1
GND on BOTTOM (solid shape): 60.37,72.89 60.41,72.87 60.42,72.82 60.41,72.78 60.41,72.73 60.5,72.5 60.74,72.4 60.78,72.4 60.85,72.38 60.89,72.31 60.97,72.13 61.15,72.05 61.22,72.02 61.25,71.86 61.04,71.86 60.95,71.82 60.93,71.79 60.85,71.73 60.76,71.7 60.71,71.7 60.67,71.68 60.61,71.67 60.55,71.7 60.46,71.76 60.36,71.79 60.3,71.82 60.17,72.09 59.96,72.18 59.95,72.19 59.83,72.3 59.83,72.35 59.86,72.42 59.94,72.45 59.94,72.45 60.17,72.55 60.27,72.78 60.26,72.85 60.3,72.89
GND on BOTTOM (solid shape): 33.15,89.19 33.22,89.28 33.33,89.26 34.11,88.48 34.13,88.37 34.03,88.31 34.02,88.31 32.65,86.94 32.57,86.87 32.52,86.79 32.42,86.69 32.42,85.5 32.38,85.45 32.37,85.41 32.37,85.02 32.39,84.97 32.42,84.93 32.45,84.92 32.45,84.28 32.36,84.19 31.5,84.19 31.35,84.04 31.35,82.65 31.57,82.43 32.56,82.43 32.6,82.48 32.71,82.5 32.78,82.41 32.78,82.33 32.71,82.24 32.6,82.26 32.56,82.31 31.49,82.31 30.83,82.97 30.77,82.97 30.59,83.06 30.5,83.24 30.14,83.24 29.82,83.57 29.82,85.55 29.74,85.63 29.61,85.75 28.75,85.75 28.63,85.87 28.63,86.88 28.88,86.88 28.88,86.34 29.13,86.34 29.13,86.88 29.38,86.88 29.38,86.34 29.63,86.34 29.63,86.88 29.88,86.88 29.88,86.34 30.13,86.34 30.13,86.74 30.2,86.81 30.2,86.81 30.22,86.84 31.16,86.84 31.29,86.97 31.29,87.55 31.43,87.69 31.87,87.69 32.07,87.89 32.07,88.11 32.15,88.2 32.79,88.2 33.15,88.56
GND on BOTTOM (solid shape): 202.26,41.75 202.26,40.38 201.93,40.05 201.89,40.05 201.83,40.07 201.78,40.07 201.73,40.07 201.67,40.05 201.59,40.05 201.51,40.01 201.47,39.93 201.47,39.84 201.24,39.61 201.22,39.61 201.02,39.56 200.89,39.41 200.82,39.35 200.73,39.37 200.58,39.42 200.44,39.34 200.4,39.33 200.36,39.34 200.34,39.36 200.33,39.4 200.34,39.44 200.42,39.57 200.38,39.72 200.36,39.78 200.39,39.84 200.43,39.94 200.44,40.04 200.47,40.13 200.56,40.16 200.7,40.18 200.81,40.28 200.88,40.33 200.96,40.31 201.46,40.39 201.41,40.89 201.41,41.67 201.6,41.86 202.15,41.86
GND on BOTTOM (solid shape): 87.25,82.89 87.28,82.81 87.36,82.77 87.55,82.77 87.64,82.71 87.62,82.61 87.56,82.5 87.54,82.37 87.54,82.33 87.55,82.26 87.43,82.14 87.06,82.14 86.67,82.53 85.84,82.53 85.71,82.67 85.52,82.72 85.33,82.67 85.2,82.53 85.04,82.53 85.04,82.58 85,82.65 84.92,82.69 84.21,82.69 84.13,82.65 84.1,82.57 84.1,82.48 84.03,82.38 83.92,82.4 83.67,82.66 83.65,82.77 83.74,82.83 85.03,82.83 85.26,83.06 85.52,83.06 85.66,82.92 85.85,82.86 86.11,82.97 86.22,83.22 86.25,83.29 86.31,83.32 86.49,83.38 86.61,83.52 87.25,83.52
GND on BOTTOM (solid shape): 168.16,81.53 168.27,81.55 168.33,81.46 168.33,80.6 168.24,80.5 168.24,79.11 168.04,78.91 168.04,78.44 167.96,78.42 167.93,78.4 167.68,78.4 167.65,78.38 167.62,78.36 167.56,78.36 167.54,78.41 167.54,78.42 167.54,78.73 167.53,78.76 167.51,78.83 167.53,78.89 167.54,78.92 167.54,79.23 167.53,79.26 167.52,79.3 167.51,79.33 167.52,79.36 167.53,79.39 167.54,79.42 167.54,79.73 167.52,79.8 167.46,79.84 167.42,79.85 167.42,79.92 166.53,79.92 166.53,79.85 166.5,79.84 166.46,79.81 166.43,79.78 166.42,79.75 166.35,79.75 166.22,79.62 165.84,79.62 165.59,79.87 165.59,80.71 165.66,80.8 165.77,80.78 166.14,80.4 166.42,80.4 166.43,80.37 166.46,80.34 166.5,80.31 166.53,80.3 166.53,80.23 167.42,80.23 167.42,80.3 167.46,80.31 167.52,80.36 167.54,80.42 167.54,80.73 167.53,80.76 167.52,80.8 167.51,80.83 167.52,80.86 167.53,80.89 167.54,80.92 167.54,81.23 167.53,81.26 167.51,81.33 167.54,81.4 168.03,81.4
GND on BOTTOM (solid shape): 80.25,78.56 80.32,78.66 80.43,78.63 80.85,78.21 82.49,78.21 82.68,78.01 82.68,77.75 82.75,77.6 82.9,77.53 83.18,77.53 83.31,77.58 83.39,77.69 83.4,77.73 83.68,77.73 83.69,77.69 83.77,77.58 83.9,77.53 84.18,77.53 84.26,77.54 84.26,77.25 84.18,77.25 83.9,77.25 83.77,77.2 83.69,77.09 83.68,77.06 83.4,77.06 83.39,77.09 83.31,77.2 83.18,77.25 82.9,77.25 82.75,77.19 82.68,77.03 82.68,76.77 82.52,76.61 81.9,76.61 81.81,76.65 81.8,76.75 81.82,76.81 81.83,76.88 81.72,77.14 81.46,77.25 81.25,77.18 81.11,77 81.04,76.94 80.94,76.96 80.25,77.65
GND on BOTTOM (solid shape): 141.93,67.48 141.95,67.46 141.94,67.38 141.98,67.25 142.08,67.17 142.1,67.15 142.13,67.11 142.12,67.08 142.12,66.84 142.14,66.8 142.16,66.77 142.14,66.72 142.09,66.69 141.98,66.6 141.94,66.47 142,66.32 142.14,66.24 142.21,66.19 142.22,66.11 142.14,66.02 141.93,66.23 141.88,66.24 141.82,66.25 141.76,66.24 141.71,66.23 141.54,66.07 141.5,66.06 141.46,66.07 141.3,66.23 141.21,66.25 141.12,66.24 141.07,66.3 141.08,66.37 141.1,66.42 141.1,66.51 141.09,66.55 141.08,66.58 141.12,66.62 141.17,66.63 141.22,66.65 141.25,66.68 141.33,66.73 141.39,66.81 141.39,66.82 141.42,66.93 141.4,67.04 141.43,67.12 141.51,67.15 141.52,67.15 141.69,67.22 141.75,67.38 141.75,67.42 141.82,67.48
GND on BOTTOM (solid shape): 67.93,85.26 67.93,85.2 68.02,84.97 68.26,84.87 68.28,84.87 68.35,84.85 68.39,84.78 68.48,84.59 68.68,84.51 68.76,84.48 68.78,84.4 68.79,84.32 68.72,84.25 68.68,84.25 68.55,84.22 68.45,84.14 68.42,84.12 68.38,84.12 68.34,84.14 68.29,84.14 68.07,84.14 67.97,84.22 67.85,84.25 67.78,84.29 67.75,84.36 67.75,84.38 67.65,84.61 67.42,84.71 67.35,84.7 67.29,84.76 67.29,84.82 67.31,84.86 67.35,84.88 67.39,84.87 67.42,84.87 67.65,84.97 67.75,85.2 67.75,85.2 67.78,85.28 67.85,85.31 67.88,85.31
GND on BOTTOM (solid shape): 127.29,82.99 127.32,82.95 127.41,82.85 127.58,82.82 127.63,82.83 127.68,82.86 127.71,82.89 127.77,82.83 127.71,82.78 127.69,82.72 127.69,82.66 127.69,82.6 127.71,82.55 127.88,82.37 127.94,82.36 127.94,82.28 127.7,82.28 127.69,82.27 127.62,82.27 127.56,82.24 127.23,81.91 127.2,81.84 127.16,81.8 127.12,81.78 127.07,81.78 126.97,81.82 126.92,81.93 126.93,81.97 126.94,82.01 126.96,82.15 126.86,82.26 126.84,82.28 126.84,82.32 126.85,82.36 126.85,82.39 126.78,82.56 126.62,82.62 126.58,82.62 126.47,82.74 126.46,82.78 126.47,82.82 126.51,82.83 126.62,82.81 126.74,82.85 126.83,82.95 126.86,82.98 126.9,83.01 126.95,82.98 127.2,82.98 127.25,83.01
GND on BOTTOM (solid shape): 213.16,31 214.27,29.89 215.38,31 215.38,31.09 216.83,31.09 216.83,28.9 217.03,28.31 217.53,27.94 217.53,25.41 217.48,25.32 217.37,25.33 216.87,25.46 216.4,25.24 216.29,25.21 216.23,25.31 216.23,27.97 214.27,27.97 214.27,26.93 214.25,26.89 214.22,26.88 214.14,26.88 213.43,26.88 213.09,26.79 212.84,26.53 211.58,26.53 211.58,27.58 211.71,27.71 212.65,27.71 212.95,28.01 212.95,28.38 213.02,28.54 213.04,28.7 213.04,29.46 213.05,29.48 213.05,31.09 213.16,31.09
GND on BOTTOM (solid shape): 178.56,18.68 178.56,18.6 178.54,18.56 178.5,18.56 178.39,18.6 178.29,18.61 178.19,18.6 178.09,18.55 177.93,18.55 177.89,18.51 177.72,18.64 177.57,18.67 177.47,18.65 177.37,18.61 176.57,18.61 176.39,18.43 176.34,18.41 176.29,18.4 176.16,18.54 175.97,18.59 175.76,18.53 175.63,18.35 175.55,18.34 175.48,18.39 175.35,18.54 175.15,18.6 174.96,18.54 174.82,18.4 174.75,18.34 174.67,18.37 174.53,18.53 174.33,18.59 174.09,18.5 173.97,18.28 173.96,18.24 173.96,18.12 172.8,18.12 172.12,18.8 172.1,18.91 172.19,18.98 178.26,18.98
GND on BOTTOM (solid shape): 45.31,95.06 45.27,94.97 45.26,94.87 45.24,94.83 45.19,94.82 45.15,94.83 45.11,94.84 45.05,94.87 45.02,94.93 44.74,95.18 44.46,94.92 44.43,94.86 44.35,94.83 44.09,94.72 44,94.4 43.96,94.38 43.93,94.38 43.89,94.4 43.88,94.44 43.8,94.73 43.53,94.84 43.45,94.86 43.42,94.93 43.12,95.18 42.86,94.89 42.86,94.87 42.78,94.79 42.72,94.8 42.65,94.83 42.62,94.9 42.6,95 42.55,95.08 42.54,95.11 42.54,95.13 42.56,95.15 42.81,95.4 44.97,95.4
GND on BOTTOM (solid shape): 177.39,72.83 177.42,72.75 177.38,72.67 177.36,72.65 177.34,72.62 177.33,72.59 177.24,72.59 177.24,71.04 177.33,71.04 177.34,71 177.36,70.97 177.4,70.94 177.43,70.93 177.43,70.81 177.57,70.68 177.57,70.55 177.49,70.55 177.47,70.57 177.35,70.67 177.19,70.71 176.94,70.6 176.84,70.35 176.9,70.15 177.06,70.02 177.09,70.01 177.09,69.92 176.93,69.92 176.61,70.24 176.61,70.68 176.75,70.81 176.75,70.93 176.78,70.94 176.82,70.97 176.84,71 176.85,71.04 176.94,71.04 176.94,72.59 176.85,72.59 176.84,72.62 176.8,72.67 176.74,72.69 175.94,72.69 175.88,72.67 175.84,72.62 175.83,72.59 175.74,72.59 175.74,71.04 175.83,71.04 175.84,71 175.86,70.97 175.9,70.94 175.93,70.93 175.93,70.81 176.07,70.68 176.07,70.07 176.03,70.03 175.98,70.04 175.96,70.06 175.73,70.06 175.1,70.68 175.1,70.86 175.17,70.93 175.24,70.93 175.3,70.95 175.34,71 175.35,71.04 175.44,71.04 175.44,72.59 175.39,72.59 175.39,72.68 175.43,72.69 175.64,72.81 175.72,73.04 175.71,73.08 175.7,73.15 175.8,73.25 176.97,73.25
GND on BOTTOM (solid shape): 139.8,17.64 139.83,17.64 139.9,17.59 140.05,17.59 140.06,17.6 140.09,17.6 140.17,17.58 140.21,17.5 140.21,17.35 140.24,17.26 140.32,17.23 140.97,17.23 141.05,17.26 141.09,17.32 141.09,17.36 141.46,17.36 141.46,17.22 141.49,17.14 141.57,17.11 143.33,17.11 143.42,17.01 143.36,16.91 143.34,16.79 143.35,16.71 143.38,16.63 143.37,16.53 143.28,16.49 142.22,16.49 142.06,16.32 142.06,15.99 139.88,15.99 139.73,15.84 139.71,15.82 139.66,15.77 138.61,15.77 138.53,15.69 137.54,15.69 137.46,15.77 137.46,16.2 137.11,16.56 136.67,16.56 136.64,16.6 136.59,16.62 136.55,16.66 136.55,16.89 136.7,17.04 138.12,17.04 138.3,16.86 138.29,16.82 138.29,16.78 138.65,16.42 139.02,16.78 139.01,16.85 138.99,16.92 139.11,17.04 139.16,17.04 139.17,17.07 139.2,17.1 139.2,17.14 139.23,17.19 139.23,17.24 139.23,17.5 139.32,17.59 139.42,17.59 139.45,17.62 139.48,17.63 139.52,17.64
GND on BOTTOM (solid shape): 202.75,28.1 202.78,28.01 202.77,27.97 202.77,27.28 203.11,26.95 203.11,26.37 203.61,25.87 206.5,25.87 206.76,25.61 207.04,25.61 207.09,25.58 207.08,25.53 207.05,25.5 207.05,24.7 206.93,24.58 205.8,24.58 205.7,24.48 205.7,24.37 205.73,24.33 205.73,24.07 205.79,23.92 205.94,23.86 206.21,23.86 206.82,23.24 206.84,23.13 206.75,23.07 206.03,23.07 204.96,24.13 204.93,24.17 204.89,24.21 204.42,24.68 204.25,24.85 203.83,24.85 203.35,25.33 202.72,25.33 202.67,25.28 202.56,25.28 202.48,25.32 202.46,25.4 202.46,25.66 202.46,25.84 202.47,25.85 202.47,25.94 202.47,25.98 202.47,26.54 202.47,26.55 202.47,26.76 202.47,26.77 202.51,26.87 202.52,26.97 202.51,27.08 202.47,27.19 202.47,27.45 202.35,27.56 202.35,27.77 202.43,27.85 202.46,27.97 202.46,28.03 202.49,28.11 202.58,28.13 202.62,28.12 202.66,28.13
GND on BOTTOM (solid shape): 62.87,85.31 62.94,85.28 62.97,85.2 62.97,85.2 63.07,84.97 63.3,84.87 63.39,84.88 63.43,84.84 63.43,84.8 63.5,84.6 63.7,84.51 63.77,84.47 63.79,84.4 63.79,84.36 63.77,84.29 63.7,84.25 63.58,84.22 63.49,84.14 63.46,84.12 63.42,84.12 63.38,84.14 63.33,84.14 63.27,84.14 63.22,84.14 63.18,84.12 63.14,84.12 63.11,84.14 63.01,84.22 62.88,84.25 62.84,84.25 62.77,84.32 62.78,84.39 62.68,84.63 62.45,84.72 62.39,84.72 62.35,84.73 62.33,84.77 62.33,84.81 62.35,84.85 62.39,84.86 62.46,84.85 62.69,84.95 62.79,85.18 62.78,85.26 62.83,85.31
GND on BOTTOM (solid shape): 163.9,77.09 163.91,77.08 164,76.96 164.14,76.89 164.15,76.88 164.57,76.47 164.57,75.06 165.63,73.99 165,73.37 165,73.18 164.99,73.15 164.95,73.13 164.71,73.13 164.16,72.58 164.16,72.56 164.16,70.31 164.69,69.78 165.37,69.78 165.48,69.67 165.48,69.61 165.48,69.61 165.48,69.51 166.34,68.65 166.34,68.33 166.34,68.33 166.24,68.29 166.15,68.22 166.07,68.19 165.99,68.25 165.85,68.39 165.67,68.44 165.41,68.33 165.3,68.07 165.35,67.88 165.5,67.74 165.53,67.71 165.53,67.68 165.5,67.59 165.49,67.51 165.5,67.44 165.44,67.34 165.32,67.36 165.2,67.48 164.65,67.48 164.05,68.07 164.05,71.41 163.55,71.91 163.52,71.98 163.5,72.03 163.5,72.33 163.59,72.48 163.63,72.65 163.56,72.88 163.39,73.04 163.38,73.04 163.05,73.38 163.05,74.33 163.24,74.33 163.78,74.87 163.78,77.05 163.86,77.13
GND on BOTTOM (solid shape): 31.63,35.43 31.63,33.16 31.9,32.89 31.91,32.87 31.92,32.8 31.88,32.74 31.76,32.61 31.71,32.43 32.08,32.07 32.44,32.43 32.43,32.54 32.38,32.64 32.37,32.75 32.46,32.8 33.12,32.8 33.49,33.17 34.75,33.17 34.85,33.07 34.85,32.66 34.67,32.48 34.57,32.48 34.49,32.51 34.41,32.52 34.34,32.51 34.24,32.48 34.15,32.4 34.1,32.34 33.68,31.92 31.05,31.92 31.05,32.32 31.02,32.4 30.94,32.43 30.84,32.43 30.84,32.95 30.74,33.04 30.74,34.12 30.71,34.19 30.55,34.22 30.55,34.28 30.56,34.29 30.62,34.43 30.64,34.58 30.6,34.78 30.49,34.96 30.6,35.14 30.64,35.34 30.63,35.42 30.62,35.49 30.63,35.58 30.71,35.62 31.44,35.62
GND on BOTTOM (solid shape): 166.14,87.61 166.21,87.58 166.24,87.5 166.24,87.49 166.32,87.27 166.51,87.14 166.58,87.06 166.55,86.96 166.45,86.84 166.42,86.68 166.5,86.45 166.7,86.32 166.7,86.03 166.58,85.9 166.54,85.73 166.64,85.46 166.9,85.36 166.95,85.36 167.01,85.37 167.32,85.07 167.46,85.07 167.46,84.98 167.43,84.97 167.36,84.94 167.31,84.89 167.24,84.86 167.16,84.89 167.04,84.97 166.9,85 166.71,84.95 166.57,84.8 165.76,84.8 164.34,83.38 164.34,83.02 164.28,82.93 164.17,82.95 163.15,83.97 163.16,84.04 163.06,84.34 162.79,84.45 162.78,84.45 162.71,84.47 162.67,84.55 162.67,85.67 164.61,87.61
GND on BOTTOM (solid shape): 198.5,97.5 198.55,97.42 198.55,96.72 198.44,96.61 198.44,95.12 197.82,94.49 197.82,94.28 197.79,94.21 197.71,94.18 197.52,94.17 197.51,94.16 197.4,94.16 197.4,94.78 197.29,94.78 197.28,94.81 197.26,94.85 197.22,94.87 197.11,94.98 197.11,95.08 197.16,95.13 197.18,95.13 197.41,95.24 197.5,95.48 197.42,95.71 197.2,95.83 197.19,95.84 197.14,95.88 197.24,95.99 197.6,95.99 197.61,95.95 197.74,95.75 197.97,95.67 198.22,95.78 198.33,96.04 198.3,96.18 198.22,96.3 198.19,96.38 198.22,96.45 198.3,96.57 198.33,96.71 198.24,96.95 198.01,97.07 197.99,97.07 197.94,97.13 197.94,97.33 197.92,97.36 197.9,97.39 197.92,97.43 197.92,97.47 197.97,97.47 198.06,97.45 198.15,97.45 198.28,97.46 198.4,97.51
GND on BOTTOM (solid shape): 73.19,27.34 73.23,27.41 73.31,27.44 73.36,27.43 73.44,27.35 73.44,27.11 73.45,27.08 73.47,27.05 73.71,26.8 73.71,26.36 73.68,26.29 73.6,26.26 73.24,25.91 73.6,25.55 73.77,25.59 73.9,25.71 73.98,25.75 74.07,25.71 74.19,25.59 74.36,25.55 74.5,25.58 74.61,25.65 74.62,25.66 74.73,25.68 74.79,25.59 74.79,25.03 74.74,24.94 74.64,24.94 74.54,24.98 74.45,25 74.41,25 74.35,24.98 74.08,25.25 74.04,25.26 72.38,25.26 72.26,25.38 72.24,25.47 72.3,25.55 72.4,25.59 72.48,25.66 72.56,25.68 72.62,25.73 73.13,26.23 73.17,26.3 73.19,26.38
GND on BOTTOM (solid shape): 182.22,26.52 182.22,26.36 182.59,25.99 183.38,25.99 183.43,25.98 183.47,25.96 183.52,25.91 183.59,25.87 183.84,25.87 183.91,25.9 183.94,25.9 184.01,25.87 184.03,25.8 184.03,25.78 184.41,25.4 184.43,25.28 184.33,25.23 183.84,25.16 183.46,24.86 183.38,24.81 183.3,24.84 183.28,24.86 183.26,24.9 183.28,24.94 183.29,24.95 183.38,25.07 183.41,25.22 183.06,25.58 182.7,25.22 182.71,25.15 182.31,24.75 182.31,21.88 182.18,21.75 182.09,21.72 182.01,21.78 181.98,21.85 181.94,21.9 181.91,21.97 181.93,22.04 181.99,22.41 181.68,22.63 181.61,22.66 181.58,22.73 181.58,25.82 181.58,25.82 181.58,26.41 181.81,26.64 182.09,26.64
GND on BOTTOM (solid shape): 47.89,91.84 47.89,91.43 47.66,91.2 47.59,91.11 47.55,91 47.55,90.96 46.52,90.96 46.52,91.01 46.42,91.24 46.19,91.33 46.06,91.3 45.95,91.23 45.6,91.23 45.53,91.26 45.4,91.55 45.17,91.64 45.13,91.64 45.08,91.63 45.04,91.64 45.02,91.69 45.02,91.73 45.08,91.79 45.15,91.78 45.19,91.77 45.42,91.87 45.52,92.1 45.52,92.12 45.54,92.19 45.6,92.23 45.64,92.24 45.73,92.28 45.78,92.32 45.96,92.5 45.98,92.51 46.18,92.62 46.26,92.83 46.17,93.07 45.93,93.16 45.72,93.08 45.61,92.88 45.6,92.86 45.52,92.78 45.5,92.78 45.45,92.79 45.44,92.84 45.45,92.89 45.46,92.94 45.41,93.1 45.29,93.23 45.25,93.27 45.34,93.36 46.37,93.36
GND on BOTTOM (solid shape): 129,86.54 129.06,86.55 129.09,86.5 129.09,85.93 129.29,85.73 129.29,85.66 129.34,85.54 129.47,85.48 129.52,85.49 129.6,85.47 129.61,85.31 129.52,85.29 129.47,85.3 129.3,85.23 129.24,85.06 129.24,85.01 129.26,84.96 129.28,84.92 129.01,84.66 129.01,84.28 128.98,84.25 128.77,84.25 128.67,84.18 128.61,84.09 128.61,83.99 128.56,83.94 128.49,83.92 128.45,83.92 128.39,83.92 128.34,83.9 128.27,83.89 128.22,83.92 128.22,83.94 128.21,84 128.2,84.06 128.15,84.1 128.17,84.16 128.21,84.2 128.31,84.29 128.35,84.41 128.35,84.47 128.33,84.52 128.31,84.56 128.53,84.78 128.53,85.33 128.63,85.43 128.63,85.72 128.67,85.8 128.85,85.82 128.94,85.88 128.98,85.99 128.98,86.51
GND on BOTTOM (solid shape): 45.79,78.4 47.09,77.1 47.12,77 47.04,76.93 46.86,76.81 46.79,76.61 46.79,76.53 46.75,76.53 46.55,76.32 46.46,76.3 46.38,76.36 46.26,76.5 46.08,76.56 45.96,76.54 45.87,76.48 45.56,76.48 45.44,76.36 45.43,76.36 45.31,76.26 45.26,76.1 45.26,76.06 45.27,76.03 45.25,75.94 45.17,75.9 45.09,75.9 44.77,75.58 44.72,75.58 44.68,75.6 44.67,75.64 44.67,75.72 44.7,75.79 44.76,75.82 44.95,75.91 45.02,76.1 45,76.19 44.96,76.27 44.93,76.31 45.32,76.69 45.32,77.15 45.51,77.34 45.58,77.33 45.81,77.43 45.91,77.66 45.82,77.89 45.6,77.99 45.52,78.06 45.54,78.17 45.59,78.22 45.59,78.35 45.61,78.38
GND on BOTTOM (solid shape): 177.39,81.15 177.46,81.07 177.53,81.01 177.56,80.99 177.56,80.93 177.58,80.86 177.65,80.82 177.69,80.82 177.69,80.73 177.68,80.72 177.68,80.24 177.63,80.22 177.6,80.21 177.57,80.22 177.53,80.24 177.49,80.25 177.19,80.25 177.12,80.23 177.08,80.17 177.07,80.14 176.99,80.14 176.99,78.59 177.07,78.59 177.08,78.55 177.12,78.49 177.19,78.47 177.49,78.47 177.53,78.48 177.57,78.5 177.6,78.51 177.68,78.46 176.65,77.42 176.65,76.91 176.79,76.54 177.14,76.35 177.18,76.34 177.18,76.27 177.18,76.27 177.18,76.14 177.48,75.85 177.45,75.82 177.4,75.8 175.92,75.8 175.83,75.87 175.85,75.98 175.93,76.05 175.93,76.85 175.96,76.86 176.14,76.99 176.21,77.2 176.21,77.22 176.24,77.24 176.24,77.97 176.14,78.07 176.12,78.18 176.22,78.24 176.27,78.24 176.49,78.47 176.51,78.47 176.57,78.5 176.6,78.55 176.61,78.59 176.69,78.59 176.69,80.14 176.61,80.14 176.6,80.18 176.61,80.27 176.69,80.32 176.83,80.32 177.12,80.61 177.12,80.89 177.15,80.9 177.26,80.98 177.3,81.1 177.3,81.17 177.37,81.17
GND on BOTTOM (solid shape): 135.18,12.62 135.18,12.16 135.05,12.04 134.92,12.04 134.2,11.31 134.2,10.98 134.16,10.97 133.95,10.84 133.87,10.61 133.9,10.48 133.98,10.36 134.01,10.32 133.51,9.81 133.43,9.78 133.36,9.81 133.24,9.9 133.1,9.93 132.92,9.88 132.79,9.76 132.74,9.72 132.69,9.72 132.55,9.87 132.36,9.92 132.3,9.92 132.24,9.9 132.21,9.94 131.68,9.94 131.58,9.84 131.49,9.84 131.42,9.82 131.38,9.76 131.37,9.73 131.29,9.73 131.29,8.44 130.99,8.44 130.99,9.73 130.91,9.73 130.9,9.76 130.86,9.82 130.79,9.84 130.7,9.84 130.6,9.9 130.62,10.01 130.88,10.27 130.92,10.3 130.94,10.3 131.06,10.37 131.14,10.39 131.23,10.37 131.31,10.32 131.34,10.3 132.88,10.3 132.89,10.3 133.89,11.31 133.89,11.31 134,11.42 134,12.04 134.03,12.07 134.04,12.1 134.06,12.14 134.13,12.16 134.46,12.16 134.53,12.18 134.66,12.32 134.68,12.36 134.74,12.48 134.85,12.55 134.88,12.57 134.91,12.59 134.94,12.62 134.95,12.65 135.15,12.65
GND on BOTTOM (solid shape): 129.37,84.21 129.42,84.19 129.47,84.18 129.51,84.18 129.55,84.15 129.55,83.92 129.59,83.85 129.64,83.79 129.66,83.72 129.62,83.65 129.57,83.6 129.53,83.53 129.53,83.35 129.49,83.28 129.41,83.27 129.36,83.27 129.13,83.04 129.36,82.81 129.39,82.81 129.47,82.79 129.51,82.72 129.51,82.64 129.48,82.61 129.4,82.62 129.36,82.62 129.2,82.56 129.13,82.4 129.14,82.35 129.15,82.31 129.06,82.22 128.73,82.22 128.66,82.29 128.67,82.34 128.68,82.4 128.61,82.56 128.45,82.62 128.43,82.62 128.36,82.65 128.32,82.71 128.31,82.76 128.35,82.8 128.42,82.81 128.45,82.81 128.67,82.97 128.58,83.23 128.58,83.34 128.52,83.4 128.58,83.47 128.58,83.51 128.64,83.56 128.68,83.66 128.71,83.68 128.74,83.7 128.77,83.68 129.01,83.68 129.11,83.75 129.17,83.84 129.17,84.06 129.34,84.22
GND on BOTTOM (solid shape): 187.54,21.42 187.6,21.33 187.6,21.04 187.63,20.98 187.66,20.94 188.96,19.63 188.96,19.06 188.97,19.05 188.97,18.99 188.98,18.92 189.02,18.87 189.28,18.61 189.34,18.57 189.4,18.56 189.44,18.56 189.63,18.37 189.6,18.33 189.56,18.29 189.54,18.25 189.51,18.22 189.48,18.22 189.36,18.23 189.3,18.25 189.25,18.25 188.99,18.25 188.99,18.26 188.75,18.26 188.74,18.28 188.71,18.31 188.68,18.34 188.65,18.35 188.65,18.53 188.64,18.55 188.62,18.62 188.58,18.68 188.08,19.18 188,19.23 187.91,19.25 187.16,19.25 187.11,19.24 187.06,19.23 187.03,19.23 186.64,18.83 186.55,18.83 186.49,18.87 186.45,18.92 186.44,18.98 186.56,19.05 186.63,19.17 186.63,19.42 186.6,19.48 186.55,19.54 186.54,19.57 186.55,19.61 186.59,19.66 186.62,19.71 186.62,19.97 186.55,20.08 186.43,20.16 186.42,20.22 186.45,20.27 186.59,20.41 186.59,20.7 186.84,20.7 186.95,20.78 187.02,20.89 187.02,21.14 187.01,21.16 187.05,21.22 187.08,21.28 187.13,21.33 187.19,21.34 187.23,21.34 187.34,21.36 187.43,21.41
GND on BOTTOM (solid shape): 42.16,94.69 42.22,94.65 42.3,94.62 42.36,94.58 42.38,94.51 42.38,94.47 42.48,94.24 42.71,94.14 42.75,94.14 42.82,94.12 42.86,94.06 42.96,93.89 43.14,93.82 43.34,93.9 43.42,94.1 43.42,94.13 43.48,94.19 43.63,94.15 43.66,94.09 43.74,93.91 43.91,93.82 43.93,93.82 44.14,93.61 44.14,92.99 43.96,92.81 43.85,92.92 43.85,92.94 43.74,93.14 43.52,93.22 43.29,93.12 43.19,92.89 43.2,92.84 43.19,92.8 43.15,92.78 43.12,92.78 43.08,92.8 43.07,92.84 43.07,92.9 42.97,93.13 42.74,93.23 42.72,93.23 42.65,93.26 42.62,93.32 42.53,93.51 42.34,93.58 42.17,93.53 42.07,93.39 42.07,93.37 42.04,93.34 41.93,93.32 41.87,93.42 41.87,94.46 42.12,94.72
GND on BOTTOM (solid shape): 139.79,92.36 139.82,92.34 139.86,92.34 139.86,92.15 139.83,92.1 139.82,92.07 139.82,91.87 139.86,91.78 139.94,91.75 140.3,91.75 140.64,91.41 140.64,90.45 140.61,90.44 140.41,90.31 140.33,90.09 140.39,89.9 140.53,89.77 140.53,89.11 140.49,89.03 140.39,89.02 140.18,89.23 140.17,89.28 140.19,89.32 140.2,89.35 140.21,89.38 140.21,89.59 140.17,89.67 140.09,89.7 139.71,89.7 139.64,89.68 139.6,89.61 139.59,89.59 139.55,89.55 139.47,89.62 139.47,89.66 139.44,89.74 139.36,89.78 139.32,89.78 139.31,89.79 139.24,89.82 139.16,89.83 139.09,89.82 139.02,89.79 139.01,89.78 138.97,89.78 138.89,89.74 138.86,89.66 138.86,89.58 138.83,89.52 138.77,89.48 138.7,89.55 138.65,89.57 138.59,89.57 138.53,89.57 138.48,89.55 138.44,89.51 138.18,89.51 138.12,89.58 138.04,89.64 138.04,89.69 138.07,89.73 138.31,89.96 138.42,90.13 138.47,90.33 138.64,90.43 138.76,90.57 138.84,90.54 138.93,90.53 139.19,90.64 139.29,90.9 139.24,91.09 139.1,91.23 139.1,91.98 139.51,92.39 139.74,92.39
GND on BOTTOM (solid shape): outline of 92 points within 123.94,10.63 134.34,18.5
GND on BOTTOM (solid shape): 83.55,17.16 83.64,17.04 83.78,16.97 83.84,16.9 83.82,16.8 83.82,16.47 83.78,16.4 83.77,16.33 83.77,16.05 83.79,15.95 83.85,15.88 83.89,15.8 83.85,15.72 83.81,15.67 83.78,15.61 83.77,15.58 83.54,15.58 83.52,15.61 83.45,15.72 83.32,15.76 83.02,15.76 82.87,15.7 82.81,15.55 82.81,15.27 82.87,15.11 83.02,15.05 83.32,15.05 83.45,15.09 83.52,15.2 83.54,15.23 83.77,15.23 83.78,15.2 83.86,15.09 83.99,15.05 84.29,15.05 84.35,15.06 84.4,15.09 84.43,15.11 85.14,14.4 85.15,14.35 85.1,14.32 85.03,14.32 84.42,14.93 82.55,14.93 82.51,14.97 82.48,15.04 82.51,15.11 82.55,15.18 82.57,15.27 82.57,15.55 82.51,15.7 82.36,15.76 82.05,15.76 81.93,15.72 81.85,15.61 81.84,15.58 81.61,15.58 81.59,15.61 81.57,15.67 81.52,15.72 81.48,15.8 81.52,15.88 81.58,15.95 81.6,16.05 81.6,16.33 81.59,16.4 81.55,16.47 81.55,16.71 81.8,16.96 82.17,16.96 82.25,16.99 82.28,17.07 82.28,17.13 82.29,17.16
GND on BOTTOM (solid shape): outline of 138 points within 94.09,70.55 97.62,73.08
GND on BOTTOM (solid shape): 61.26,85.31 61.3,85.29 61.31,85.25 61.31,85.2 61.41,84.97 61.64,84.87 61.71,84.88 61.75,84.84 61.75,84.8 61.83,84.6 62.02,84.51 62.09,84.48 62.12,84.4 62.12,84.36 62.09,84.29 62.02,84.25 61.92,84.23 61.83,84.16 61.81,84.14 61.77,84.14 61.71,84.08 61.65,83.99 61.66,83.88 61.65,83.84 61.61,83.81 61.58,83.81 61.53,83.86 61.53,83.9 61.45,84.11 61.24,84.19 61.03,84.11 60.95,83.9 60.91,83.82 60.83,83.8 60.69,83.8 60.63,83.86 60.63,83.9 60.56,84.09 60.38,84.19 60.32,84.23 60.29,84.3 60.29,84.35 60.32,84.42 60.39,84.46 60.6,84.54 60.68,84.75 60.68,84.76 60.71,84.84 60.8,84.87 60.84,84.87 61.07,84.96 61.17,85.2 61.16,85.27 61.2,85.31
GND on BOTTOM (solid shape): 44.29,92.56 44.4,92.58 44.46,92.49 44.55,92.3 44.74,92.22 44.75,92.22 44.83,92.19 44.86,92.12 44.86,92.07 44.77,91.98 44.74,91.98 44.54,91.9 44.46,91.7 44.54,91.5 44.81,91.39 44.85,91.24 44.78,91.18 44.74,91.18 44.58,91.13 44.48,90.99 44.46,90.96 44.41,90.96 44.38,90.93 44.28,90.9 44.21,90.97 44.12,91.12 43.96,91.18 43.89,91.22 43.87,91.29 43.87,91.34 43.77,91.57 43.54,91.67 43.52,91.67 43.45,91.69 43.41,91.75 43.33,91.91 43.16,91.98 43.1,92.01 43.07,92.08 43.07,92.12 43.1,92.19 43.16,92.22 43.35,92.31 43.42,92.5 43.43,92.57 43.49,92.56 43.7,92.35 43.7,92.35 43.81,92.25 43.94,92.22 44.13,92.29 44.22,92.47 44.22,92.49
GND on BOTTOM (solid shape): 59.25,71.54 59.25,71.5 59.32,71.3 59.58,71.18 59.61,71.11 59.61,71.1 59.64,70.95 59.74,70.84 59.78,70.8 59.72,70.74 59.72,70.68 59.7,70.63 59.68,70.59 59.65,70.56 59.62,70.54 59.59,70.53 59.38,70.32 59.38,70.26 59.32,70.13 59.2,70.06 59.15,70.05 59.11,70.02 59.04,70 58.97,70.04 58.87,70.11 58.74,70.14 58.53,70.06 58.45,69.85 58.45,69.81 58.39,69.75 58.34,69.76 58.11,69.66 58.01,69.43 58.01,69.4 57.99,69.33 57.92,69.29 57.9,69.29 57.86,69.31 57.84,69.35 57.85,69.39 57.85,69.43 57.81,69.59 57.69,69.71 57.69,70.03 57.8,70.13 58.19,70.13 58.54,70.48 58.58,70.46 58.65,70.42 58.74,70.41 59.03,70.7 58.74,70.99 58.73,70.99 58.64,71.05 58.66,71.17 58.7,71.21 58.74,71.21 58.94,71.29 59.06,71.55 59.13,71.58 59.2,71.58
GND on BOTTOM (solid shape): outline of 83 points within 185.24,12.44 189.88,16.56
GND on BOTTOM (solid shape): outline of 83 points within 140.76,79.86 141.97,82.36
GND on BOTTOM (solid shape): outline of 81 points within 139.06,68 140.28,70.3
GND on BOTTOM (solid shape): 41.51,75.12 41.57,75.21 41.68,75.19 41.82,75.05 42.22,75.05 42.27,75.03 42.32,75.02 42.39,74.99 42.41,74.91 42.41,74.88 42.39,74.81 42.32,74.78 42.13,74.69 42.06,74.5 42.13,74.31 42.32,74.22 42.38,74.19 42.41,74.12 42.41,74.08 42.38,74.01 42.32,73.98 42.13,73.89 42.06,73.7 42.11,73.54 42.23,73.44 42.24,73.44 42.38,73.3 42.38,73.29 42.49,73.08 42.71,73 42.75,73.01 42.83,72.98 42.86,72.9 42.86,72.9 42.94,72.7 43.14,72.62 43.2,72.63 43.25,72.57 43.24,72.49 43.22,72.41 43.14,72.38 42.94,72.3 42.86,72.1 42.89,71.98 42.96,71.88 43,71.79 42.94,71.71 42.88,71.67 42.82,71.62 42.69,71.49 42.61,71.46 42.54,71.49 42.52,71.52 42.52,71.67 41.66,72.53 41.66,73.28 41.79,73.41 41.84,73.59 41.76,73.81 41.55,73.94 41.51,73.94
GND on BOTTOM (solid shape): outline of 89 points within 80.32,59.75 85.43,64.22

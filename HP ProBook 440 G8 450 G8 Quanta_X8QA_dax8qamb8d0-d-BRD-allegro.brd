# Allegro board HP ProBook 440 G8 450 G8 Quanta_X8QA_dax8qamb8d0-d-BRD-allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLEEVE_C: length 18.7
  BOTTOM w0.254: CON3700.3 210.24,41.44 206.36,41.44 205.45,42.35 D3703.1 204.77,40.6 v1(201.09,36.92) 199.66,35.49 C3701.2 199.04,34.1 R3700.1
SLEEVE_L: length 7.4
  TOP w0.203: v1(194.72,34.25) 194.55,34.43 U3600.14
  BOTTOM w0.254: v1(194.72,34.25) 195.37,33.61 198.14,33.61 R3700.2 198.17,33.82 v1(198.17,34.87) R3600.1
SLG4E_SR1: length 2.1
  TOP w0.109: R7505.1 21.28,44.11 v1(21.28,43.41) 21.74,43.41 22.05,43.1 U7500.4
SLP_LAN#: length 276
  TOP w0.109: v2(185.25,22.29) 185.28,22.29 186.05,23.06 186.05,24.56 186.43,24.94 186.43,25.52 187.08,26.17 187.69,26.17 188.01,26.49 188.01,27.68 v1(187.41,28.28) 186.18,29.51 184.87,29.51 184.49,29.88 183.17,29.88 182.6,30.45 182.6,31.09 182.2,31.49 178.98,31.49 177.14,29.65 174.47,29.65 173.41,30.72 168.71,30.72 161.28,38.15 161.28,40.14 161.11,40.31 159.98,40.31 159.71,40.04 159.71,39.54 159.47,39.3 158.8,39.3 158.34,38.85 157.93,38.85 157.72,39.06 157.72,39.61 157.83,39.72 157.83,40.93 158.55,41.64 158.55,42.87 158.06,43.36 v1(157.81,43.36) ; v1(24.62,6.57) 24.13,6.57 23.49,7.21 R4751.2 22.78,7.29 R1540.2
  IN2 w0.089: v1(157.81,43.36) 157.52,43.65 156.06,43.65 153.46,46.25 152.45,46.25 151.19,47.5 149.1,47.5 147.17,49.43 146.26,49.43 141.04,54.65 141.04,56.06 142.24,57.26 142.24,58.31 142.01,58.54 142.01,60.02 140.88,61.15 140.88,63.51 140.44,63.95 140.44,66.13 140.66,66.34 142.53,66.34 143.27,67.09 143.27,67.75 142.51,68.51 142.51,68.84 141.91,69.44 v2(141.91,69.57)
  IN3 w0.089: v2(185.25,22.29) 184.78,22.09 184.55,21.87 184.55,20.04 182.7,18.18 181.02,18.18 180.82,17.98 180.82,17.58 178.86,15.63 178.86,13.1 178.5,12.74 177.98,12.74 177.9,12.82 172.16,12.82 170.73,11.39 169.55,11.39 169.29,11.66 169.29,11.96 168.57,12.68 164.95,12.68 163.83,13.8 157.47,13.8 157.15,13.47 157.15,13.26 156.75,12.86 153.47,12.86 153.02,13.31 148.18,13.31 147.85,13.65 144.91,13.65 144.24,12.97 142.93,12.97 142.81,13.09 140.97,13.09 140.74,12.85 138.3,12.85 138.02,12.57 136.37,12.57 135.53,13.41 134.48,13.41 133.83,12.76 133.83,12.4 133.17,11.73 130.8,11.73 130.38,12.15 129.44,12.15 129.19,11.89 124.7,11.89 124.43,12.16 123.49,12.16 123.08,11.75 121.79,11.75 121.33,12.21 120.03,12.21 119.33,11.5 118.13,11.5 117.93,11.3 116.45,11.3 116.13,10.98 116.13,10.36 115.89,10.13 114.71,10.13 114.57,10.27 114.43,10.6 114.22,10.81 114.08,10.87 113.8,10.87 113.7,10.97 113.5,11.05 112.62,11.05 111.88,10.31 111.88,9.65 111.55,9.31 109.8,9.31 108.53,8.05 105.89,8.05 105.64,8.3 104.1,8.3 103.26,9.14 99.57,9.14 98.62,10.09 96.21,10.09 95.44,10.85 93.81,10.85 93.7,10.74 86.43,10.74 85.78,10.09 74.61,10.09 74.4,9.88 61.36,9.88 60.5,9.01 60.5,8.25 59.53,7.28 54.61,7.28 53.84,8.05 51.85,8.05 51.62,8.14 50.31,8.14 49.79,7.62 46.9,7.62 46.13,6.85 43.02,6.85 42.56,7.3 40.02,7.3 39.65,6.94 34.62,6.94 33.54,5.86 30.31,5.86 29.97,6.2 27.3,6.2 26.43,7.07 26.24,7.15 25.19,7.15 v1(24.62,6.57)
  BOTTOM w0.109: v2(141.91,69.57) 141.93,69.57 142.17,69.33 U400.DN39
SLP_S0#: length 182.3
  TOP w0.079: R1521.1 137.36,67.64 137.21,67.79 136.39,67.79 R1522.1
  TOP w0.109: R1521.1 137.56,67.46 v2(137.8,67.22)
  IN1 w0.079: v1(19.12,40) 19.81,40 19.91,40.1 21.13,40.1 21.75,40.73 23.86,40.73 25.22,42.09 27.82,42.09 28.4,42.67 28.4,42.74 29.51,43.84 30.11,43.84 30.74,43.21 34.97,43.21 35.58,42.61 37.54,42.61 38.23,43.3 39.25,43.3 39.85,43.9 44.73,43.9 45.2,43.43 46.29,43.43 48.03,45.17 50.75,45.17 v1(51.32,45.74) ; v2(137.8,67.22) 138.01,67.43 138.85,67.43 139.27,67.01 139.27,66.71 139.89,66.09 139.89,63.91 140.38,63.42 140.38,59.6 142.12,57.87 142.12,57.01 142.6,56.53 143.08,56.53 143.8,55.8 143.8,55.15 143.67,55.02 143.67,54.15 145.69,52.14 146.67,52.14 146.83,51.98 146.83,51.42 148.04,50.2 149.44,50.2 149.91,49.73 152.86,49.73 v1(153.48,49.11)
  BOTTOM w0.109: v1(51.32,45.74) 60.99,45.74 62.38,44.34 77.13,44.34 82.11,49.33 100.85,49.33 107.93,42.24 116.22,42.24 119.45,45.48 151.8,45.48 152.43,46.11 152.43,47.08 153.48,48.13 v1(153.48,49.11) ; v2(137.8,67.22) 138.19,67.61 U400.DD42 ; CON7700.15 18.15,41.69 19.12,40.71 v1(19.12,40)
SLP_S3#_3R: length 360
  TOP w0.076: v2(193.49,18.29) U4700.D6
  TOP w0.109: v1(143.94,91.13) 143.14,91.93 PD9600.2 ; PR9514.1 178.18,65.12 v1(178.59,65.53) ; U6203.6 199.81,83.42 200.66,84.26 v1(200.99,84.26) ; PR9518.1 157.1,16.18 157.3,15.97 157.35,15.97 157.71,15.62 158.57,15.62 158.7,15.49 PR9520.1 158.85,16 v1(158.8,16.05) 160.7,16.05 161.11,15.65 162.08,15.65 162.34,15.91 PQ8703.2 ; PU10602.2 146.57,97.69 146.86,97.41 146.86,96.84 v1(146.46,96.44) ; R1542.2 145.13,55.97 145.13,55.43 144.66,54.96 R1506.2 144.66,54.66 v1(144.3,54.3) ; v2(187.62,16.75) 187.62,16.35 187.4,16.13 186,16.13 185.18,15.31 184.68,15.31 184.12,14.76 183.08,14.76 182.29,15.54 181.73,15.54 180.86,16.42 180.86,16.58 180.31,17.13 179.5,17.13 178.8,17.83 177.52,17.83 176.45,18.9 174.99,18.9 v1(174.33,18.23)
  IN1 w0.079: v1(173.91,100.02) 171.78,100.02 171.47,99.72 166.65,99.72 166.49,99.57 166.49,99.08 166.32,98.91 165.43,98.91 164.63,99.71 154.01,99.71 153.24,100.48 151.2,100.48 149.6,102.08 144.79,102.08 142.97,103.9 135.04,103.9 133.61,102.47 v1(133.08,102.47) ; v1(154.35,48.97) 154.35,49.68 153.22,50.82 153.22,52.61 153.04,52.79 147.7,52.79 146.68,53.81 146.68,54.35 146.26,54.77 144.77,54.77 v1(144.3,54.3) ; v1(200.96,46.71) 200.67,46.71 200.61,46.77 198.9,46.77 197.71,47.95 192.18,47.95 191.64,47.42 188.26,47.42 187.09,48.59 187.09,50.86 186.35,51.6 186.35,53.5 185.39,54.46 185.39,54.86 185.03,55.22 v1(179.17,55.22) 179.02,55.38 177.1,55.38 176.1,54.38 174.49,54.38 174.2,54.09 172.42,54.09 172.09,53.75 164.93,53.75 162.71,51.53 162.71,50.56 160.48,48.33 159.98,48.33 159.02,47.37 157.8,47.37 157.39,46.96 156.72,46.96 v1(156.47,46.71)
  IN2 w0.089: v1(146.12,92.02) 146.12,91.68 145.19,90.75 144.32,90.75 v1(143.94,91.13) 142.41,92.65 139.74,92.65 139.41,92.99 138.02,92.99 137.55,93.47 137.55,95.92 136.58,96.88 136.58,98.78 135.76,99.6 134.58,99.6 134.24,99.94 134.24,100.65 134.54,100.96 134.54,101.82 133.89,102.47 v1(133.08,102.47) ; v1(158.8,16.05) 159.77,17.02 164.58,17.02 165.7,18.14 168.7,18.14 168.99,17.85 170.5,17.85 171.6,18.95 173.61,18.95 v1(174.33,18.23) ; v2(187.62,16.75) 187.26,17.11 186.01,17.11 185.11,18.01 185.11,18.5 183.42,20.19 183.42,21.95 181.04,24.33 181.04,27.65 178.9,29.78 178.9,31.27 176.29,33.88 176.29,34.39 173.78,36.9 173.78,37.82 173.4,38.21 173.4,38.75 171.31,40.83 169.9,40.83 167.91,42.82 164.1,42.82 163.37,42.09 161.87,42.09 161.19,41.41 160.12,41.41 159.25,42.27 159.25,43.29 158.17,44.37 158.17,45.42 156.89,46.71 v1(156.47,46.71) ; v1(179.17,55.22) 179.43,55.48 179.43,57.66 178.92,58.17 178.92,58.54 179.4,59.03 180.29,59.03 180.41,59.15 180.41,59.7 180.14,59.97 179.87,59.97 179.09,60.75 179.09,62.67 178.16,63.6 178.16,65.1 v1(178.59,65.53) 179.47,66.41 179.47,67.05 179.02,67.5 179.02,70.14 179.21,70.33 179.98,70.33 181,71.35 181,76.6 176.37,81.23 176.37,82.91 174.7,84.58 174.7,86.23 171.74,89.19 171.74,93.3 171.27,93.77 171.27,97.1 171.62,97.45 171.62,99.74 171.91,100.02 v1(173.91,100.02)
  IN3 w0.089: v1(156.47,46.71) 156.47,47.13 155.76,47.84 154.82,47.84 154.35,48.31 v1(154.35,48.97) ; v1(200.99,84.26) 200.8,84.26 199.7,83.17 199.7,81.09 201.82,78.97 202.35,78.97 203.24,78.08 203.24,76.62 203,76.37 203,68.19 203.12,68.07 203.12,64.62 205.33,62.41 205.33,58.61 203.66,56.93 203.66,50.72 200.96,48.03 v1(200.96,46.71)
  BOTTOM w0.076: 191.92,18.87 192,18.87 192.58,18.29 193.49,18.29 v2(193.49,18.29)
  BOTTOM w0.109: 191.92,18.87 190.8,18.87 190.45,18.51 190.45,17.8 190.22,17.57 190.22,17.02 189.93,16.73 187.64,16.73 v2(187.62,16.75) ; v1(146.12,92.02) 146.12,93.9 146.46,94.24 v1(146.46,96.44) ; PR8109.2 181.22,57.07 180.3,57.07 179.17,55.94 v1(179.17,55.22) ; PR10623.2 134.44,100.12 134.44,101.93 133.9,102.47 v1(133.08,102.47)
SLP_S3#_3R_3: length 156.9
  TOP w0.109: v1(113.23,16.18) 112.62,15.57 v1(112.62,14.73) 112.62,10.84 112.06,10.28 112.06,7.52 111.38,6.83 v1(111.12,6.83) ; v1(25.32,5.56) 25.32,5.84 25.63,6.14 26.39,6.14 26.67,6.42 26.67,6.66 26.87,6.86 PR9507.2 ; v1(151.1,17.5) 151.1,17.1 151.67,16.53 156.11,16.53 156.24,16.4 PR9518.2
  IN3 w0.089: v1(113.23,16.18) 113.23,16.46 115.8,19.02 119.33,19.02 119.91,18.44 122.2,18.44 123.29,17.35 123.29,17.02 123.62,16.69 123.98,16.69 124.83,17.55 124.83,17.98 125.13,18.28 131.98,18.28 132.59,17.67 134.39,17.67 134.99,17.07 135.92,17.07 136.61,16.38 139.14,16.38 139.3,16.22 143.73,16.22 144.24,16.74 147.93,16.74 148.94,17.75 150.85,17.75 v1(151.1,17.5) ; v1(25.32,5.56) 25.86,5.02 31.61,5.02 31.73,5.15 33.83,5.15 34.5,5.81 34.82,5.81 34.97,5.66 35.28,5.66 35.68,6.07 39.79,6.07 40.17,6.45 40.54,6.45 41.02,5.97 42.11,5.97 42.57,5.51 44.23,5.51 44.74,6.02 47.33,6.02 48.22,6.91 50.08,6.91 50.6,7.43 51.39,7.43 51.92,7.21 52.56,6.57 54.61,6.57 56.43,4.75 58.5,4.75 58.7,4.96 59.89,4.96 60.56,4.28 62.7,4.28 63.23,4.81 64.77,4.81 65.38,5.42 65.38,8.36 66.19,9.17 74.69,9.17 74.9,9.37 86.07,9.37 86.73,10.03 93.34,10.03 94,9.37 98.32,9.37 99.27,8.42 101.83,8.42 102.59,7.66 103.37,7.34 104.44,7.34 104.66,7.56 105.31,7.56 105.55,7.31 108.81,7.31 109.01,7.52 110.44,7.52 v1(111.12,6.83)
SLP_S3#_3R_5: length 1.3
  TOP w0.109: PR9520.2 159.3,15.26 159.18,15.14 158.6,15.14 158.47,15.26 PR9504.1
SLP_S3#_3R_PCH: length 15.7
  TOP w0.109: v1(144.51,55.47) 144.2,55.16 R1506.1
  IN1 w0.079: v2(139.98,67.77) 140.18,67.57 140.18,66.32 140.26,66.24 140.26,64.08 140.74,63.6 140.74,59.75 142.43,58.06 142.43,57.14 142.73,56.84 143.21,56.84 144.51,55.54 v1(144.51,55.47)
  BOTTOM w0.109: U400.DJ43 140.22,67.53 v2(139.98,67.77)
SLP_S3_5R: length 2.6
  TOP w0.109: PR8720.1 162.19,14.06 162.34,14.21 PQ8703.5 162.34,15.01 162.49,15.17 162.86,15.17 162.99,15.04 PQ8703.6
SLP_S4#_3R: length 414.2
  TOP w0.076: 195.65,22.5 195.65,22.16 195.45,21.97 195.45,21.55 U4700.F11
  TOP w0.109: v2(192.4,27.15) 192.4,24.82 193.36,23.85 194.58,23.85 195.65,22.79 195.65,22.5 ; U6202.4 205.12,81.04 203.5,79.41 202.92,79.41 v1(201.87,80.46) 201.73,80.46 200.81,81.39 200.81,81.78 201.46,82.43 201.46,84.42 201.14,84.73 200.65,84.73 199.83,83.92 U6203.7 ; v1(172.63,47.86) 172.85,48.08 PR8724.1 171.93,49.53 PD8700.2 ; v2(140.56,67.79) 140.18,68.18 R1505.2 ; v1(14.47,40.81) 15.01,41.34 17.45,41.34 17.66,41.56 R1541.2 19.91,42.16 D3300.1 19.13,43.83 19.11,43.83 R3302.1 ; v1(8.77,24.23) 6.66,22.12 6.66,18.85 8.08,17.43 8.08,11.62 8.61,11.09 8.61,5.99 9.27,5.33 9.77,5.33 9.95,5.51 9.95,6.68 9.67,6.95 9.67,7.56 9.79,7.68 CON7602.39
  IN1 w0.079: v1(8.77,24.23) 8.43,24.56 8.43,34.35 9.51,35.43 14.58,35.43 v1(15.49,36.35) 15.49,36.84 13.45,38.88 13.45,39.78 v1(14.47,40.81) 15.1,40.81 15.54,41.25 17.8,41.25 18.25,41.69 23.49,41.69 25.46,43.67 28,43.67 29.14,44.81 33.37,44.81 33.82,44.37 35.89,44.37 v1(35.95,44.31) ; v1(183.48,43.18) 183.4,43.26 181.26,43.26 176.99,47.53 176.67,47.53 175.71,48.48 174.67,48.48 174.24,48.05 172.82,48.05 v1(172.63,47.86) 172.38,47.61 171.45,47.61 171.07,47.99 169.82,47.99 169.6,47.77 169.6,47.45 168.36,46.22 167.09,46.22 166.7,45.82 166.7,45.18 165.99,44.47 164.97,44.47 163.81,45.64 v1(162.93,45.64) ; v1(182.36,60.27) 184.42,62.33 189.82,62.33 192.72,59.43 198.73,59.43 201.3,62.01 201.3,63.17 200.68,63.79 200.68,68.48 200.22,68.94 200.22,72.12 196.34,76 193.9,76 v1(193.59,75.68)
  IN2 w0.089: v1(182.36,60.27) 182.65,60.27 182.8,60.12 182.8,57.98 182.18,57.36 181.68,57.36 181.28,56.96 181.28,54.49 182.5,53.27 182.5,52.55 184.63,50.42 184.63,49.41 184.3,49.08 182.97,49.08 182.76,48.87 182.76,48.14 182.96,47.94 182.96,45.13 183.53,44.57 183.53,43.48 183.48,43.43 v1(183.48,43.18) 183.73,42.92 184.25,42.92 184.49,42.69 184.49,40.53 184.25,40.29 184.25,36.61 188.22,32.64 188.22,30.57 188.36,30.22 189.31,29.28 190.19,29.28 191.69,27.78 191.76,27.78 v2(192.4,27.15) ; v1(162.93,45.64) 162.34,46.23 162.34,47.37 161.38,48.33 161.38,52.03 160.26,53.15 159.57,53.15 158.44,54.28 158.44,55.21 158.35,55.3 158.35,57.8 v1(158.14,58.01)
  IN3 w0.089: v2(140.56,67.79) 140.95,68.18 143.22,68.18 145.2,66.2 146.39,66.2 147.22,65.38 147.37,65.38 148.33,64.41 149.4,64.41 149.46,64.48 150.81,64.48 151.13,64.79 151.13,64.92 151.35,65.15 151.67,65.15 151.81,65.09 151.91,64.99 151.96,64.86 151.96,64.05 149.65,61.75 149.65,58.99 151.61,57.03 154.02,57.03 155.09,58.1 158.05,58.1 v1(158.14,58.01)
  BOTTOM w0.109: CON7700.5 15.83,36.69 v1(15.49,36.35) ; v1(193.59,75.68) 194.65,76.74 194.65,77.09 194.82,77.26 195.45,77.26 196.29,78.1 198.37,78.1 198.82,77.64 199.68,77.64 200.2,78.16 200.2,78.79 v1(201.87,80.46) ; v1(162.93,45.64) 162.86,45.64 161.6,44.38 161.6,42.97 162.02,42.54 162.02,42.12 160.7,40.79 160.28,40.79 159.74,40.24 159.74,39.53 159.6,39.39 159.6,38.16 158.19,36.75 124.29,36.75 119.2,31.65 103.93,31.65 102.9,32.68 47.22,32.68 41.68,38.22 41.68,39.25 38.86,42.07 36.55,42.07 35.53,43.1 35.53,43.88 v1(35.95,44.31)
SLP_S4#_3R_PCH: length 1.2
  TOP w0.109: v2(139.88,68.77) 139.73,68.62 R1505.1
  BOTTOM w0.109: v2(139.88,68.77) 140.22,68.43 U400.DJ41
SLP_S5#_3R: length 292.2
  TOP w0.109: R5927.2 189.75,94.04 189.07,93.37 v2(188.92,93.37)
  IN1 w0.079: v1(49.41,45.74) 49.2,45.95 45.57,45.95 45.29,45.67 45.29,44.65 44.89,44.26 39.7,44.26 39.1,43.66 38.08,43.66 37.35,42.92 35.71,42.92 35.1,43.53 30.87,43.53 30.24,44.16 29.38,44.16 28.09,42.87 28.09,42.8 27.69,42.4 25.09,42.4 23.73,41.04 19.88,41.04 19.52,40.69 19,40.69 18.57,40.26 18.57,38.59 18.73,38.42 18.73,36.94 v1(18.36,36.57) ; v1(198.98,78.37) 198.75,78.15 198.75,73.86 200.37,72.24 200.37,69.01 200.84,68.54 200.84,63.87 201.52,63.19 201.52,61.92 198.68,59.08 198.68,57.83 196.95,56.11 193.95,56.11 192.99,55.14 192.99,54.27 192.45,53.73 190.64,53.73 188.72,55.65 187.81,55.65 185.9,57.55 184.15,57.55 183.61,57.01 183.61,56.03 183.27,55.69 180.01,55.69 179.87,55.83 178.94,55.83 178.81,55.69 176.97,55.69 175.97,54.7 174.36,54.7 174.06,54.4 172.29,54.4 171.96,54.07 171.71,54.07 171.7,54.07 164.52,54.07 162.4,51.95 162.4,51.1 160.9,49.6 160.28,49.6 159.87,49.19 159.87,48.45 158.95,47.53 157.73,47.53 157.32,47.11 156.35,47.11 155.96,46.73 155.96,46.39 155.75,46.17 154.14,46.17 153.47,46.84 v1(153.13,46.84) ; v2(141.85,67.77) 142.03,67.58 142.03,66.65 141.81,66.42 140.74,66.42 140.46,66.14 140.46,64.13 140.9,63.7 140.9,61.21 140.9,59.84 142.59,58.15 142.59,57.2 142.79,57 143.27,57 143.99,56.28 144.62,56.28 145.18,55.71 145.18,55.17 145.42,54.93 146.36,54.93 146.84,54.46 146.84,53.87 147.74,52.97 153.11,52.97 153.37,52.7 153.37,50.88 154.42,49.83 v1(154.69,49.83)
  IN3 w0.089: v2(188.92,93.37) 189.76,94.21 193.55,94.21 195.87,91.88 196.78,91.5 197.36,90.93 197.36,88.64 197.74,88.26 197.74,86.61 196.49,85.37 196.49,83.64 196.9,83.23 196.9,79.68 198.21,78.37 v1(198.98,78.37)
  BOTTOM w0.109: v1(18.36,36.57) 18.29,36.57 17.9,36.19 CON7700.4 ; v2(141.85,67.77) 141.82,67.73 141.82,67.67 U400.DM43 ; v1(154.69,49.83) 154.69,49.23 154.78,49.15 154.78,48.78 153.13,47.13 v1(153.13,46.84) 153.13,46.14 150.01,43.03 117.65,43.03 116.43,41.8 107.72,41.8 100.66,48.87 82.3,48.87 77.31,43.89 61.9,43.89 60.73,45.06 50.09,45.06 v1(49.41,45.74)
SM_VREF: length 87.6
  TOP w0.508: v1(117.66,48.51) 117.66,49.51 118.18,50.04 118.18,52.31 116.47,54.03 116.47,60.29 117.54,61.36 117.54,62.58 116.66,63.46 v2(116.66,63.46)
  IN1 w0.508: v1(117.66,48.51) 117.66,47.86 115.34,45.54 115.34,34.35 113.49,32.49 113.49,22.73 113.82,22.4 116.25,22.4 117.76,20.9 146.78,20.9 147.78,19.9 152.18,19.9 153.35,21.06 v1(153.35,21.71)
  BOTTOM w0.079: U400.AU49 117.05,64.39 116.74,64.08 116.74,63.53 v2(116.66,63.46)
SMB_ALERT#: length 16
  TOP w0.109: R1226.2 153.39,76.38 153.64,76.12 R1229.1 153.23,75.84 v2(153.08,75.69) ; v2(142.31,77.82) 142.31,77.8 141.55,77.04 R1227.2
  IN1 w0.079: v2(153.08,75.69) 152.37,76.4 151.62,76.4 150.55,77.47 148.66,77.47 148.5,77.63 147.44,77.63 147.02,77.2 144.05,77.2 143.81,77.45 142.69,77.45 v2(142.31,77.82)
  BOTTOM w0.109: v2(142.31,77.82) 142.31,78.15 U400.DN19
SMB_PCH_CLK: length 8.3
  TOP w0.109: v2(137.91,66.04) 137.61,65.74 137.11,65.74 136.71,65.34 136.71,64.76 137.21,64.26 137.21,61.17 137.27,61.11 137.27,59.82 R816.2
  BOTTOM w0.109: U400.DB45 137.62,66.04 v2(137.91,66.04)
SMB_PCH_DAT: length 7.8
  TOP w0.109: v2(137.88,66.65) 137.64,66.41 137.34,66.11 137.18,66.11 136.5,65.43 136.5,64.45 137,63.95 137,61.08 137,61.07 R815.2
  BOTTOM w0.109: v2(137.88,66.65) 137.66,66.65 U400.DB44
SMB_PCH_R_CLK: length 18.9
  TOP w0.109: R1106.1 155.87,76.3 155.82,76.25 155.32,76.25 154.79,75.72 154.4,75.72 154.2,75.92 154.2,76.07 v2(154.05,76.22)
  IN2 w0.089: v2(141.02,79.65) 141.57,79.11 142.73,79.11 143.2,79.58 144.6,79.58 145.06,80.03 146.81,80.03 147.04,80.27 148.3,80.27 149,79.56 149,78.8 151.28,76.53 153.42,76.53 153.73,76.22 v2(154.05,76.22)
  BOTTOM w0.109: U400.DK17 140.87,79.5 v2(141.02,79.65)
SMB_PCH_R_DAT: length 20.1
  TOP w0.109: v2(154.59,76.1) 154.79,76.1 155.17,76.48 155.73,76.48 156.08,76.84 R1107.1
  IN2 w0.089: v2(154.59,76.1) 154.58,76.1 154.23,75.74 153.92,75.74 153.41,76.25 151.23,76.25 148.77,78.71 148.77,79.54 148.22,80.09 147.14,80.09 146.31,79.25 144.21,79.25 144.07,79.4 143.28,79.4 142.79,78.91 141.23,78.91 v2(140.47,79.67)
  BOTTOM w0.109: v2(140.47,79.67) 140.4,79.67 140.22,79.48 U400.DJ17
SMB_SML0_CLK: length 394.8
  TOP w0.109: R1128.1 152.58,73.03 152.58,73.76 v2(152.25,74.09) ; v1(9.4,8.82) 9.76,9.18 CON7602.36 ; C5940.2 187.17,89.89 186.99,90.07 v1(186.87,90.07) 186.14,90.07 v2(185.73,90.47)
  IN1 w0.079: v2(152.25,74.09) 152.72,74.56 153.54,74.56 154.21,73.89 158.6,73.89 160.37,75.66 163.04,75.66 163.62,75.08 167.56,75.08 167.61,75.03 v1(168.37,75.03) ; v1(36.8,54.56) 36.8,55.7 34.81,57.7 30.58,57.7 29.85,56.97 29.11,56.97 28.75,57.33 28.24,57.33 25.24,54.33 25.24,54.16 22.89,51.81 22.2,51.81 21.95,52.06 18.79,52.06 18.36,51.64 18.36,50.9 15.26,47.8 15.26,45.3 13.19,43.23 12.77,43.23 10.93,41.4 10.93,40.32 v1(11.15,40.1)
  IN2 w0.089: v2(139.97,77.81) 139.98,77.81 140.46,78.3 146.34,78.3 146.42,78.37 147.97,78.37 148.04,78.3 148.4,78.3 152.25,74.45 v2(152.25,74.09) 152.22,74.06 152.09,74.06 151.82,73.79 151.82,72.98 150.59,71.75 150.59,71.32 150.04,70.77 150.04,70.36 150.49,69.9 150.49,67.97 151.01,67.46 151.01,65.27 151.03,65.24 151.03,64.22 148.81,62 148.81,58.57 149.22,58.16 149.22,57.89 151.03,56.08 152.02,56.08 155.38,52.72 155.85,52.72 157.85,50.72 157.85,48.35 158.37,47.83 158.9,47.3 158.9,46.73 159.38,46.25 v1(159.97,46.25) ; v1(165.53,102.16) 165.04,101.67 165.04,94.93 163.73,93.63 163.73,88.98 165.56,87.16 165.56,84.27 166.09,83.74 166.09,82.9 167.45,81.54 167.45,76.8 168.3,75.94 168.3,75.1 v1(168.37,75.03) ; v1(11.15,40.1) 10.28,40.97 10.14,40.97 10,40.83 10,40.7 10.49,40.21 10.49,40.08 10.34,39.92 10.22,39.92 9.56,40.58 9.44,40.58 9.31,40.45 9.31,40.33 9.97,39.67 9.97,39.55 9.84,39.42 9.71,39.42 9.06,40.08 8.93,40.08 8.81,39.95 8.81,39.82 9.46,39.17 9.46,39.04 9.34,38.92 9.21,38.92 8.56,39.57 8.43,39.57 8.3,39.45 8.3,39.32 8.96,38.67 8.96,38.54 8.83,38.41 8.71,38.41 8.05,39.07 7.93,39.07 7.8,38.94 7.8,38.82 8.46,38.16 8.46,38.04 8.33,37.91 8.21,37.91 7.55,38.57 7.42,38.57 7.3,38.44 7.3,38.32 7.95,37.66 7.95,37.53 7.68,37.26 6.43,37.26 6.34,37.18 6.34,37 6.43,36.91 7.86,36.91 7.95,36.82 7.95,36.64 7.86,36.55 6.43,36.55 6.34,36.46 6.34,36.29 6.43,36.2 7.86,36.2 7.95,36.11 7.95,35.93 7.86,35.84 6.43,35.84 6.34,35.75 6.34,35.58 6.43,35.49 7.86,35.49 7.95,35.4 7.95,35.22 7.86,35.13 6.43,35.13 6.34,35.04 6.34,34.86 6.43,34.78 7.86,34.78 7.95,34.69 7.95,33.81 7.86,33.72 6.94,33.72 6.85,33.64 6.85,33.46 6.94,33.37 7.86,33.37 7.95,33.28 7.95,33.1 7.86,33.01 6.94,33.01 6.85,32.92 6.85,32.75 6.94,32.66 7.86,32.66 7.95,32.57 7.95,32.31 7.86,32.23 6.95,32.23 6.86,32.13 6.86,31.9 7.16,31.6 7.16,28.3 7.62,27.84 7.62,23.94 6.29,22.61 6.29,20.39 6.98,19.69 6.98,18.14 6.27,17.43 6.27,12.99 7.94,11.32 7.94,11.11 6.23,9.41 6.23,9.3 6.36,9.17 6.5,9.17 8.15,10.82 8.3,10.82 8.43,10.7 8.43,10.59 6.66,8.83 6.66,8.72 6.79,8.59 6.93,8.59 8.22,9.88 8.35,9.88 8.47,9.76 8.47,9.63 7.42,8.58 7.42,8.45 7.55,8.33 7.67,8.33 8.72,9.38 8.85,9.38 8.97,9.25 8.97,9.13 7.92,8.08 7.92,7.95 8.05,7.83 8.18,7.83 9.17,8.82 v1(9.4,8.82)
  IN3 w0.089: v2(185.73,90.47) 185.73,90.15 185.39,89.81 183.87,89.81 183.11,89.05 182.7,89.05 182.31,88.66 181.26,88.66 180.92,89 180.92,89.21 180.42,89.71 179.81,89.71 178.9,90.62 175.52,90.62 171.07,95.08 171.07,97.08 166.47,101.67 166.01,101.67 v1(165.53,102.16)
  BOTTOM w0.079: U400.DK19 140.62,78.29 140.14,77.81 v2(139.97,77.81)
  BOTTOM w0.109: v1(36.8,54.56) 36.14,53.9 36.14,49.33 39.94,45.54 40.38,45.54 40.86,45.07 40.86,44.62 43.29,42.18 43.77,42.18 45.24,40.71 45.24,38.55 49.13,34.66 103.39,34.66 104.65,33.4 118.36,33.4 124.02,39.06 155.31,39.06 156.65,40.41 157.03,40.41 158.78,42.17 158.78,43.76 159.71,44.69 159.71,46.04 159.93,46.25 v1(159.97,46.25) ; v2(185.73,90.47) 185.73,90.91 R5916.2
SMB_SML0_DAT: length 377
  TOP w0.109: C5941.2 187.75,89.11 187.35,89.51 185.95,89.51 v2(185.14,90.32) ; v1(9.47,5.9) 9.03,6.34 9.03,7.83 9.88,8.68 CON7602.37 ; R1129.1 151.72,78.61 151.51,78.4 151.51,78.1 151.89,77.72 152.68,77.72 152.86,77.9 v2(152.86,78.1)
  IN1 w0.079: v2(152.86,78.1) 152.9,78.05 154.89,78.05 155.11,78.27 155.11,78.65 155.49,79.04 156.19,79.04 157.19,78.04 161.01,78.04 161.34,77.71 163.23,77.71 164.33,76.61 166.45,76.61 167.81,77.97 v2(167.81,78.08) ; v1(9.47,5.9) 10.31,5.05 14.52,5.05 17.01,7.54 20.39,7.54 20.7,7.85 21.41,7.85 21.83,7.43 21.83,6.94 22.65,6.12 30.42,6.12 31.68,4.86 35.27,4.86 35.84,5.43 42.14,5.43 42.69,4.88 50.69,4.88 50.92,5.11 51.63,5.11 52.49,5.97 54.18,5.97 56.39,8.18 58.31,8.18 58.97,8.84 59.25,8.84 59.72,9.3 80.69,9.3 80.73,9.26 85.1,9.26 86.44,10.61 88.58,10.61 88.74,10.45 91.65,10.45 92.14,9.96 93.44,9.96 94.09,9.3 96.29,9.3 96.82,8.78 98.72,8.78 99.79,7.7 102.18,7.7 102.61,7.28 103.98,7.28 104.96,6.3 113.03,6.3 113.69,6.96 113.69,7.54 114.13,7.98 114.48,7.98 115.19,8.69 126.12,8.69 126.28,8.85 134.59,8.85 134.79,8.65 135.69,8.65 135.99,8.36 140.86,8.36 141.16,8.06 143.14,8.06 143.49,8.41 145.68,8.41 145.86,8.59 146.83,8.59 147,8.41 151.05,8.41 151.37,8.1 158.32,8.1 158.78,8.55 160.41,8.55 160.97,9.11 168.8,9.11 172.15,5.76 176.27,5.76 177.93,7.42 181.73,7.42 183.12,8.8 185.57,8.8 185.75,8.99 190.75,8.99 191.34,9.57 191.34,10.61 191.67,10.95 191.67,12.06 191.31,12.42 191.31,12.98 192.07,13.74 192.07,15.09 191.66,15.5 191.66,18.35 191.01,19 191.01,19.45 191.31,19.76 191.31,20.14 190.15,21.31 190.15,22.94 188.47,24.63 187.72,24.63 185.84,26.51 185.47,27.41 185.47,27.89 183.05,30.31 183.05,31.45 181.76,32.74 181.76,35.27 180.73,36.3 180.73,36.81 179.67,37.86 176.26,37.86 175.25,38.88 175.25,40.08 174.12,41.21 174.12,42.31 v1(172.71,43.73)
  IN2 w0.089: v2(152.86,78.1) 152.86,77.98 152.35,77.47 151.15,77.47 149.22,79.4 149.22,79.59 148.37,80.44 146.93,80.44 146.7,80.21 144.98,80.21 144.59,79.82 143.19,79.82 142.66,79.28 141.95,79.28 v2(141.57,79.67) ; v1(166.16,102.16) 165.22,101.21 165.22,94.86 163.91,93.55 163.91,89.06 165.74,87.23 165.74,84.35 166.32,83.77 166.32,82.92 168.04,81.19 168.04,78.36 167.81,78.13 v2(167.81,78.08) 168.32,78.08 168.72,77.68 168.72,75.52 170.66,73.58 170.66,72.29 170.36,71.99 170.02,71.99 169.46,71.43 169.46,69.54 169.26,69.34 169.26,67.53 170.18,66.61 170.18,65.35 170.03,65.21 170.03,63.99 170.41,63.62 170.41,57.95 171.35,57.01 171.35,55.95 171.01,55.61 171.01,51.47 170.37,50.84 170.37,47.88 172.31,45.94 174.3,45.94 v1(174.35,46)
  IN3 w0.089: v2(185.14,90.32) 184.81,89.99 183.79,89.99 183.06,89.25 182.65,89.25 182.24,88.84 181.33,88.84 181.1,89.08 181.1,89.28 180.48,89.9 179.88,89.9 178.92,90.85 175.54,90.85 171.24,95.15 171.24,97.15 166.24,102.16 v1(166.16,102.16)
  BOTTOM w0.109: v2(141.57,79.67) 141.52,79.62 U400.DM17 ; R5918.2 185.14,90.77 v2(185.14,90.32) ; v1(174.35,46) 172.71,44.35 v1(172.71,43.73)
SMC: length 4.1
  BOTTOM w0.109: PCN8400.6 86.12,13.67 84.38,15.41 PR8419.1 PC8410.2
SMD: length 5.3
  BOTTOM w0.109: PR8418.1 PC8409.2 82.21,15.03 82.48,14.76 84.35,14.76 84.87,14.24 PCN8400.7
SMDDR_VREF_DQ1_M3: length 45.2
  TOP w0.508: v2(116.47,61.73) 115.45,60.71 115.45,53.6 117.17,51.89 117.17,50.46 116.64,49.93 v1(116.64,48.32)
  IN1 w0.508: v1(116.64,48.32) 114.32,46 114.32,34.85 112.47,33 v1(112.47,21.44)
  BOTTOM w0.079: U400.AU52 117.05,63.14 116.8,62.89 116.8,62.06 v2(116.47,61.73)
  vias: v1(112.55,20.83)
SML0_ALERT#: length 2.9
  TOP w0.109: v2(142.12,79.67) 142.1,79.65 142.1,79.46 141.88,79.24 R1234.2 139.98,79.24 R1235.1
  BOTTOM w0.109: U400.DN17 142.17,79.61 v2(142.12,79.67)
SN5V: length 1.4
  TOP w0.254: PC8629.1 172.76,16.48 PR8614.1
SN_CHG: length 1.4
  TOP w0.508: PC8219.1 65.9,5.32 PR8218.1
SN_DDR: length 1.9
  TOP w0.203: v1(99.06,15.87) 99.41,15.52 PC8720.2
  TOP w0.254: PR8708.1 99.8,14.53 PC8720.2
SN_GPU1: length 1.3
  BOTTOM w0.305: PC9910.1 73.54,105.22 PR9901.2
SN_GPU2: length 1
  BOTTOM w0.254: PC9921.1 PR9902.2
SN_VCCIN1: length 1.9
  TOP w0.508: PC8919.1 v1(94.16,103.1) 94.16,102.27 PR8904.2
SN_VCCIN2:
  vias: v1(103.35,103.45)
SNDW_RCOMP: length 1.5
  TOP w0.109: v2(139.27,72.41) 139.27,72.51 138.78,73 R1504.1
  BOTTOM w0.109: v2(139.27,72.41) 139.25,72.39 139.25,72.25 U400.DF33
SPI_TPM_CS#: length 38.1
  TOP w0.109: U5100.20 164.39,65.17 164.36,65.2 v1(164.36,65.55) 164.36,65.57 164.68,65.88 164.68,66.27 164.45,66.49 R5101.2 164.29,67.41 TP5101.1
  IN1 w0.079: v2(139.23,69.57) 139.23,69.62 138.78,70.06 138.78,71.01 138.7,71.09 138.43,71.09 138.37,71.03 138.37,69.52 138.49,69.4 138.82,69.4 138.93,69.3 138.93,69.12 138.8,68.99 138.36,68.99 138.2,68.83 138.2,68.57 138.38,68.39 142.57,68.39 143.56,67.4 144.71,67.4 144.9,67.21 146.51,67.21 149.3,64.42 155.91,64.42 156.55,63.77 158.75,63.77 159.25,64.27 161.68,64.27 162.53,65.12 163.93,65.12 v1(164.36,65.55)
  BOTTOM w0.109: v2(139.23,69.57) 139.18,69.57 138.92,69.31 U400.DF39
SRTC_RST#: length 222.3
  TOP w0.109: R1421.2 155.57,66.95 v2(155.46,66.84) 155.34,66.72 155.34,65.96 155.56,65.74 C1402.1 R1418.2 ; Q7507.3 23.01,35.67 v1(23.09,35.75)
  IN1 w0.079: v1(25.35,48.89) 25.35,49.35 25.55,49.55 26.4,49.55 26.55,49.41 26.81,49.41 27.43,48.79 29,48.79 29.69,49.48 30.73,49.48 31.03,49.18 38.64,49.18 39.87,50.42 44.93,50.42 v1(45.11,50.59) ; v1(166.36,67.02) 166.36,67.02 166.27,66.93 164.48,66.93 164.06,67.35 163.48,67.35 162.62,66.5 161.69,66.5 161.54,66.34 161,66.34 160.47,65.81 156.18,65.81 155.57,66.42 155.57,66.72 v2(155.46,66.84) 155.28,66.66 153.79,66.66 153.77,66.64 151.34,66.64 151.06,66.92 149.27,66.92 149.05,67.15 148.52,67.15 147.67,68 145.23,68 144.76,68.47 144.36,68.47 143.41,69.42 142.87,69.42 142.32,69.97 141.75,69.97 v2(141.13,70.59)
  BOTTOM w0.109: v1(45.11,50.59) 47.36,48.34 47.36,40.5 51.11,36.75 100.19,36.75 103.23,39.79 117.64,39.79 118.59,40.74 152.38,40.74 156.57,44.93 156.98,44.93 158.27,46.21 158.27,47.62 159.44,48.8 160.65,48.8 162.47,50.62 162.47,52.25 163.53,53.31 164.51,53.31 165.25,54.04 166.04,54.04 166.77,54.77 166.77,57.7 166.26,58.21 166.26,66.92 v1(166.36,67.02) ; U400.DK37 140.87,70.34 v2(141.13,70.59) ; v1(25.35,48.89) 25.35,48.21 24.79,47.65 24.79,46.51 23.45,45.17 23.45,44.66 23.67,44.43 23.67,36.33 v1(23.09,35.75)
STRAP0: length 12.5
  BOTTOM w0.109: R6905.1 R6914.2 82.56,78.38 80.92,78.38 80.31,78.99 80.31,81.39 80.71,81.79 80.71,84.54 79.65,85.6 U6600.D1
STRAP1: length 12.5
  BOTTOM w0.109: U6600.D2 78,85.6 78.39,85.99 79.64,85.99 80.94,84.69 80.94,81.47 80.68,81.21 80.68,80.06 81.34,79.41 82.52,79.41 R6915.2 R6906.1
STRAP2: length 16.5
  BOTTOM w0.109: R6907.1 R6916.2 82.59,76.44 81.23,76.44 80.08,77.58 80.08,81.52 80.48,81.92 80.48,84.38 79.63,85.23 76.83,85.23 76.34,84.75 U6600.E4
STRAP3: length 15
  BOTTOM w0.109: U6600.E3 77.22,84.75 77.65,84.33 77.9,84.33 78.22,84.64 78.93,84.64 79.25,84.33 79.65,84.33 79.91,84.07 79.91,82.98 79.86,82.93 79.86,77.48 81.13,76.21 82.6,76.21 R6917.2 R6908.1
STRAP4: length 12
  BOTTOM w0.109: R6909.1 R6918.2 83.04,81.22 82.65,81.61 81.74,81.61 81.43,81.91 81.43,84.96 79.74,86.65 79.05,86.65 78.92,86.78 78.38,86.78 78.15,86.55 78.15,86.22 77.91,85.99 77.53,85.99 77.14,85.6 U6600.D3
STRAP5: length 11.6
  BOTTOM w0.109: U6600.C1 79.61,86.4 81.17,84.84 81.17,81.38 80.91,81.12 80.91,80.16 81.41,79.66 82.59,79.66 R6919.2 R6910.1
SUSCLK32_KBC: length 131.5
  TOP w0.076: U4700.L5 198.67,17.63 199.15,17.63 199.57,17.21
  TOP w0.109: v2(200.06,17.03) 199.75,17.03 199.57,17.21
  IN1 w0.079: v1(188.57,74.87) 187.7,74.01 187.7,73.48 186.19,71.96 182.35,71.96 180.7,70.32 179.13,70.32 177.87,69.06 177.19,69.06 177.11,68.98 177.11,68.35 176.74,67.98 175.46,67.98 174.94,67.46 174.94,65.91 174.39,65.36 173.1,65.36 172.88,65.14 171.83,65.14 171.48,64.79 v1(171.2,64.79) 170.31,64.79 170.07,64.55 169.19,64.55 168.49,65.25 167.71,65.25 167.49,65.02 167.09,65.02 166.13,65.98 163.45,65.98 163.05,65.58 162.34,65.58 162.19,65.42 161.38,65.42 160.68,64.73 159.05,64.73 158.56,64.23 156.74,64.23 156.1,64.88 152.72,64.88 152.29,65.3 149.06,65.3 147.44,66.92 v2(147.44,66.98)
  IN3 w0.089: v1(188.57,74.87) 188.57,77.37 185.25,80.69 184.98,80.69 184.77,80.78 184.45,81.1 184.45,81.63 v1(184.02,82.07) ; v2(200.06,17.03) 200.06,17.31 198.9,18.47 198.9,19.89 197.06,21.73 196.21,21.73 195.24,22.71 193.8,22.71 193.47,23.04 191.21,23.04 190.51,23.73 189.65,24.09 188.84,24.9 187.94,25.27 187.27,25.27 185.71,26.84 185.39,27.61 184.32,29.2 184.32,31.28 182.06,33.55 180.81,33.55 180.26,34.11 180.26,37.11 179.02,38.35 179.02,40.85 176.74,43.13 175.83,43.13 175.72,43.24 175.68,43.24 174.62,44.3 173.42,44.3 172.27,45.44 172.02,45.44 170.48,46.97 v1(169.99,46.97)
  BOTTOM w0.079: U400.DW41 145.14,67.92 146.4,67.92 147.34,66.98 v2(147.44,66.98)
  BOTTOM w0.109: v1(184.02,82.07) 184.45,81.63 R4131.1 ; v1(169.99,46.97) 170.43,47.41 170.43,48.08 170.3,48.21 170.3,50.85 170.1,51.05 170.1,55.56 v1(170.12,55.57) 170.12,59.44 171.2,60.52 v1(171.2,64.79)
SUSCLK32_KBC_WLAN: length 1.8
  BOTTOM w0.109: CON4100.50 184.84,80.26 184.45,80.64 R4131.2
SY127F_BST: length 4.2
  IN2 w0.254: v1(165.86,15.77) 165.86,15.8 165.73,15.92 165.73,17.45 v1(166.04,17.75)
  BOTTOM w0.254: PR8612.1 166.68,17.75 v1(166.04,17.75) ; PU8601.13 165.83,15.74 v1(165.86,15.77)
SY127F_BST_S: length 1.4
  BOTTOM w0.508: PR8612.2 168.36,17.27 169.1,17.27 PC8628.1
SY127F_BYP: length 9.6
  TOP w0.254: PR8620.2 170.67,12.03 172.03,10.67 v1(172.03,9.97)
  TOP w0.508: v1(166.9,10.71) 167.03,10.58 167.03,10.4 v1(167.34,10.09) 167.41,10.02 170.81,10.02 PC8635.2 170.97,9.97 v1(172.03,9.97)
  BOTTOM w0.203: PU8601.8 166.83,10.83 166.92,10.74 v1(166.9,10.71)
SY127F_EN: length 3.6
  BOTTOM w0.109: PR8619.2 PC8636.1 PR8621.1 168.93,10.46 168.55,10.46 168.1,10.92 167.97,10.97 167.84,11.06 167.73,11.16 PU8601.6
SY127F_FB: length 5.4
  TOP w0.109: PR8620.1 169.44,12.57 169.39,12.52 PR8622.2 169.38,12.06 169.38,11.47 169.29,11.38 168.78,11.38 168.47,11.06 PR8618.1 167.86,10.84 v1(167.67,10.65)
  BOTTOM w0.109: PU8601.7 167.28,11.1 167.67,10.71 v1(167.67,10.65)
SY127F_FB_S: length 1.6
  TOP w0.109: PC8635.1 170.38,10.85 170.37,10.84 PR8618.2
SY127F_LDOEN: length 3.3
  BOTTOM w0.109: PU8601.5 168.18,11.16 168.61,10.73 169.2,10.73 169.5,10.43 PR8616.1 170.03,10.43 170.48,9.98 PR8613.2
SY127F_LX: length 1.1
  TOP w0.254: v1(170.48,16.74) 170.69,16.53 PR8614.2
SY127F_PG: length 1.3
  BOTTOM w0.109: PR8617.2 169.44,12.04 169.15,12.33 PU8601.4
SY8386_FB: length 3
  TOP w0.254: PR9212.1 121.92,13.92 v1(121.67,13.67) 121.67,13.1 PC9218.2
  BOTTOM w0.254: PR9213.2 121.5,13.49 v1(121.67,13.67) 121.89,13.89 PU9200.10
SYS_RESET#: length 237.2
  TOP w0.109: v2(149.86,82.16) 150.11,81.91 150.11,81.81 150.57,81.35 R1526.2 ; v1(39,44.79) 38.89,44.91 38.89,46.45 37.99,47.35 37.99,48.74 37.3,49.43 37.3,52.33 37.51,52.55 38.84,52.55 C7701.2 40.4,50.98 CON7703.48
  IN1 w0.079: v1(39,44.79) 38.47,44.26 37.76,44.26 36.74,43.24 35.84,43.24 35.23,43.84 31,43.84 30.37,44.47 29.25,44.47 28.11,43.33 25.57,43.33 23.62,41.38 19.62,41.38 19.41,41.17 18.63,41.17 v1(18.15,40.69)
  IN2 w0.089: v2(138.64,81.44) 138.43,81.65 138.43,82.67 138.64,82.88 140.66,82.88 140.73,82.95 142.35,82.95 142.67,82.62 143.06,82.62 143.4,82.96 149.06,82.96 v2(149.86,82.16) 150,82.02 150,81.9 150.45,81.45 152.36,81.45 152.67,81.14 155.08,81.14 156.87,79.36 156.87,78.4 157.2,78.07 157.2,75.96 157.28,75.88 157.28,74.84 158.14,73.99 158.14,72.96 157.44,72.26 157.44,71.64 155.57,69.78 155.57,69.25 154.31,67.98 154.31,67.16 156.67,64.8 156.67,64.38 157.7,63.35 157.7,61.59 157.63,61.52 157.63,60.92 158.4,60.15 158.4,59.42 157.57,58.59 157.57,57.78 157.99,57.36 157.99,55.15 158.08,55.06 158.08,54.13 159.42,52.79 159.74,52.79 160.15,52.38 160.15,51.91 159.87,51.63 159.87,49.25 159.95,49.17 159.95,48.77 160.8,47.91 161.25,47.91 v1(161.51,47.65)
  BOTTOM w0.109: v1(161.51,47.65) 161.51,45.84 159.39,43.73 159.39,42.13 157.22,39.95 156.84,39.95 155.01,38.12 149.65,38.12 149.43,38.35 123.95,38.35 118.57,32.96 104.47,32.96 103.23,34.2 48.94,34.2 44.78,38.36 44.78,40.21 44.15,40.84 42.68,40.84 40.92,42.6 40.92,43.71 40.23,44.41 39.39,44.41 v1(39,44.79) ; v1(18.15,40.69) CON7700.13 ; U400.DD10 138.64,81.56 v2(138.64,81.44)
TACH_FAN2_IN_R: length 14
  BOTTOM w0.109: R5404.2 31.54,58.75 v1(31.47,58.82) 31.47,59.21 31.72,59.46 C5404.1 C5405.2 31.25,60.74 30.63,61.36 30.63,62.1 29.23,63.5 28.37,63.5 28.09,63.22 26.32,63.22 26.07,63.46 26.07,63.82 26.72,64.46 26.72,65.28 CON5400.2
TACH_FAN_IN: length 211.4
  TOP w0.076: U4700.E10 194.13,20.9 194.13,21.99 194.04,22.08 194.04,22.61 193.78,22.87 193.25,22.87
  TOP w0.109: v2(187.27,25.8) 187.35,25.73 189.38,25.73 v1(189.49,25.61) 189.49,25.41 192.04,22.87 193.25,22.87
  IN1 w0.079: v1(36.18,59.8) 37.07,59.8 37.51,59.37 37.51,58.51 v1(41.03,54.99)
  IN2 w0.089: v2(187.27,25.8) 186.82,25.8 186.06,26.57 184.75,29.72 184.74,29.77 184.74,31.07 182.07,33.74 182.07,34.7 180.47,36.3 180.47,37.12 178.98,38.6 176.77,38.6 176.69,38.68 176.69,43.84 174.98,45.55 172.38,45.55 171.35,46.59 169.73,46.59 169.58,46.74 169.58,49.27 v1(167.64,51.2)
  BOTTOM w0.109: v1(36.18,59.8) 35.94,59.8 35.91,59.77 C5403.1 34.92,59.18 34.8,59.05 R5403.2 34.54,59.33 34.36,59.51 33.91,59.51 33.14,58.75 R5404.1 ; v1(41.03,54.99) 40.92,54.87 40.92,52.43 46.37,46.98 46.37,38.93 49.57,35.74 100.61,35.74 103.68,38.81 118.08,38.81 119.02,39.75 153.84,39.75 157.03,42.93 158.05,42.93 158.33,43.21 158.33,43.95 159.26,44.88 159.26,47.21 159.85,47.81 161.06,47.81 162.64,49.39 166.2,49.39 167.08,48.51 167.74,48.51 167.97,48.74 167.97,49.5 167.64,49.83 v1(167.64,51.2)
TBT_CYPRE_INT: length 42
  TOP w0.109: v2(189.01,90.57) 189.01,88.58 188.82,88.39 187.35,88.39 187.04,88.08 186.74,88.08 185.27,86.61 185.27,84.02 184.55,83.31 184.55,82.17 184.9,81.82 185.66,81.82 v2(186,81.48) 185.75,81.23 185.57,81.23 185.28,81.52 184.51,81.52 184.25,81.25 183.6,81.25 182.24,82.61 182.24,83.21 181.83,83.61 180.74,83.61 180.16,83.03 177.85,83.03 v1(177.56,82.74) 176.98,82.16 172.69,82.16 169.98,84.87 169.12,84.87 v1(168.18,85.81)
  BOTTOM w0.109: v2(189.01,90.57) 189.25,90.82 R5923.2 ; v1(168.18,85.81) 168.18,85.37 169.2,84.35 169.2,82.74 168.76,82.3 168.68,82.3 167.96,81.58 CON7701.12 ; R6129.1 186.18,81.66 v2(186,81.48)
TBT_FORCE_PWR: length 126.7
  TOP w0.109: v1(145.77,55.46) 145.13,54.82 145.13,54.47 144.49,53.82 142.98,53.82 142.16,54.64 v1(142.16,54.84) R1501.1
  IN1 w0.079: v1(159.54,55.06) 159.79,55.06 160.17,54.67 160.41,54.67 160.66,54.92 162.03,54.92 163.4,56.29 164.88,56.29 165.53,55.65 169.47,55.65 v1(170.69,56.87)
  IN2 w0.089: v1(166.83,102.18) 166.7,102.18 166.33,102.55 165.3,102.55 164.86,102.11 164.86,95 163.56,93.7 163.56,88.82 165.38,87 165.38,84.17 165.86,83.69 165.86,82.55 v1(166.11,82.29) 167.27,81.14 167.27,74.57 168.15,73.7 168.15,72.26 169.1,71.3 169.1,69.69 168.9,69.49 168.9,66.93 169.12,66.71 169.12,64.3 170.05,63.37 170.05,57.51 v1(170.69,56.87)
  IN3 w0.089: v2(187.42,93.09) 187.42,92.78 186.47,91.83 184.16,91.83 183.54,91.21 183.54,90.03 183.13,89.62 181.61,89.62 181.36,89.86 180.77,89.86 180.56,90.08 179.95,90.08 179.65,90.38 179.65,91.14 179.75,91.24 179.75,92.81 179.28,93.27 178.04,93.27 177.75,93.56 173.21,93.56 171.45,95.33 171.45,97.2 166.83,101.83 v1(166.83,102.18)
  BOTTOM w0.079: U5900.B10 187.1,93.79 187.1,93.5 187.17,93.35 v2(187.42,93.09) 187.42,92.97 187.71,92.69
  BOTTOM w0.109: v1(166.11,82.29) 166.33,82.08 CON7701.13 ; v1(159.54,55.06) 159.28,55.06 158.6,54.38 157.16,54.38 156.57,54.97 154.25,54.97 153.94,55.28 150.16,55.28 149.74,55.7 147.67,55.7 147.25,55.28 145.95,55.28 v1(145.77,55.46) ; 187.71,92.69 187.78,92.62 187.86,92.43 188.03,92.25 188.66,92.25 189.03,92.56 189.15,92.61 189.32,92.61 189.47,92.54 189.97,92.04 R5930.1 190.36,91.74 190.37,91.73 R5929.1 190.72,91.75 192.27,91.75 192.49,91.52 192.95,91.22 193.65,90.52 194.08,90.52 R6102.2
TBT_FORCE_PWR_GPPA23: length 13.8
  TOP w0.109: R1501.2 142.16,56.88 141.76,57.28 141.76,57.81 141.53,58.03 141.53,59.34 v1(141.67,59.47) 141.86,59.66 141.86,60.38 142.44,60.96 142.44,61.24 141.74,61.94 141.74,62.03 139.72,64.04 139.72,66.23 139.23,66.72 139.23,67.65 v2(139.41,67.83)
  BOTTOM w0.109: U400.DG41 139.57,67.99 v2(139.41,67.83)
TBT_LSX0_RXD: length 90
  TOP w0.109: v2(146.68,84.78) 146.68,84.97 147.28,85.57 148.21,85.57 150.2,83.58 150.38,83.58 150.68,83.28 152.72,83.28 153.07,82.92 155.4,82.92 155.75,82.58 R1215.1 R1207.2
  IN2 w0.089: v1(147.11,90.86) 146.89,90.86 145.43,89.4 145.43,88.38 146.68,87.13 146.68,86.88 146.59,86.78 146,86.78 145.92,86.71 145.92,86.53 146.02,86.43 146.6,86.43 146.68,86.35 v2(146.68,84.78) ; v2(147.27,100.35) 147.27,100.53 146.51,101.29 145.36,101.29 144.73,101.93 144.73,103.07 145.08,103.43 153.26,103.43 153.35,103.34 153.35,102.96 153.44,102.87 153.62,102.87 153.71,102.96 153.71,103.34 153.8,103.43 153.97,103.43 154.06,103.34 154.06,102.96 154.15,102.87 154.33,102.87 154.42,102.96 154.42,103.34 154.51,103.43 154.69,103.43 154.77,103.34 154.77,102.96 154.86,102.87 155.04,102.87 155.13,102.96 155.13,103.34 155.22,103.43 155.4,103.43 155.49,103.34 155.49,102.96 155.57,102.87 155.75,102.87 155.94,103.06 155.94,103.21 156.16,103.43 162.61,103.43 163.68,104.49 165.71,104.49 166.74,103.46 168.39,103.46 v1(168.83,103.02)
  IN3 w0.089: v1(168.83,103.02) 169.29,103.02 171.26,104.99 171.61,104.99 171.85,105.23 172.3,105.23 172.54,104.99 172.55,104.99 172.74,104.8 173.91,104.8 175.31,103.4 177.99,103.4 181.26,100.13 184.58,100.13 v2(184.81,99.9)
  BOTTOM w0.109: R5917.1 184.76,101.75 184.76,99.95 v2(184.81,99.9) 185.27,99.44 185.27,98.38 U5900.L7 ; v2(147.27,100.35) 147.27,99.61 146.89,99.23 146.89,98.7 v1(146.51,98.32) 146.89,97.94 146.89,97.36 147.04,97.2 147.04,92.48 147.15,92.37 147.15,91.91 147.42,91.64 147.42,91.17 v1(147.11,90.86) ; v2(146.68,84.78) 146.68,84.58 145.26,83.16 144.74,83.16 U400.DV8
TBT_LSX0_TXD: length 80.3
  TOP w0.109: v1(186.1,78.18) 185.63,78.66 171.51,78.66 171.26,78.41 170.4,78.41 167.54,81.27 164.9,81.27 v1(164.19,81.98) 163.88,82.29 161.02,82.29 160.62,81.9 157.89,81.9 156.64,83.15 153.17,83.15 152.81,83.51 150.8,83.51 150.51,83.8 150.31,83.8 148.24,85.87 147.02,85.87 144.63,83.48 143.64,83.48 v2(143.63,83.48)
  IN2 w0.089: v2(185.37,99.95) 185.37,99.16 186.28,98.24 186.92,98.24 187.86,97.31 188.44,97.31 188.72,97.03 188.72,94.49 189.48,93.72 189.48,92.68 188.02,91.22 188.02,90.42 188.07,90.36 188.07,88.4 187.51,87.84 187.51,85.05 187.24,84.77 186.37,84.77 184.66,83.06 184.66,82.01 185.42,81.25 185.42,78.87 v1(186.1,78.18)
  BOTTOM w0.109: v2(185.37,99.95) 185.37,100.07 185.04,100.4 185.04,103.24 R5915.1 ; U400.DU8 143.95,83.17 143.64,83.48 v2(143.63,83.48) ; U5900.M7 185.5,99.82
  BOTTOM w0.115: 185.5,99.82 v2(185.37,99.95)
TBT_LSX1_RXD: length 17.4
  TOP w0.109: R1208.2 R1216.1 149.27,77.71 149.08,77.52 148.15,77.52 v1(148.15,77.53) 147.93,77.75 147.57,77.75 147.21,78.1 145.08,78.1 143.38,79.8 142.68,79.8 142.44,80.03 140.79,80.03 140.68,80.14 139.64,80.14 139.57,80.21 138.99,80.21 138.61,80.59 138.61,80.84 138.23,81.21 138.23,81.88 138.44,82.1 138.44,82.65 139.08,83.29 v2(139.24,83.29)
  BOTTOM w0.079: v2(139.24,83.29) 139.02,83.29 138.54,83.77 U400.DD6
TBT_LSX2_RXD: length 9.9
  TOP w0.109: v2(141.22,76.05) 141.58,75.69 143.34,75.69 143.36,75.7 146.39,75.7 146.58,75.51 v1(147.93,75.51) 148.41,75.51 148.67,75.77 R1217.1 149.41,75.77 149.47,75.72 R1209.2
  BOTTOM w0.109: U400.DM23 141.52,76.35 v2(141.22,76.05)
TBT_LSX3_RXD: length 10.7
  TOP w0.109: R1210.2 150.09,76.55 R1218.1 148.41,76.55 148.21,76.35 146.68,76.35 146.48,76.15 144.74,76.15 143.88,77.01 142.84,77.01 v2(141.88,76.05)
  BOTTOM w0.109: U400.DN21 142.17,77.25 141.88,76.96 v2(141.88,76.05)
TBT_MRESET: length 4.1
  TOP w0.076: U4700.F5 v2(195.44,16.99)
  BOTTOM w0.076: R4742.1 196.74,15.34 196.77,15.36 196.77,15.8 196.64,15.92 196.64,16.96 196.26,17.35 195.79,17.35 v2(195.44,16.99)
TBT_PD_I2C_SCL: length 59.8
  TOP w0.109: v2(188.73,92.83) 188.61,92.95 188.12,93.15 188.06,93.22 187.88,93.64 187.88,94.77 187.72,94.93 R5919.2 ; R6108.1 167.01,85.2 v1(167.57,84.63) v1(168.3,83.91) 168.71,83.5 169.49,83.5 171.98,81.02 179.79,81.02 180.76,81.99 181.83,81.99 183.39,80.43 187.49,80.43 187.75,80.69 187.75,81.35 188.14,81.73 188.8,81.73 189.13,82.07 189.13,82.75 188.85,83.03 188.85,83.64 189.05,83.84 189.71,83.84 191.68,81.88 v2(191.68,81.34)
  IN3 w0.089: v2(191.68,81.34) 192.21,81.88 192.85,81.88 193.74,82.77 193.74,87.45 193.24,87.96 190.45,87.96 189.69,88.72 189.69,91.23 188.73,92.19 v2(188.73,92.83)
  BOTTOM w0.102: U6100.29 191.81,81.47 v2(191.68,81.34)
  BOTTOM w0.109: CON7701.10 166.21,80.58 165.38,81.4 165.38,83.5 166.05,84.17 167.11,84.17 v1(167.57,84.63)
TBT_PD_I2C_SDA: length 64.1
  TOP w0.109: R6107.1 165.4,85.19 165.94,85.73 v1(166.9,85.73) 167.51,85.12 167.81,85.12 168.66,84.27 169.04,84.27 169.85,83.46 v1(170.2,83.46) 170.77,83.46 172.51,81.73 178.92,81.73 179.58,82.38 180.15,82.38 180.31,82.22 181.93,82.22 183.49,80.66 187.39,80.66 187.53,80.8 187.53,81.46 188.03,81.96 188.69,81.96 188.9,82.17 188.9,82.66 188.62,82.94 188.62,83.73 188.96,84.07 189.81,84.07 192.22,81.65 v2(192.22,81.34) ; v2(188.19,92.7) 187.92,92.97 187.79,93.29 187.53,93.54 R5921.2
  IN3 w0.089: v2(188.19,92.7) 188.19,92.44 189.48,91.15 189.48,88.63 190.36,87.75 193.15,87.75 193.54,87.37 193.54,82.86 192.74,82.07 191.79,82.07 191.31,81.58 191.31,81.15 191.49,80.97 191.89,80.97 192.22,81.3 v2(192.22,81.34)
  BOTTOM w0.102: v2(192.22,81.34) 192.21,81.35 U6100.28
  BOTTOM w0.109: v1(166.9,85.73) 167.39,85.24 167.66,85.24 168.08,84.82 168.08,84.52 167.27,83.7 165.91,83.7 165.61,83.41 165.61,81.5 166.03,81.08 CON7701.11
TBTA_I2C_INT#_R: length 4
  BOTTOM w0.079: U5900.A10 186.93,93.5 186.98,93.38 186.98,93 187.26,92.72 187.35,92.72 187.48,92.59
  BOTTOM w0.109: 187.48,92.59 187.58,92.49 187.66,92.29 187.93,92.02 189.08,92.02 v1(189.23,92.17) 189.25,92.15 R5923.1
TBTA_I2C_SCL_R: length 1.1
  TOP w0.109: R5919.1 186.9,94.48 v2(186.89,94.47)
  BOTTOM w0.079: v2(186.89,94.47) 186.57,94.79 U5900.C9
TBTA_I2C_SDA_R: length 2
  TOP w0.079: v2(185.6,95.11) 185.96,94.75 185.96,94.1 186.06,93.99 R5921.1
  BOTTOM w0.079: U5900.E7 v2(185.6,95.11)
TBTA_SSRX1_N: length 6.7
  BOTTOM w0.079: U5900.J11 187.44,97.13 arc(187.55,97.05) 187.68,97.03 187.89,97.03 arc(187.96,97.04) 188.03,97.09 188.07,97.13 arc(188.17,97.2) 188.29,97.22 188.49,97.22 188.52,97.19 188.54,97.19
  BOTTOM w0.109: 188.54,97.19 188.78,97.19 arc(188.92,97.21) 189.04,97.29 189.31,97.56 arc(189.38,97.67) 189.41,97.8 189.41,98.25 arc(189.42,98.31) 189.45,98.35 191.18,100.09 arc(191.29,100.13) 191.4,100.09 191.59,99.89 arc(191.69,99.81) 191.81,99.76 arc(191.89,99.74) 191.98,99.74 R5902.1
TBTA_SSRX1_N_C: length 20
  TOP w0.109: v2(192.99,100.31) 192.99,100.32 arc(192.85,100.51) 192.79,100.74 arc(192.79,100.8) 192.82,100.85 192.83,100.87 arc(193.19,101.14) 193.63,101.24 195.32,101.24 arc(195.39,101.24) 195.46,101.25 arc(195.75,101.3) 196.04,101.37 arc(199.3,102.65) 202.27,104.5 arc(202.34,104.55) 202.4,104.61 205.44,107.65 arc(205.83,108.23) 205.96,108.9 205.96,109.2 arc(206.06,109.34) 206.23,109.31 D5907.1 206.58,109 arc(206.71,109.09) 206.8,109.22 206.85,109.34 arc(206.9,109.4) 206.97,109.42 207.26,109.42 arc(207.31,109.41) 207.35,109.39 arc(207.38,109.34) 207.39,109.28 C6309.2
  BOTTOM w0.109: v2(192.99,100.31) 192.8,100.11 arc(192.72,100) 192.7,99.87 R5955.2
TBTA_SSRX1_P: length 6.8
  BOTTOM w0.079: U5900.J12 187.71,97.24 arc(187.61,97.3) 187.63,97.42 arc(187.67,97.45) 187.73,97.46 187.93,97.46 arc(187.98,97.45) 188.02,97.43 188.03,97.41 arc(188.07,97.39) 188.12,97.38 188.49,97.38 188.52,97.41 188.54,97.41
  BOTTOM w0.109: R5900.1 192.03,100.88 arc(191.83,100.84) 191.65,100.72 191.37,100.44 arc(191.29,100.38) 191.21,100.35 arc(191.12,100.32) 191.04,100.26 189.29,98.51 arc(189.21,98.39) 189.18,98.25 189.18,97.8 arc(189.17,97.76) 189.15,97.72 188.88,97.45 arc(188.83,97.42) 188.78,97.41 188.54,97.41
TBTA_SSRX1_P_C: length 20
  TOP w0.109: C6308.2 207.3,109.71 arc(207.23,109.66) 207.14,109.64 206.89,109.64 arc(206.79,109.67) 206.69,109.73 D5906.1 206.31,109.61 arc(206.27,109.59) 206.23,109.58 206.12,109.58 arc(205.85,109.47) 205.74,109.2 205.74,108.9 arc(205.62,108.31) 205.29,107.81 205.06,107.59 arc(205.06,107.58) 205.06,107.58 202.24,104.76 arc(202.2,104.73) 202.16,104.69 arc(202.15,104.68) 202.14,104.68 arc(199.2,102.85) 195.98,101.59 arc(195.7,101.52) 195.43,101.47 arc(195.37,101.47) 195.32,101.47 193.63,101.47 arc(193.09,101.35) 192.66,101.01 192.65,100.99 arc(192.58,100.88) 192.56,100.76 arc(192.56,100.76) 192.56,100.76 192.56,100.64 arc(192.54,100.52) 192.47,100.42 v2(192.35,100.3)
  BOTTOM w0.109: v2(192.35,100.3) 192.62,100.57 arc(192.68,100.66) 192.7,100.75 R5953.2
TBTA_SSRX2_N: length 4.9
  BOTTOM w0.079: U5900.C11 187.44,94.37 arc(187.55,94.29) 187.68,94.27 187.87,94.27 arc(187.96,94.29) 188.04,94.34 188.06,94.36 arc(188.11,94.39) 188.16,94.42 arc(188.19,94.44) 188.23,94.44 188.69,94.44 188.69,94.42 188.7,94.41 188.72,94.41
  BOTTOM w0.109: 188.72,94.41 188.88,94.41 arc(189.09,94.36) 189.26,94.22 arc(189.42,93.95) 189.5,93.65 arc(189.51,93.6) 189.51,93.56 arc(189.55,93.42) 189.63,93.31 189.83,93.1 arc(189.95,93.02) 190.09,92.99 arc(190.24,92.96) 190.36,92.87 190.58,92.65 arc(190.72,92.56) 190.9,92.52 R5906.1
TBTA_SSRX2_N_C: length 22.4
  TOP w0.109: v2(191.25,93.08) 191.34,93.17 arc(191.37,93.21) 191.4,93.26 arc(191.41,93.3) 191.41,93.34 191.41,93.41 arc(191.54,93.72) 191.85,93.85 192.56,93.85 arc(192.67,93.87) 192.76,93.93 192.84,94.01 arc(193,94.12) 193.2,94.16 193.42,94.16 arc(193.79,94.23) 194.11,94.44 194.34,94.67 arc(194.41,94.78) 194.43,94.9 194.43,95.48 arc(194.62,96.39) 195.13,97.16 195.42,97.45 arc(195.54,97.63) 195.58,97.83 195.58,98.4 arc(195.66,98.83) 195.91,99.2 196.7,99.99 arc(197.07,100.24) 197.51,100.32 197.68,100.32 arc(197.8,100.35) 197.9,100.42 197.92,100.43 arc(201.55,102.27) 205.5,103.26 arc(205.76,103.34) 205.97,103.5 D5903.1 206.29,103.37 arc(206.43,103.28) 206.59,103.25 arc(206.73,103.22) 206.85,103.14 arc(206.96,103.07) 207.1,103.04 207.13,103.04 arc(207.23,103.06) 207.31,103.11 C6313.2
  BOTTOM w0.109: v2(191.25,93.08) 191.54,92.8 arc(191.59,92.73) 191.61,92.64 R5906.2
TBTA_SSRX2_P: length 4.9
  BOTTOM w0.079: U5900.C12 187.67,94.48 arc(187.56,94.58) 187.67,94.69 187.83,94.69 arc(187.9,94.69) 187.97,94.67 188.05,94.64 arc(188.09,94.63) 188.14,94.61 arc(188.15,94.6) 188.16,94.6 188.63,94.6 arc(188.66,94.6) 188.69,94.62 188.7,94.63 188.72,94.63
  BOTTOM w0.109: R5905.1 190.88,93.66 arc(190.71,93.63) 190.56,93.53 190.29,93.26 arc(190.24,93.23) 190.19,93.21 arc(190.18,93.21) 190.16,93.21 190.11,93.21 arc(190.05,93.23) 189.99,93.26 189.79,93.47 arc(189.75,93.52) 189.74,93.58 arc(189.73,93.63) 189.72,93.68 arc(189.62,94.04) 189.44,94.35 arc(189.19,94.56) 188.88,94.63 188.72,94.63
TBTA_SSRX2_P_C: length 22.4
  TOP w0.109: C6312.2 207.39,102.65 arc(207.38,102.71) 207.35,102.76 207.33,102.77 arc(207.28,102.81) 207.22,102.82 207.1,102.82 arc(206.9,102.85) 206.72,102.95 arc(206.63,103) 206.53,103.02 206.46,103.02 arc(206.42,103.01) 206.38,102.99 D5902.1 205.79,102.96 arc(205.67,103.03) 205.53,103.04 arc(201.64,102.07) 198.06,100.26 arc(197.89,100.14) 197.68,100.1 197.51,100.1 arc(197.16,100.03) 196.86,99.83 196.07,99.04 arc(195.87,98.74) 195.8,98.4 195.8,97.83 arc(195.74,97.54) 195.58,97.29 195.29,97.01 arc(194.82,96.31) 194.66,95.48 194.66,94.9 arc(194.62,94.69) 194.5,94.51 194.27,94.28 arc(193.88,94.02) 193.42,93.93 193.2,93.93 arc(193.09,93.91) 193,93.85 192.92,93.77 arc(192.75,93.66) 192.56,93.62 191.85,93.62 arc(191.7,93.56) 191.64,93.41 191.64,93.29 arc(191.64,93.24) 191.67,93.21 191.7,93.18 arc(191.79,93.12) v2(191.9,93.1)
  BOTTOM w0.109: R5961.2 191.61,93.64 arc(191.65,93.41) 191.78,93.22 v2(191.9,93.1)
TBTA_SSTX1_N: length 5.1
  BOTTOM w0.079: U5900.G11 187.48,96.18 arc(187.56,96.12) 187.67,96.1 187.85,96.1 arc(187.94,96.11) 188.01,96.17 188.05,96.2 arc(188.14,96.26) 188.24,96.28 188.97,96.28 arc(189.11,96.3) 189.22,96.38 189.27,96.43 arc(189.29,96.44) 189.31,96.45 arc(189.32,96.45) 189.34,96.46
  BOTTOM w0.109: R5904.1 190.78,97.75 arc(190.74,97.76) 190.7,97.79 190.45,98.04 arc(190.36,98.07) 190.28,98.02 arc(190.2,97.85) 190.15,97.66 arc(190.02,97.23) 189.75,96.87 189.38,96.49 arc(189.36,96.47) 189.34,96.46
TBTA_SSTX1_N_C: length 25.3
  TOP w0.109: C6311.2 207.77,111.95 arc(207.75,112.02) 207.69,112.06 207.67,112.06 207.41,112.06 arc(207.33,112.05) 207.26,112 D5905.1 206.83,111.82 arc(206.79,111.86) 206.76,111.9 arc(206.72,111.95) 206.68,111.98 arc(206.63,112.01) 206.58,112.01 arc(206.52,112) 206.45,111.99 206.44,111.99 arc(206.28,111.96) 206.15,111.86 206.02,111.73 arc(205.7,111.25) 205.58,110.68 205.58,110.43 arc(205.55,110.29) 205.48,110.17 arc(205.47,110.17) 205.47,110.17 205.37,110.07 arc(205.23,109.86) 205.18,109.61 205.18,108.88 arc(205.16,108.75) 205.12,108.61 arc(205.08,108.53) 205.01,108.46 201.61,105.05 arc(201.56,105.01) 201.52,104.97 arc(197.75,102.78) 193.47,101.98 arc(193.23,101.96) 193,101.89 arc(192.78,101.8) 192.57,101.7 arc(192.53,101.67) 192.49,101.63 191.54,100.68 arc(191.42,100.51) 191.38,100.3 191.38,100.15 arc(191.39,100.06) 191.42,99.98 191.67,99.35 arc(191.7,99.26) 191.71,99.16 191.71,98.64 arc(191.73,98.53) 191.8,98.43 v2(191.9,98.33)
  BOTTOM w0.109: R5904.2 191.61,97.89 arc(191.63,98.02) 191.71,98.13 v2(191.9,98.33)
TBTA_SSTX1_P: length 5.1
  BOTTOM w0.079: 189.18,96.61 189.17,96.6 189.17,96.55 189.11,96.49 arc(189.04,96.45) 188.97,96.44 188.17,96.44 arc(188.09,96.45) 188.02,96.48 arc(187.95,96.52) 187.87,96.53 187.75,96.53 arc(187.69,96.52) 187.63,96.48 arc(187.61,96.43) 187.63,96.37 187.64,96.37 arc(187.7,96.33) 187.76,96.32 U5900.G12
  BOTTOM w0.109: 189.18,96.61 189.6,97.02 arc(189.82,97.33) 189.93,97.7 arc(189.98,97.92) 190.08,98.13 arc(190.09,98.15) 190.1,98.16 190.1,98.16 arc(190.17,98.27) 190.26,98.37 190.3,98.41 190.5,98.61 arc(190.54,98.64) 190.59,98.67 arc(190.86,98.81) R5903.1
